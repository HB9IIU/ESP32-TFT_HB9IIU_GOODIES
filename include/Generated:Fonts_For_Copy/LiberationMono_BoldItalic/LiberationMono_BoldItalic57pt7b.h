#ifndef _LIBERATIONMONO_BOLDITALIC57PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x3F, 0xCF, 0xE0, 0xFF, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x8E, 0x7F, 0xC0, 0x7F,
  0x87, 0x1F, 0xF0, 0x7F, 0x83, 0x87, 0xF8, 0x3F, 0x83, 0x83, 0xFC, 0x1F,
  0xC1, 0xC1, 0xC0, 0x0F, 0xE0, 0xE0, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x03,
  0xFC, 0x38, 0x00, 0x01, 0xFF, 0xB8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x00, 0x3C, 0x3F,
  0xE0, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x0E, 0x07, 0xF0, 0x1C, 0x07, 0x03,
  0xF8, 0xFF, 0x03, 0x81, 0xFC, 0x7F, 0x83, 0xC1, 0xFE, 0x3F, 0xC1, 0xC0,
  0xFE, 0x1F, 0xF0, 0xE0, 0xFF, 0x07, 0xFE, 0x71, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xFC,
  0x00, 0x7C, 0x07, 0xE3, 0xF0, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0xFC, 0x7C, 0x00, 0x03, 0xFF, 0xE3, 0xE0, 0x00, 0x0F,
  0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x01, 0xF1, 0xFF,
  0xF0, 0x00, 0x0F, 0x8F, 0xFF, 0xC0, 0x00, 0x3C, 0x3F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x0F, 0xC7, 0xC0, 0x3E, 0x00,
  0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x80,
  0x7F, 0xFC, 0x03, 0xF0, 0x7F, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0x01, 0xF8,
  0x7F, 0x9F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF8, 0xFC,
  0x3F, 0x81, 0xFE, 0x7E, 0x1F, 0xC0, 0x7F, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF,
  0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xF8, 0x7F, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x3F, 0xCF,
  0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x60, 0xF8, 0x73, 0xE7, 0xE7, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0xC1, 0xFC, 0x3F, 0x83, 0xE0, 0xFC, 0x07, 0x01, 0xC0, 0x08, 0x04,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0xDF,
  0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xEF, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xCF, 0xC7, 0xF9, 0xFE, 0x3F, 0x1F, 0xE7,
  0xF8, 0xFC, 0x7F, 0x9F, 0xE3, 0xF1, 0xFE, 0x7F, 0x8F, 0xC7, 0xF9, 0xFE,
  0x7F, 0x3F, 0xC7, 0xF1, 0xF8, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xEF, 0xF0, 0x07, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x10, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFD, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x83, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x03, 0xFB, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE,
  0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xE0, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xC0,
  0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF0,
  0x3C, 0x0F, 0xF3, 0xDE, 0x07, 0x03, 0xFE, 0x7B, 0xC1, 0xE0, 0xF8, 0xFE,
  0x78, 0x38, 0x3C, 0x1F, 0xCF, 0x0F, 0x0F, 0x01, 0xF1, 0xE1, 0xE1, 0xE0,
  0x3E, 0x3C, 0x78, 0x78, 0x0F, 0xC7, 0x8F, 0x1F, 0x01, 0xF0, 0xE1, 0xE3,
  0xC0, 0x3E, 0x3C, 0x78, 0xF8, 0x07, 0x87, 0x8F, 0x1E, 0x01, 0xF0, 0xF1,
  0xE3, 0xC0, 0x3E, 0x1C, 0x38, 0xF8, 0x07, 0x83, 0x8F, 0x1E, 0x01, 0xF0,
  0xF1, 0xE3, 0xC0, 0x3C, 0x1E, 0x3C, 0xF8, 0x07, 0x83, 0x87, 0x9F, 0x01,
  0xF0, 0xF0, 0xE3, 0xC0, 0x3C, 0x1C, 0x1C, 0x78, 0x0F, 0x87, 0x87, 0x8F,
  0x01, 0xF0, 0xE0, 0xF1, 0xE0, 0x7C, 0x3C, 0x1E, 0x3C, 0x1F, 0x87, 0x03,
  0xC7, 0xC7, 0x71, 0xC0, 0x78, 0x7F, 0xCF, 0xF0, 0x0F, 0x0F, 0xF1, 0xFC,
  0x01, 0xE0, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0xF8, 0x1F, 0xE0, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x07,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0xF3, 0xFC, 0x0F,
  0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0x9F, 0xE0, 0xFF,
  0xFF, 0x7F, 0xC1, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xF9, 0xFF, 0x00, 0x07,
  0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1C, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xFF, 0xC0, 0x7E, 0xF8, 0x3E, 0xFC,
  0x07, 0xEF, 0xC3, 0xEF, 0xC0, 0x7E, 0xFC, 0x7F, 0xFC, 0x07, 0xEF, 0xC7,
  0xDF, 0x80, 0x7E, 0xFC, 0xFD, 0xF8, 0x0F, 0xCF, 0xCF, 0x9F, 0x80, 0xFC,
  0xFC, 0xF9, 0xF8, 0x0F, 0xCF, 0xDF, 0x3F, 0x80, 0xFC, 0xFD, 0xF3, 0xF0,
  0x0F, 0xCF, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0xE3, 0xF0, 0x1F, 0x87, 0xFE,
  0x3F, 0x01, 0xF8, 0x7F, 0xC3, 0xF0, 0x1F, 0x87, 0xFC, 0x7F, 0x01, 0xF8,
  0x7F, 0x87, 0xE0, 0x3F, 0x87, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x83, 0xFC, 0x07, 0xEF, 0xE0,
  0xFE, 0x01, 0xFB, 0xF8, 0x3F, 0x80, 0xFE, 0x7E, 0x0F, 0xE0, 0x3F, 0x9F,
  0x83, 0xF8, 0x0F, 0xE7, 0xF1, 0xFE, 0x03, 0xF9, 0xFC, 0x7F, 0x00, 0xFE,
  0x7F, 0x1F, 0xC0, 0x7F, 0x9F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF1, 0xFC, 0x07,
  0xF0, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xBF, 0xC0, 0x7F, 0x0F, 0xEF, 0xE0,
  0x3F, 0xC3, 0xFB, 0xF8, 0x0F, 0xE0, 0x7E, 0xFE, 0x03, 0xF8, 0x1F, 0xBF,
  0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x00,
  0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xF8,
  0x03, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0,
  0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0xFF, 0x0F, 0xC0, 0x7F, 0x1F, 0xF1, 0xFC, 0x07, 0xE1, 0xFF, 0x1F,
  0xC0, 0x7E, 0x3F, 0xF1, 0xF8, 0x07, 0xE3, 0xFF, 0x3F, 0x80, 0x7E, 0x7F,
  0xF3, 0xF0, 0x07, 0xE7, 0xDF, 0x3F, 0x00, 0x7E, 0xFD, 0xF7, 0xF0, 0x0F,
  0xEF, 0x9F, 0x7E, 0x00, 0xFF, 0xF9, 0xF7, 0xE0, 0x0F, 0xFF, 0x1F, 0x7E,
  0x00, 0xFD, 0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF8, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0xC0, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x80, 0x7F,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3,
  0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xCF, 0xFF, 0xE0, 0x7F, 0x9F, 0xFF, 0x00, 0xFF, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xFE, 0x3F,
  0xC0, 0x0F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x07,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x1F, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x1F,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x9F,
  0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFC, 0xFE, 0x00,
  0x3F, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE1, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF,
  0xC0, 0xFF, 0x3F, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xF7, 0x87, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x7E, 0x7F, 0x07, 0xF8, 0x0F, 0x9F,
  0xF3, 0xFF, 0x03, 0xF7, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xDF, 0xFE, 0x0F,
  0xF1, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0xF0, 0x1F, 0xE3, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFD, 0xE1, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0x1F,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE3, 0xFC,
  0x03, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xFE, 0x1F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xF8,
  0x07, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0xC3, 0xFC,
  0x3F, 0xFE, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0x07, 0xFB, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x04, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xBF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFC, 0x7F, 0x00, 0xFF,
  0xC1, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x07,
  0xE1, 0xFF, 0x0F, 0xC0, 0xFC, 0x3F, 0xE1, 0xF8, 0x1F, 0x8F, 0xFC, 0x3E,
  0x03, 0xF1, 0xFF, 0x8F, 0xC0, 0x7E, 0x7D, 0xF1, 0xF8, 0x0F, 0xCF, 0x9E,
  0x7E, 0x01, 0xF3, 0xE3, 0xEF, 0xC0, 0x3E, 0x7C, 0x7D, 0xF8, 0x07, 0xDF,
  0x0F, 0xBE, 0x00, 0xFB, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x17, 0xFF, 0xFE, 0x03, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEE, 0x01, 0xFF, 0xFF,
  0xA0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
};

const GFXglyph LiberationMono_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 16, 38, 34, 10, -38 },
  { 77, 22, 18, 34, 10, -41 },
  { 127, 34, 38, 34, 1, -38 },
  { 289, 33, 48, 34, 1, -43 },
  { 487, 38, 40, 34, -1, -39 },
  { 677, 33, 39, 34, -1, -38 },
  { 838, 10, 18, 34, 16, -41 },
  { 861, 23, 53, 34, 8, -41 },
  { 1014, 23, 53, 34, 3, -41 },
  { 1167, 22, 21, 34, 9, -41 },
  { 1225, 28, 28, 34, 3, -33 },
  { 1323, 17, 18, 34, 2, -8 },
  { 1362, 18, 7, 34, 8, -18 },
  { 1378, 10, 8, 34, 10, -8 },
  { 1388, 38, 42, 34, -1, -41 },
  { 1588, 30, 40, 34, 3, -39 },
  { 1738, 29, 38, 34, 1, -38 },
  { 1876, 33, 39, 34, 0, -39 },
  { 2037, 31, 40, 34, 2, -39 },
  { 2192, 31, 38, 34, 1, -38 },
  { 2340, 31, 39, 34, 2, -38 },
  { 2492, 29, 40, 34, 4, -39 },
  { 2637, 29, 38, 34, 6, -38 },
  { 2775, 31, 40, 34, 2, -39 },
  { 2930, 29, 40, 34, 3, -39 },
  { 3075, 14, 30, 34, 10, -30 },
  { 3128, 20, 40, 34, 4, -30 },
  { 3228, 28, 31, 34, 3, -34 },
  { 3337, 28, 21, 34, 3, -30 },
  { 3411, 28, 31, 34, 3, -34 },
  { 3520, 30, 39, 34, 4, -39 },
  { 3667, 35, 49, 34, 0, -41 },
  { 3882, 34, 38, 34, -3, -38 },
  { 4044, 33, 38, 34, 1, -38 },
  { 4201, 32, 40, 34, 2, -39 },
  { 4361, 32, 38, 34, 1, -38 },
  { 4513, 34, 38, 34, 1, -38 },
  { 4675, 33, 38, 34, 2, -38 },
  { 4832, 31, 40, 34, 2, -39 },
  { 4987, 34, 38, 34, 1, -38 },
  { 5149, 33, 38, 34, 1, -38 },
  { 5306, 31, 39, 34, 2, -38 },
  { 5458, 37, 38, 34, 1, -38 },
  { 5634, 27, 38, 34, 3, -38 },
  { 5763, 36, 38, 34, 0, -38 },
  { 5934, 34, 38, 34, 1, -38 },
  { 6096, 32, 40, 34, 2, -39 },
  { 6256, 33, 38, 34, 1, -38 },
  { 6413, 32, 50, 34, 2, -39 },
  { 6613, 34, 38, 34, 1, -38 },
  { 6775, 34, 40, 34, 0, -39 },
  { 6945, 32, 38, 34, 5, -38 },
  { 7097, 32, 39, 34, 3, -38 },
  { 7253, 35, 38, 34, 4, -38 },
  { 7420, 36, 38, 34, 3, -38 },
  { 7591, 40, 38, 34, -3, -38 },
  { 7781, 34, 38, 34, 4, -38 },
  { 7943, 36, 38, 34, -1, -38 },
  { 8114, 27, 53, 34, 5, -41 },
  { 8293, 21, 42, 34, 8, -41 },
  { 8404, 27, 53, 34, 2, -41 },
  { 8583, 31, 25, 34, 1, -39 },
  { 8680, 35, 3, 34, -4, 3 },
  { 8694, 14, 8, 34, 14, -41 },
  { 8708, 30, 32, 34, 1, -31 },
  { 8828, 31, 42, 34, 1, -41 },
  { 8991, 29, 32, 34, 3, -31 },
  { 9107, 33, 42, 34, 2, -41 },
  { 9281, 30, 32, 34, 2, -31 },
  { 9401, 31, 42, 34, 5, -42 },
  { 9564, 33, 43, 34, 1, -31 },
  { 9742, 31, 41, 34, 1, -41 },
  { 9901, 30, 41, 34, 0, -41 },
  { 10055, 31, 53, 34, -2, -41 },
  { 10261, 33, 41, 34, 2, -41 },
  { 10431, 30, 41, 34, 0, -41 },
  { 10585, 35, 31, 34, -1, -31 },
  { 10721, 31, 31, 34, 1, -31 },
  { 10842, 30, 32, 34, 2, -31 },
  { 10962, 33, 43, 34, -1, -31 },
  { 11140, 31, 43, 34, 2, -31 },
  { 11307, 29, 31, 34, 4, -31 },
  { 11420, 30, 32, 34, 2, -31 },
  { 11540, 25, 39, 34, 6, -38 },
  { 11662, 30, 31, 34, 3, -30 },
  { 11779, 32, 30, 34, 4, -30 },
  { 11899, 35, 30, 34, 2, -30 },
  { 12031, 37, 30, 34, -2, -30 },
  { 12170, 37, 42, 34, -1, -30 },
  { 12365, 31, 30, 34, 1, -30 },
  { 12482, 29, 53, 34, 5, -41 },
  { 12675, 8, 54, 34, 13, -41 },
  { 12729, 29, 53, 34, 0, -41 },
  { 12922, 30, 9, 34, 3, -23 },
};

const GFXfont LiberationMono_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic57pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _LIBERATIONMONO_BOLDITALIC57PT7B_H_
