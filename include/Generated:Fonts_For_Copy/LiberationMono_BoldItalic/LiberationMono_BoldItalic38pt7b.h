#ifndef _LIBERATIONMONO_BOLDITALIC38PT7B_H_
#define _LIBERATIONMONO_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0x00, 0x1C, 0x0C,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x06, 0x00, 0x18, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xF8, 0xDF, 0x87, 0xC6, 0x3E, 0x1F, 0x18, 0xFC, 0x7C, 0x60,
  0x01, 0xF1, 0x80, 0x07, 0xF6, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0x8F, 0xC0, 0x06,
  0x1F, 0x1E, 0x18, 0x7C, 0xF8, 0x61, 0xF3, 0xE3, 0x8F, 0x8F, 0xCC, 0x7E,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x81,
  0xFE, 0x01, 0xC0, 0xFF, 0x80, 0xE0, 0x38, 0xF0, 0x78, 0x1E, 0x3C, 0x3C,
  0x07, 0x0F, 0x1E, 0x01, 0xC3, 0x87, 0x00, 0x70, 0xE3, 0x80, 0x1C, 0x79,
  0xC0, 0x07, 0x1C, 0xE0, 0x01, 0xFF, 0x70, 0x00, 0x7F, 0xB8, 0x00, 0x0F,
  0x9E, 0xF8, 0x00, 0x0F, 0x7F, 0x80, 0x07, 0xBF, 0xE0, 0x01, 0xDE, 0x38,
  0x00, 0xE7, 0x0E, 0x00, 0x71, 0xC3, 0x80, 0x38, 0xF0, 0xE0, 0x1C, 0x3C,
  0x78, 0x0E, 0x0E, 0x1E, 0x07, 0x83, 0xCF, 0x03, 0xC0, 0xFF, 0x81, 0xE0,
  0x1F, 0xE0, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0x7C, 0x03, 0xEF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFF, 0x07, 0x9F, 0xF8, 0x3D, 0xFB, 0xE3, 0xCF, 0x8F, 0x1E,
  0xF8, 0x7D, 0xE7, 0x81, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0, 0x3F, 0x0F, 0x81,
  0xFC, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0x1F, 0xC0, 0xF8,
  0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBC, 0xF3, 0xCF, 0x38, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0x1E, 0x27, 0xBD, 0xCF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xF7, 0xC3, 0xC7, 0x87,
  0x8E, 0x02, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xC7, 0xE1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7C, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF3, 0xEF, 0xCF, 0x3E,
  0xFC, 0xF7, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xBE, 0x07, 0xE7, 0xC0, 0xE1, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x07, 0xF0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x07, 0xC1,
  0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x01, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xF8, 0x7E, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x87, 0xE1, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8,
  0x3F, 0x1F, 0x01, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x7C,
  0xFF, 0x87, 0xDF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFC, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8,
  0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xF0,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xBE, 0x1F, 0xF7, 0xC0, 0x7C, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x38, 0x0F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x07, 0xBB, 0x0E, 0x3F, 0x76, 0x18, 0xE2,
  0xCC, 0x73, 0x87, 0x98, 0xC7, 0x0F, 0x33, 0x9C, 0x1C, 0x66, 0x30, 0x39,
  0xCC, 0xE0, 0xE3, 0xB9, 0xC1, 0xC6, 0x77, 0x03, 0x8C, 0xCE, 0x06, 0x39,
  0x9C, 0x1C, 0x77, 0x38, 0x38, 0xCE, 0x70, 0xE3, 0x9C, 0xE1, 0xC6, 0x39,
  0xC7, 0x9C, 0x73, 0x9B, 0x30, 0xE7, 0xE7, 0xC1, 0xC7, 0x8F, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x18, 0x07, 0x00, 0x70, 0x0F, 0x03,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7E,
  0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0x07, 0xC0, 0x1F,
  0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0x8F,
  0xC3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3, 0xF0, 0x3F, 0x3F, 0x01,
  0xF7, 0xE0, 0x18, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7,
  0xFF, 0xFC, 0x7F, 0xEF, 0x87, 0xFE, 0xF8, 0x7F, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0xFE, 0x1F, 0xC7,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C,
  0x07, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87,
  0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x04, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x0F, 0x83, 0xF8, 0x0F, 0x87,
  0xF0, 0x1F, 0x8F, 0xE0, 0x1F, 0x1F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x7F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xBF, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF1, 0xFE, 0x1E, 0xF1, 0xDE, 0x1E, 0xF3, 0xFC, 0x1E, 0xF3,
  0xBC, 0x1E, 0xF7, 0xBC, 0x1E, 0xF7, 0x3C, 0x3E, 0xFF, 0x7C, 0x3C, 0xFE,
  0x78, 0x3C, 0xFE, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x0F, 0xE0, 0x7C, 0x3F, 0x81, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0x1F,
  0x0F, 0xF0, 0x78, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E,
  0xF0, 0xF8, 0x7B, 0xC3, 0xC3, 0xEF, 0x9F, 0x0F, 0xBE, 0x7C, 0x3E, 0x79,
  0xF0, 0xF9, 0xE7, 0xC3, 0xC7, 0x9E, 0x1F, 0x1F, 0x78, 0x7C, 0x7F, 0xE1,
  0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0,
  0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x07, 0xF0, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFF, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3F, 0x01, 0xF8,
  0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x81, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC1,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFE, 0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0xBE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0x3F, 0x01, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0x81, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F,
  0x00, 0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81,
  0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x38,
  0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x87, 0xF0, 0x7F, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0xFC, 0x07,
  0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0xF8, 0x78, 0xF8, 0xF0, 0xF9, 0xF8, 0xF0, 0xF9, 0xF9,
  0xF0, 0xFB, 0xF9, 0xE0, 0xFB, 0xF9, 0xE0, 0xFB, 0xBB, 0xE0, 0xFF, 0xBF,
  0xC0, 0xF7, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xF7,
  0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0xF8,
  0x3C, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x78,
  0x01, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFC, 0x7E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7C,
  0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x7F,
  0x8F, 0xFF, 0xF8, 0xFF, 0xEF, 0xE7, 0xFC, 0x7E, 0x3F, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x0F, 0xBF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x7F, 0xF1, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF7, 0xE0,
  0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xF1, 0xFC, 0xFF,
  0xFF, 0x8F, 0xBF, 0xF0, 0xF9, 0xFE, 0x0F, 0x8F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF7, 0xE0, 0x7C, 0xFC,
  0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x3E, 0x03, 0xFC, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x8F, 0xF0, 0x7F, 0xF7, 0xC1, 0xFF, 0xFF, 0x03, 0xFE,
  0xF8, 0x07, 0xE3, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xC3, 0xE3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x3C, 0xFE, 0x1F, 0x9F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x0F,
  0xF3, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F,
  0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0,
  0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x7C,
  0x07, 0xF9, 0xF0, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x1E,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFC,
  0x1F, 0x9F, 0xE1, 0xF7, 0xFF, 0x1F, 0x7F, 0xF1, 0xFC, 0x3F, 0x1F, 0x81,
  0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E,
  0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xCF,
  0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x3C, 0x3C,
  0x1E, 0xFC, 0xFC, 0x3F, 0xFB, 0xF8, 0x7C, 0xFC, 0xF0, 0xF1, 0xF1, 0xE3,
  0xE3, 0xE3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x7C, 0xF8, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87,
  0x87, 0x8F, 0x0F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x78, 0x78, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x8F, 0x8F, 0x80, 0x1F, 0x07,
  0xC1, 0xF1, 0xFE, 0x1F, 0x3F, 0xF1, 0xF7, 0xFF, 0x1F, 0xC3, 0xF1, 0xF8,
  0x1F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xC0, 0x7C, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x1F,
  0x9F, 0xE0, 0x7D, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xF0, 0xFC, 0x1F, 0x81,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x83, 0xEF, 0xFC,
  0x0F, 0x9F, 0xE0, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x3F,
  0xC3, 0xFF, 0xBE, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0x01, 0xF8, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x0F, 0xE3,
  0xE7, 0xFC, 0x7D, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0x81, 0xF1,
  0xF0, 0x1E, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE7, 0x80, 0x3C, 0xFC, 0x07, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x3F, 0x01, 0xF3, 0xE0,
  0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C,
  0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0xC0, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x7F, 0x8F, 0xFE, 0xF8, 0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x3E, 0x1F,
  0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x1E, 0x0F, 0x3C, 0x3C, 0x3C, 0x78, 0xF8, 0x78, 0xF1, 0xF8, 0xF1, 0xE7,
  0xF3, 0xC3, 0xCE, 0xE7, 0x87, 0xBD, 0xCF, 0x0F, 0x73, 0xBC, 0x1E, 0xE7,
  0x78, 0x3F, 0x8E, 0xE0, 0x77, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E,
  0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xF1,
  0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x87,
  0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0x80, 0x17, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0xFF,
  0xE0, 0x01, 0xF8,
};

const GFXglyph LiberationMono_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 25, 23, 7, -25 },
  { 33, 16, 12, 23, 6, -28 },
  { 57, 23, 25, 23, 0, -25 },
  { 129, 22, 30, 23, 1, -27 },
  { 212, 26, 25, 23, -1, -25 },
  { 294, 21, 25, 23, 0, -25 },
  { 360, 6, 12, 23, 11, -28 },
  { 369, 15, 36, 23, 6, -28 },
  { 437, 15, 36, 23, 2, -28 },
  { 505, 15, 14, 23, 6, -28 },
  { 532, 19, 20, 23, 2, -23 },
  { 580, 11, 12, 23, 2, -6 },
  { 597, 11, 5, 23, 6, -12 },
  { 604, 6, 6, 23, 7, -6 },
  { 609, 25, 28, 23, 0, -28 },
  { 697, 20, 25, 23, 2, -25 },
  { 760, 19, 25, 23, 1, -25 },
  { 820, 22, 25, 23, 0, -25 },
  { 889, 21, 25, 23, 1, -25 },
  { 955, 22, 25, 23, 0, -25 },
  { 1024, 21, 25, 23, 1, -25 },
  { 1090, 20, 25, 23, 2, -25 },
  { 1153, 19, 25, 23, 4, -25 },
  { 1213, 21, 25, 23, 1, -25 },
  { 1279, 20, 25, 23, 2, -25 },
  { 1342, 9, 21, 23, 7, -21 },
  { 1366, 13, 27, 23, 3, -21 },
  { 1410, 19, 21, 23, 2, -23 },
  { 1460, 19, 14, 23, 2, -20 },
  { 1494, 19, 21, 23, 2, -23 },
  { 1544, 19, 25, 23, 3, -25 },
  { 1604, 23, 33, 23, 0, -28 },
  { 1699, 23, 25, 23, -2, -25 },
  { 1771, 21, 25, 23, 1, -25 },
  { 1837, 21, 25, 23, 2, -25 },
  { 1903, 21, 25, 23, 1, -25 },
  { 1969, 22, 25, 23, 1, -25 },
  { 2038, 22, 25, 23, 1, -25 },
  { 2107, 20, 25, 23, 2, -25 },
  { 2170, 22, 25, 23, 1, -25 },
  { 2239, 22, 25, 23, 1, -25 },
  { 2308, 21, 25, 23, 1, -25 },
  { 2374, 24, 25, 23, 1, -25 },
  { 2449, 18, 25, 23, 2, -25 },
  { 2506, 24, 25, 23, 0, -25 },
  { 2581, 22, 25, 23, 1, -25 },
  { 2650, 21, 25, 23, 1, -25 },
  { 2716, 22, 25, 23, 1, -25 },
  { 2785, 21, 32, 23, 1, -25 },
  { 2869, 22, 25, 23, 1, -25 },
  { 2938, 23, 25, 23, 0, -25 },
  { 3010, 22, 25, 23, 3, -25 },
  { 3079, 21, 25, 23, 2, -25 },
  { 3145, 23, 25, 23, 3, -25 },
  { 3217, 24, 25, 23, 2, -25 },
  { 3292, 27, 25, 23, -2, -25 },
  { 3377, 23, 25, 23, 3, -25 },
  { 3449, 23, 25, 23, 0, -25 },
  { 3521, 18, 36, 23, 3, -28 },
  { 3602, 14, 28, 23, 5, -28 },
  { 3651, 18, 36, 23, 1, -28 },
  { 3732, 20, 17, 23, 1, -26 },
  { 3775, 23, 2, 23, -3, 2 },
  { 3781, 8, 5, 23, 10, -27 },
  { 3786, 20, 21, 23, 1, -21 },
  { 3839, 20, 28, 23, 1, -28 },
  { 3909, 19, 21, 23, 2, -21 },
  { 3959, 22, 28, 23, 1, -28 },
  { 4036, 19, 21, 23, 2, -21 },
  { 4086, 21, 28, 23, 3, -28 },
  { 4160, 22, 29, 23, 1, -21 },
  { 4240, 20, 28, 23, 1, -28 },
  { 4310, 20, 28, 23, 0, -28 },
  { 4380, 20, 36, 23, -1, -28 },
  { 4470, 22, 28, 23, 1, -28 },
  { 4547, 20, 28, 23, 0, -28 },
  { 4617, 23, 21, 23, -1, -21 },
  { 4678, 20, 21, 23, 1, -21 },
  { 4731, 20, 21, 23, 1, -21 },
  { 4784, 22, 29, 23, -1, -21 },
  { 4864, 21, 29, 23, 1, -21 },
  { 4941, 19, 21, 23, 3, -21 },
  { 4991, 20, 21, 23, 1, -21 },
  { 5044, 16, 26, 23, 4, -26 },
  { 5096, 20, 21, 23, 2, -21 },
  { 5149, 21, 21, 23, 3, -21 },
  { 5205, 23, 21, 23, 2, -21 },
  { 5266, 24, 21, 23, -1, -21 },
  { 5329, 25, 29, 23, -1, -21 },
  { 5420, 20, 21, 23, 1, -21 },
  { 5473, 20, 36, 23, 3, -28 },
  { 5563, 5, 36, 23, 9, -28 },
  { 5586, 20, 36, 23, 0, -28 },
  { 5676, 20, 6, 23, 2, -16 },
};

const GFXfont LiberationMono_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_BoldItalic38pt7bBitmaps,
  (GFXglyph *)LiberationMono_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _LIBERATIONMONO_BOLDITALIC38PT7B_H_
