#ifndef _NOTOSANS_SEMIBOLD40PT7B_H_
#define _NOTOSANS_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xFB, 0xE7, 0xC2, 0x00, 0xF8, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3C, 0x00, 0x70,
  0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE1,
  0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x81, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xE7, 0x1C, 0xF8, 0xE0, 0x1F, 0x1C,
  0x03, 0xE3, 0x80, 0x7E, 0x70, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x73,
  0xF0, 0x0E, 0x3E, 0x01, 0xC7, 0xE0, 0x38, 0xFF, 0x87, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x01,
  0xE0, 0x0F, 0xFC, 0x01, 0xE0, 0x0F, 0xFE, 0x00, 0xF0, 0x07, 0x87, 0x80,
  0xF0, 0x03, 0xC3, 0xC0, 0xF8, 0x01, 0xE1, 0xE0, 0x78, 0x00, 0xF0, 0xF0,
  0x7C, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x1E, 0x0C, 0x07, 0x87, 0x8F, 0x3F, 0x83, 0xC3,
  0xCF, 0x3F, 0xF0, 0xFF, 0xC7, 0x9F, 0xF8, 0x7F, 0xE7, 0x9F, 0x3E, 0x1F,
  0xE7, 0xCF, 0x0F, 0x03, 0xC3, 0xC7, 0x87, 0x80, 0x03, 0xC3, 0xC3, 0xC0,
  0x01, 0xE1, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x78, 0x0F, 0x0F,
  0x00, 0x7C, 0x07, 0xCF, 0x80, 0x3C, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x7F,
  0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xC3, 0xFF, 0xC0,
  0x7C, 0x7F, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0, 0xF8, 0xFC, 0x1F, 0x9F, 0x8F,
  0x80, 0xFD, 0xF0, 0xF8, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xE0, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xDF, 0x81, 0xFF, 0xF8, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0xFF,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xE0,
  0xDF, 0xB9, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x0F, 0x00, 0x40, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3C,
  0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xF7,
  0xCF, 0x84, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1,
  0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x0F,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0x78,
  0xF9, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE3, 0xFC, 0xF0, 0x1F,
  0x88, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC1, 0xFC, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xC1, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0xE0, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x04, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0xFF, 0x0F, 0xBF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3E, 0x1F, 0xDF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0x3F, 0x8F, 0xC1, 0xFB, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0xF7, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF1,
  0xF9, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x87,
  0xFB, 0xFF, 0xFF, 0x3F, 0xFB, 0xE3, 0xFE, 0x7C, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7C, 0xFB,
  0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x84, 0x00, 0x3E, 0x3E, 0x7F, 0x3F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x3F, 0x88, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x07, 0xFC, 0x1E, 0x3C, 0x1F, 0xFE, 0x1E, 0x78, 0x3F, 0xFE, 0x0E, 0x78,
  0x7E, 0x1E, 0x0F, 0x78, 0x78, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F, 0xF0,
  0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0,
  0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0E, 0xF0, 0xF0, 0x3E, 0x1E, 0xF0,
  0x78, 0x3E, 0x1E, 0xF0, 0x7F, 0xFF, 0xFC, 0x78, 0x3F, 0xE7, 0xF8, 0x78,
  0x1F, 0xC3, 0xF0, 0x7C, 0x06, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7E, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xF9, 0xF8, 0x7F, 0x00, 0x63, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x38, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0x00, 0xFE, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x03, 0xF8, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0xFE, 0x1F, 0xC0, 0x04,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x1F, 0x1F, 0xE0, 0x1F, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x8F, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x01, 0xF8,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8,
  0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3D,
  0xFE, 0xF0, 0x01, 0xEF, 0xF7, 0xC0, 0x0F, 0x7F, 0xBE, 0x00, 0xF3, 0xFC,
  0xF0, 0x07, 0x9F, 0xE7, 0xC0, 0x7C, 0xFF, 0x3E, 0x03, 0xC7, 0xF8, 0xF0,
  0x1E, 0x3F, 0xC7, 0xC1, 0xF1, 0xFE, 0x3E, 0x0F, 0x0F, 0xF0, 0xF0, 0x78,
  0x7F, 0x87, 0xC7, 0xC3, 0xFC, 0x3E, 0x3C, 0x1F, 0xE0, 0xF1, 0xE0, 0xFF,
  0x07, 0xDF, 0x07, 0xF8, 0x3E, 0xF0, 0x3F, 0xC0, 0xF7, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0x80, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xC0, 0x1F, 0xF7, 0xE0, 0x1F,
  0xF3, 0xF0, 0x1F, 0xF3, 0xF0, 0x1F, 0xF1, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F,
  0xF0, 0xFC, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x3F, 0x1F,
  0xF0, 0x1F, 0x1F, 0xF0, 0x1F, 0x9F, 0xF0, 0x0F, 0xCF, 0xF0, 0x07, 0xCF,
  0xF0, 0x07, 0xEF, 0xF0, 0x03, 0xEF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x3F, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFE, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0x9F, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE1, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0x9F, 0x9F, 0x00, 0x6F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x01,
  0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F,
  0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x78, 0x0F,
  0x3C, 0x07, 0xC1, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0xF8,
  0x1F, 0x07, 0xCF, 0x83, 0xE0, 0x3C, 0x1E, 0x1E, 0x0F, 0x80, 0xF8, 0x78,
  0x78, 0x7C, 0x03, 0xE3, 0xE1, 0xF1, 0xF0, 0x0F, 0x8F, 0x87, 0xC7, 0xC0,
  0x1E, 0x3C, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0,
  0xFB, 0xE0, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF8,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x03,
  0xEF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x70,
  0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1C, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0xF7, 0xFD, 0xFF, 0xEF, 0x7F, 0xF3, 0xC7, 0xF8, 0x70,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFE, 0x0F, 0x9F,
  0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF3, 0xFF,
  0x8F, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3,
  0xF0, 0x73, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x81, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xF1,
  0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xE0,
  0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFD, 0xF0, 0x7F, 0x0F, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x08,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xEC, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x60, 0x07, 0xE7, 0xFB, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x7B,
  0xEF, 0xFE, 0x78, 0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x03, 0xC0,
  0xF8, 0x1F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x7F, 0xEF,
  0xF9, 0xFF, 0x3F, 0xC1, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F,
  0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0,
  0xFC, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0xFE, 0x03, 0xF0, 0xF3, 0xFF, 0x8F, 0xFC, 0xFF,
  0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFE,
  0x07, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0xFE, 0x0F, 0x1F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0xF0, 0xFE, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFB, 0xFF, 0x8F, 0x9F, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0xF0, 0xFF,
  0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFD,
  0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC7, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFB, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0xF8, 0x0C, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0xBF, 0xFE,
  0xF3, 0xFF, 0x9E, 0x3F, 0xE3, 0xC0, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xBE,
  0x01, 0xF8, 0x0F, 0x9F, 0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE3,
  0xE0, 0x7F, 0x81, 0xF1, 0xF0, 0x7B, 0xC1, 0xF0, 0xF8, 0x3D, 0xE0, 0xF8,
  0x7C, 0x1E, 0xF0, 0x7C, 0x1F, 0x0F, 0x3C, 0x3C, 0x0F, 0x8F, 0x1E, 0x3E,
  0x07, 0xC7, 0x8F, 0x1F, 0x01, 0xE3, 0xC7, 0x8F, 0x80, 0xFB, 0xE1, 0xE7,
  0x80, 0x7D, 0xE0, 0xF7, 0xC0, 0x3E, 0xF0, 0x7B, 0xE0, 0x0F, 0x78, 0x3D,
  0xE0, 0x07, 0xB8, 0x0E, 0xF0, 0x03, 0xDC, 0x07, 0xF8, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x07, 0xE0,
  0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x7E, 0x01, 0xFB,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x1B, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0xFF, 0x07, 0xE0, 0x3F,
  0x81, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0x07, 0xF8,
  0x1F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFD, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 30, 11, 2, -29 },
  { 28, 13, 11, 18, 3, -29 },
  { 46, 24, 29, 26, 1, -29 },
  { 133, 19, 32, 23, 2, -30 },
  { 209, 33, 29, 35, 1, -29 },
  { 329, 28, 29, 30, 2, -29 },
  { 431, 5, 11, 10, 3, -29 },
  { 438, 10, 35, 13, 2, -29 },
  { 482, 10, 35, 13, 1, -29 },
  { 526, 19, 18, 22, 1, -30 },
  { 569, 19, 20, 23, 2, -24 },
  { 617, 7, 10, 11, 1, -5 },
  { 626, 11, 4, 13, 1, -13 },
  { 632, 7, 7, 11, 2, -6 },
  { 639, 16, 29, 16, 0, -29 },
  { 697, 19, 29, 23, 2, -29 },
  { 766, 13, 29, 23, 3, -29 },
  { 814, 19, 29, 23, 2, -29 },
  { 883, 19, 29, 23, 2, -29 },
  { 952, 21, 29, 23, 1, -29 },
  { 1029, 19, 29, 23, 2, -29 },
  { 1098, 19, 29, 23, 2, -29 },
  { 1167, 20, 29, 23, 1, -29 },
  { 1240, 19, 29, 23, 2, -29 },
  { 1309, 19, 29, 23, 2, -29 },
  { 1378, 7, 23, 11, 2, -22 },
  { 1399, 8, 27, 11, 1, -22 },
  { 1426, 19, 21, 23, 2, -25 },
  { 1476, 19, 12, 23, 2, -20 },
  { 1505, 19, 21, 23, 2, -25 },
  { 1555, 18, 30, 18, 0, -29 },
  { 1623, 32, 32, 36, 2, -29 },
  { 1751, 27, 29, 27, 0, -29 },
  { 1849, 20, 29, 26, 4, -29 },
  { 1922, 22, 29, 26, 2, -29 },
  { 2002, 23, 29, 29, 4, -29 },
  { 2086, 16, 29, 22, 4, -29 },
  { 2144, 16, 29, 22, 4, -29 },
  { 2202, 24, 29, 29, 2, -29 },
  { 2289, 23, 29, 30, 4, -29 },
  { 2373, 12, 29, 15, 1, -29 },
  { 2417, 12, 37, 12, -3, -29 },
  { 2473, 22, 29, 26, 4, -29 },
  { 2553, 17, 29, 22, 4, -29 },
  { 2615, 29, 29, 37, 4, -29 },
  { 2721, 24, 29, 32, 4, -29 },
  { 2808, 27, 29, 31, 2, -29 },
  { 2906, 19, 29, 25, 4, -29 },
  { 2975, 27, 36, 31, 2, -29 },
  { 3097, 22, 29, 26, 4, -29 },
  { 3177, 18, 29, 22, 2, -29 },
  { 3243, 21, 29, 23, 1, -29 },
  { 3320, 23, 29, 30, 3, -29 },
  { 3404, 25, 29, 25, 0, -29 },
  { 3495, 38, 29, 38, 0, -29 },
  { 3633, 25, 29, 26, 0, -29 },
  { 3724, 24, 29, 24, 0, -29 },
  { 3811, 21, 29, 23, 1, -29 },
  { 3888, 9, 35, 13, 3, -29 },
  { 3928, 16, 29, 16, 0, -29 },
  { 3986, 9, 35, 13, 1, -29 },
  { 4026, 21, 19, 23, 1, -29 },
  { 4076, 17, 2, 17, 0, 4 },
  { 4081, 10, 7, 13, 2, -31 },
  { 4090, 18, 22, 23, 2, -22 },
  { 4140, 20, 30, 25, 3, -30 },
  { 4215, 17, 22, 20, 2, -22 },
  { 4262, 20, 30, 25, 2, -30 },
  { 4337, 19, 22, 23, 2, -22 },
  { 4390, 16, 31, 15, 1, -31 },
  { 4452, 20, 32, 25, 2, -22 },
  { 4532, 20, 30, 26, 3, -30 },
  { 4607, 6, 30, 11, 3, -30 },
  { 4630, 11, 40, 11, -2, -30 },
  { 4685, 20, 30, 24, 3, -30 },
  { 4760, 5, 30, 11, 3, -30 },
  { 4779, 32, 22, 38, 3, -22 },
  { 4867, 20, 22, 26, 3, -22 },
  { 4922, 21, 22, 25, 2, -22 },
  { 4980, 20, 32, 25, 3, -22 },
  { 5060, 20, 32, 25, 2, -22 },
  { 5140, 14, 22, 17, 3, -22 },
  { 5179, 16, 22, 20, 2, -22 },
  { 5223, 14, 26, 16, 1, -26 },
  { 5269, 19, 22, 26, 3, -22 },
  { 5322, 22, 22, 22, 0, -22 },
  { 5383, 33, 22, 33, 0, -22 },
  { 5474, 22, 22, 22, 0, -22 },
  { 5535, 22, 32, 22, 0, -22 },
  { 5623, 17, 22, 19, 1, -22 },
  { 5670, 13, 35, 16, 1, -29 },
  { 5727, 4, 39, 22, 9, -30 },
  { 5747, 14, 35, 16, 1, -29 },
  { 5809, 19, 6, 23, 2, -17 },
};

const GFXfont NotoSans_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMIBOLD40PT7B_H_
