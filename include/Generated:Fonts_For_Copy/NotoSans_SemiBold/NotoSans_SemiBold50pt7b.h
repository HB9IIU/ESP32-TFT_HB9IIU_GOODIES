#ifndef _NOTOSANS_SEMIBOLD50PT7B_H_
#define _NOTOSANS_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x18, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x78, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x9C,
  0xFC, 0x7E, 0x1C, 0x0C, 0x7E, 0x1C, 0x00, 0xFE, 0x1C, 0x00, 0x7E, 0x1C,
  0x00, 0x7F, 0x1C, 0x00, 0x7F, 0x9C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C,
  0x3F, 0x00, 0x1C, 0x3F, 0x00, 0x1C, 0x3F, 0x80, 0x1C, 0x3F, 0x70, 0x1C,
  0x7F, 0x7F, 0x1F, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x1F, 0x07,
  0xC0, 0xF8, 0x3F, 0x1F, 0x1F, 0xF0, 0x7C, 0x3E, 0x3E, 0x3F, 0xF8, 0x7C,
  0x7E, 0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x7E, 0xFE, 0x3F, 0xFC, 0xFC,
  0xFC, 0x3E, 0x1F, 0xF8, 0xF8, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0xFE, 0x00, 0x7E, 0x0F, 0xFF, 0xE0,
  0x1F, 0xC3, 0xFD, 0xFE, 0x03, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0xE3, 0xF0, 0xFE, 0x01, 0xFE, 0xFE, 0x1F,
  0xC0, 0x1F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x78, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF0,
  0x7C, 0x0E, 0xFE, 0x3C, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F,
  0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0x81, 0xC0, 0x01, 0x01, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xBF, 0xBF, 0x9F, 0xCF, 0x0F, 0xE3, 0x07, 0xF1, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0xF8, 0x03, 0xF8, 0x30, 0x01,
  0xFC, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x03, 0xFE, 0x38,
  0x00, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00,
  0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xD0, 0x00, 0x3F,
  0xBC, 0x01, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x01, 0xF1, 0xFF, 0xC1, 0xF9, 0xFF, 0xF0, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xDF, 0xF0, 0x0F, 0xEF,
  0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07,
  0xE7, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0x7F, 0xC1, 0xFC, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x1F,
  0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0x3F,
  0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xF0,
  0x7F, 0xF9, 0xF8, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x0C, 0x1F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xF8, 0x1F, 0xE3,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x03, 0xFF, 0xC1, 0xF1, 0xF0, 0x1F, 0xFF, 0xC1, 0xE7,
  0xC0, 0x7F, 0xFF, 0x83, 0xEF, 0x81, 0xFF, 0xFF, 0x07, 0xDE, 0x07, 0xE0,
  0x3E, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x1F, 0xF8, 0x3F, 0x00, 0xF8, 0x1F,
  0xF0, 0x7C, 0x01, 0xE0, 0x3F, 0xC0, 0xF8, 0x07, 0xC0, 0x7F, 0x83, 0xF0,
  0x0F, 0x80, 0xFF, 0x07, 0xC0, 0x1F, 0x01, 0xFE, 0x0F, 0x80, 0x3E, 0x07,
  0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF0, 0x3E,
  0x03, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0xF0, 0xFB, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE7, 0xC0, 0xFF, 0xFB, 0xFF, 0x8F, 0xC0, 0xFF, 0xE3, 0xFF, 0x0F, 0x80,
  0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0,
  0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0x87, 0xFC, 0x00, 0x71, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x87, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x0F, 0xE0, 0x07, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0x81, 0xF8, 0x7F, 0xE0, 0x01, 0x83, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xFC, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0x7F, 0xE0, 0x07, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x81, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0xC7, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFB, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xC7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFB, 0xE0, 0x00, 0x7D,
  0xFF, 0xDF, 0x80, 0x03, 0xEF, 0xFE, 0xFC, 0x00, 0x3F, 0x7F, 0xF3, 0xE0,
  0x01, 0xF3, 0xFF, 0x9F, 0x80, 0x0F, 0x9F, 0xFC, 0xFC, 0x00, 0xFC, 0xFF,
  0xE3, 0xE0, 0x07, 0xC7, 0xFF, 0x1F, 0x80, 0x3E, 0x3F, 0xF8, 0xFC, 0x03,
  0xF1, 0xFF, 0xC3, 0xE0, 0x1F, 0x0F, 0xFE, 0x1F, 0x80, 0xF8, 0x7F, 0xF0,
  0xFC, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xFC, 0x1F, 0x83, 0xE0,
  0xFF, 0xE0, 0xFC, 0x3E, 0x07, 0xFF, 0x03, 0xE1, 0xF0, 0x3F, 0xF8, 0x1F,
  0x9F, 0x81, 0xFF, 0xC0, 0xFC, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0x9F, 0xC0, 0x0F, 0xFE,
  0x7F, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0x87,
  0xF0, 0x0F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0x80, 0xFF, 0xE0, 0x7F,
  0x03, 0xFF, 0x81, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0xFF, 0xE0, 0x1F, 0xC3, 0xFF, 0x80, 0x3F, 0x8F, 0xFE, 0x00, 0xFF, 0x3F,
  0xF8, 0x01, 0xFC, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0x80, 0x0F, 0xEF, 0xFE,
  0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xBF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xF8, 0x3F, 0x9F, 0xC0, 0x06, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7D, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF7, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x3F, 0x03, 0xF0,
  0x0F, 0xE0, 0xFC, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x00,
  0x7F, 0x1F, 0x81, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7C, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x03,
  0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0x80, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xC1, 0xFE, 0x06, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xF0, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0x8F, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFE, 0x1F, 0x0F,
  0xFC, 0x1F, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x01, 0x80, 0x1F, 0x8F, 0xFC, 0x0F, 0xCF, 0xFF, 0x07, 0xEF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0x7F, 0x80,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0x0F, 0x8F, 0xFF,
  0x07, 0xC3, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFC, 0x03, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x23, 0xFC, 0x03, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0E,
  0x07, 0xE0, 0x7F, 0xE3, 0xF0, 0x7F, 0xF9, 0xF8, 0x7F, 0xFE, 0xFC, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x9F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xF9, 0xF0, 0x7F, 0xF8, 0xF8, 0x0F,
  0xF8, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x18, 0x3F, 0xF1, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x02, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0x87, 0xC1, 0xFF, 0xE3, 0xE1, 0xFF, 0xFD, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xC1, 0xFF, 0xE7, 0xE0,
  0x3F, 0xE3, 0xF0, 0x03, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x98, 0x00, 0x3F, 0xCF, 0xC0, 0x7F,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x02,
  0x00, 0xFC, 0x3F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x31, 0xFB,
  0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x60, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x87, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x8F, 0xF0, 0x0F, 0xCF, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x03, 0x00, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xFD, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0xF8, 0x7F, 0xF0, 0xF8, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x07, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x7C, 0x3F, 0xF0, 0x3E, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x03, 0xF9, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7E, 0xFF, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F,
  0x8F, 0xFC, 0x0F, 0xC0, 0x60, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x87, 0xC1, 0xFF,
  0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xBF, 0xFC, 0xFF,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x01,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xEF, 0xC1, 0xFF, 0xE7, 0xE0, 0x7F, 0xE3, 0xF0, 0x02, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x7C,
  0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0x81,
  0xF3, 0xF8, 0x01, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFB, 0x80, 0x0F, 0xDF, 0xC3, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x04, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF,
  0x1F, 0x0F, 0xFC, 0x1F, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0xF0, 0x07, 0xE3,
  0xF0, 0x0F, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0xFE, 0x07,
  0xDF, 0x01, 0xF8, 0x3F, 0x03, 0xEF, 0x80, 0xFC, 0x1F, 0x81, 0xF3, 0xE0,
  0xFE, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x07, 0xF0, 0xF8, 0xF8, 0x3F, 0x01,
  0xF8, 0x7C, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x1F,
  0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x83, 0xE3,
  0xF0, 0x07, 0xE7, 0xC0, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x7D, 0xF8, 0x00,
  0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0x7C, 0x00, 0x3F, 0xF8,
  0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 37, 14, 3, -36 },
  { 38, 16, 13, 23, 3, -36 },
  { 64, 30, 36, 32, 1, -36 },
  { 199, 24, 41, 29, 2, -38 },
  { 322, 40, 36, 44, 2, -36 },
  { 502, 35, 37, 37, 2, -36 },
  { 664, 6, 13, 13, 3, -36 },
  { 674, 13, 44, 16, 2, -36 },
  { 746, 13, 44, 16, 1, -36 },
  { 818, 24, 23, 27, 2, -38 },
  { 887, 24, 24, 29, 2, -30 },
  { 959, 9, 12, 14, 2, -6 },
  { 973, 12, 5, 16, 2, -16 },
  { 981, 8, 8, 14, 3, -7 },
  { 989, 20, 36, 20, 0, -36 },
  { 1079, 25, 37, 29, 2, -36 },
  { 1195, 17, 36, 29, 3, -36 },
  { 1272, 25, 36, 29, 2, -36 },
  { 1385, 24, 37, 29, 2, -36 },
  { 1496, 27, 36, 29, 1, -36 },
  { 1618, 23, 37, 29, 3, -36 },
  { 1725, 25, 37, 29, 2, -36 },
  { 1841, 25, 36, 29, 2, -36 },
  { 1954, 25, 37, 29, 2, -36 },
  { 2070, 25, 37, 29, 2, -36 },
  { 2186, 8, 29, 14, 3, -28 },
  { 2215, 9, 34, 14, 2, -28 },
  { 2254, 24, 26, 29, 2, -31 },
  { 2332, 24, 15, 29, 2, -25 },
  { 2377, 24, 26, 29, 2, -31 },
  { 2455, 22, 37, 23, 0, -36 },
  { 2557, 39, 40, 45, 3, -36 },
  { 2752, 34, 36, 34, 0, -36 },
  { 2905, 26, 36, 33, 4, -36 },
  { 3022, 27, 37, 32, 3, -36 },
  { 3147, 30, 36, 37, 4, -36 },
  { 3282, 20, 36, 28, 5, -36 },
  { 3372, 20, 36, 27, 5, -36 },
  { 3462, 29, 37, 36, 3, -36 },
  { 3597, 28, 36, 38, 5, -36 },
  { 3723, 15, 36, 19, 2, -36 },
  { 3791, 15, 46, 15, -4, -36 },
  { 3878, 27, 36, 32, 5, -36 },
  { 4000, 22, 36, 27, 4, -36 },
  { 4099, 37, 36, 46, 5, -36 },
  { 4266, 30, 36, 40, 5, -36 },
  { 4401, 34, 37, 39, 3, -36 },
  { 4559, 25, 36, 31, 4, -36 },
  { 4672, 34, 45, 39, 3, -36 },
  { 4864, 28, 36, 32, 4, -36 },
  { 4990, 23, 37, 28, 2, -36 },
  { 5097, 27, 36, 28, 1, -36 },
  { 5219, 29, 37, 37, 4, -36 },
  { 5354, 32, 36, 32, 0, -36 },
  { 5498, 47, 36, 48, 0, -36 },
  { 5710, 32, 36, 32, 0, -36 },
  { 5854, 30, 36, 30, 0, -36 },
  { 5989, 26, 36, 29, 1, -36 },
  { 6106, 11, 44, 17, 4, -36 },
  { 6167, 20, 36, 20, 0, -36 },
  { 6257, 12, 44, 17, 1, -36 },
  { 6323, 26, 23, 29, 1, -36 },
  { 6398, 21, 4, 21, 0, 4 },
  { 6409, 13, 8, 17, 2, -38 },
  { 6422, 24, 29, 29, 2, -28 },
  { 6509, 25, 39, 31, 4, -38 },
  { 6631, 22, 29, 25, 2, -28 },
  { 6711, 25, 39, 31, 2, -38 },
  { 6833, 25, 29, 29, 2, -28 },
  { 6924, 20, 38, 19, 1, -38 },
  { 7019, 25, 40, 31, 2, -28 },
  { 7144, 24, 38, 32, 4, -38 },
  { 7258, 7, 38, 14, 4, -38 },
  { 7292, 14, 50, 14, -3, -38 },
  { 7380, 25, 38, 29, 4, -38 },
  { 7499, 6, 38, 14, 4, -38 },
  { 7528, 40, 28, 48, 4, -28 },
  { 7668, 24, 28, 32, 4, -28 },
  { 7752, 26, 29, 31, 2, -28 },
  { 7847, 25, 40, 31, 4, -28 },
  { 7972, 25, 40, 31, 2, -28 },
  { 8097, 17, 28, 22, 4, -28 },
  { 8157, 21, 29, 25, 2, -28 },
  { 8234, 18, 34, 20, 1, -33 },
  { 8311, 24, 28, 32, 4, -27 },
  { 8395, 27, 27, 27, 0, -27 },
  { 8487, 41, 27, 42, 0, -27 },
  { 8626, 28, 27, 28, 0, -27 },
  { 8721, 27, 39, 27, 0, -27 },
  { 8853, 21, 27, 24, 2, -27 },
  { 8924, 17, 44, 19, 1, -36 },
  { 9018, 5, 50, 28, 11, -38 },
  { 9050, 16, 44, 19, 2, -36 },
  { 9138, 24, 7, 29, 2, -21 },
};

const GFXfont NotoSans_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMIBOLD50PT7B_H_
