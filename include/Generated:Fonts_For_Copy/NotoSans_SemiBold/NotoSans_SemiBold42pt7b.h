#ifndef _NOTOSANS_SEMIBOLD42PT7B_H_
#define _NOTOSANS_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2,
  0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE1, 0xE0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFC, 0x61, 0xCF, 0xC6, 0x00, 0xF8, 0x60, 0x0F, 0x86, 0x00, 0xFC,
  0x60, 0x07, 0xF6, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x67, 0xF0, 0x06, 0x3F,
  0x00, 0x61, 0xF0, 0x06, 0x1F, 0xC0, 0x63, 0xFF, 0x86, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0xF0,
  0x01, 0xE0, 0x1F, 0xFC, 0x01, 0xE0, 0x1F, 0x3E, 0x00, 0xF0, 0x0F, 0x0F,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0,
  0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x3E, 0x00, 0x3C,
  0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x1E, 0x00, 0x0F, 0x07, 0x8F, 0x1F, 0xC7,
  0x87, 0xCF, 0x1F, 0xF1, 0xE7, 0xCF, 0x9F, 0xFC, 0xFF, 0xE7, 0x9F, 0x3E,
  0x3F, 0xE7, 0xCF, 0x8F, 0x8F, 0xE3, 0xC7, 0x83, 0xC0, 0x03, 0xE3, 0xC1,
  0xE0, 0x01, 0xE1, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x3C, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0xF8, 0x1E, 0x0F, 0x00, 0x78, 0x0F,
  0x07, 0x80, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x00,
  0xFF, 0xE0, 0x1E, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xC3, 0xFF, 0x80, 0x7C, 0x3F, 0xFE, 0x03, 0xE3,
  0xF9, 0xF8, 0x3F, 0x3F, 0x87, 0xE1, 0xF1, 0xF8, 0x1F, 0x9F, 0x8F, 0xC0,
  0x7E, 0xF8, 0x7C, 0x01, 0xFF, 0xC3, 0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBC, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x70,
  0x70, 0x77, 0xF7, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x07, 0xDF, 0x00, 0xF8, 0xF8,
  0x1F, 0x8F, 0xC0, 0xF0, 0x78, 0x03, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F,
  0x78, 0xF9, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7E, 0x0F,
  0xE7, 0x80, 0x7E, 0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7C, 0x0F, 0xE3, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x80, 0x07, 0xEF, 0x01, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xF0,
  0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3F, 0x07, 0xC3, 0xF9, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC7, 0xF0, 0xFC, 0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0xDF, 0x0F, 0xF1, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x88, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3C, 0x0F, 0xC8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x3C, 0x3E, 0x03, 0xFF, 0x0F, 0x0F, 0x03, 0xFF, 0xE1, 0xE7, 0xC1,
  0xFF, 0xF8, 0x79, 0xE0, 0xFC, 0x3E, 0x1E, 0x78, 0x3C, 0x0F, 0x83, 0x9E,
  0x1F, 0x03, 0xE0, 0xFF, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F,
  0xF0, 0xF8, 0x0F, 0x03, 0xBC, 0x3E, 0x03, 0xC1, 0xEF, 0x0F, 0x80, 0xF0,
  0x7B, 0xC1, 0xE0, 0x3C, 0x1E, 0xF0, 0x78, 0x1F, 0x0F, 0xBC, 0x1F, 0x0F,
  0xE3, 0xC7, 0x83, 0xFF, 0xBF, 0xE1, 0xE0, 0x7F, 0xCF, 0xF8, 0x7C, 0x0F,
  0xE1, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0,
  0x7F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3C, 0x1F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x02, 0x1F, 0xF0, 0x3C, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xF8, 0x03, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBE, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x81,
  0xF0, 0xFF, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x7C,
  0x03, 0xFF, 0xBE, 0x01, 0xFF, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x1F,
  0x1F, 0xC0, 0x0F, 0x8F, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F,
  0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xF1, 0xF0,
  0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xF0, 0x00, 0x7F, 0xFD, 0xF0, 0x01,
  0xFF, 0xFB, 0xE0, 0x03, 0xDF, 0xFB, 0xC0, 0x07, 0xBF, 0xF7, 0xC0, 0x1F,
  0x7F, 0xEF, 0x80, 0x3C, 0xFF, 0xCF, 0x00, 0x79, 0xFF, 0x9F, 0x01, 0xF3,
  0xFF, 0x3E, 0x03, 0xC7, 0xFE, 0x3C, 0x07, 0x8F, 0xFC, 0x7C, 0x1F, 0x1F,
  0xF8, 0xF8, 0x3C, 0x3F, 0xF0, 0xF0, 0x78, 0x7F, 0xE1, 0xF1, 0xF0, 0xFF,
  0xC3, 0xE3, 0xC1, 0xFF, 0x83, 0xC7, 0x83, 0xFF, 0x07, 0xDF, 0x07, 0xFE,
  0x0F, 0xBC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x80,
  0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xDF, 0x00, 0x1F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x07, 0xFD,
  0xF8, 0x03, 0xFE, 0x7E, 0x01, 0xFF, 0x1F, 0x80, 0xFF, 0x8F, 0xC0, 0x7F,
  0xC3, 0xF0, 0x3F, 0xE1, 0xF8, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x1F, 0x87,
  0xFC, 0x0F, 0xC3, 0xFE, 0x03, 0xF1, 0xFF, 0x01, 0xF8, 0xFF, 0x80, 0x7E,
  0x7F, 0xC0, 0x1F, 0xBF, 0xE0, 0x0F, 0xDF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0x87, 0xFE, 0x1F, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x1F, 0x03, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1,
  0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0xDF,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE7, 0xF0, 0x7C, 0xF8, 0x01, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xEF,
  0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x7E, 0x00,
  0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00,
  0x7C, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x1F,
  0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x03, 0xE7, 0x80, 0xF8, 0x1F, 0x03, 0xE7,
  0xC0, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x0F, 0x83, 0xC3, 0xC1, 0xF0,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0xC7,
  0xC3, 0xE3, 0xF0, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x03,
  0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFD, 0xF8, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xC0, 0x7E, 0x20, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xDE, 0x7F, 0xF3, 0xC7, 0xF8,
  0x78, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x3F, 0x7F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFD,
  0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0x7D, 0xFF, 0xF3, 0xE7, 0xFF, 0x1E, 0x1F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x87,
  0x9F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x13, 0xF8, 0x18, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0xC7, 0xC3, 0xFF, 0x3E, 0x3F, 0xFD,
  0xF3, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0x7C,
  0x3F, 0xF3, 0xE0, 0xFF, 0x0F, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x18, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xC2, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8,
  0x78, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xBF,
  0x01, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x40, 0x07, 0xE3,
  0xE0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x3F, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xC3, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7D, 0x1F, 0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0x9F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x3E, 0x7F, 0xF1, 0xFF, 0xCF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFE, 0x1F,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0,
  0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0xFC,
  0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0xF0, 0x7F, 0x07, 0xCF, 0xFE, 0x3E, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0x7F, 0x01, 0xFB, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x7F,
  0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x7F,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xBF, 0xC1, 0xFD,
  0xFF, 0xFF, 0xCF, 0xBF, 0xFE, 0x7C, 0xFF, 0xE3, 0xF3, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF3,
  0xF8, 0x7F, 0xBF, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x7C, 0x1F,
  0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xF7, 0xDF, 0xEF,
  0xFF, 0xDF, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0x67, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x83, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xEF, 0x9F, 0xFE, 0x7C, 0x3F, 0xE3, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0xFE, 0x01, 0xF7, 0xC0,
  0x3F, 0x80, 0x7D, 0xF8, 0x0F, 0xE0, 0x3E, 0x3E, 0x07, 0xFC, 0x0F, 0x8F,
  0x81, 0xEF, 0x03, 0xE3, 0xE0, 0x7B, 0xC1, 0xF8, 0xFC, 0x1E, 0xF0, 0x7C,
  0x1F, 0x0F, 0x3E, 0x1F, 0x07, 0xC3, 0xC7, 0x87, 0xC1, 0xF0, 0xF1, 0xE3,
  0xE0, 0x3E, 0x7C, 0x78, 0xF8, 0x0F, 0x9E, 0x1F, 0x3E, 0x03, 0xE7, 0x83,
  0xCF, 0x80, 0xF9, 0xE0, 0xF7, 0xC0, 0x1E, 0xF8, 0x3D, 0xF0, 0x07, 0xFC,
  0x0F, 0x7C, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF0,
  0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80,
  0x03, 0xDF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x17,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 31, 12, 3, -30 },
  { 25, 13, 11, 19, 3, -30 },
  { 43, 25, 30, 27, 1, -30 },
  { 137, 20, 34, 24, 2, -32 },
  { 222, 33, 30, 37, 2, -30 },
  { 346, 29, 30, 31, 2, -30 },
  { 455, 5, 11, 11, 3, -30 },
  { 462, 10, 37, 14, 2, -30 },
  { 509, 11, 37, 14, 1, -30 },
  { 560, 20, 19, 23, 1, -32 },
  { 608, 20, 20, 24, 2, -25 },
  { 658, 8, 10, 12, 1, -5 },
  { 668, 11, 4, 13, 1, -13 },
  { 674, 6, 7, 12, 3, -6 },
  { 680, 16, 30, 17, 0, -30 },
  { 740, 20, 30, 24, 2, -30 },
  { 815, 13, 30, 24, 3, -30 },
  { 864, 20, 30, 24, 2, -30 },
  { 939, 20, 30, 24, 2, -30 },
  { 1014, 22, 30, 24, 1, -30 },
  { 1097, 20, 30, 24, 2, -30 },
  { 1172, 20, 30, 24, 2, -30 },
  { 1247, 21, 30, 24, 1, -30 },
  { 1326, 20, 30, 24, 2, -30 },
  { 1401, 20, 30, 24, 2, -30 },
  { 1476, 6, 24, 12, 3, -23 },
  { 1494, 8, 28, 12, 1, -23 },
  { 1522, 20, 22, 24, 2, -26 },
  { 1577, 20, 12, 24, 2, -21 },
  { 1607, 20, 22, 24, 2, -26 },
  { 1662, 18, 31, 19, 0, -30 },
  { 1732, 34, 34, 38, 2, -30 },
  { 1877, 28, 30, 28, 0, -30 },
  { 1982, 22, 30, 28, 4, -30 },
  { 2065, 24, 30, 27, 2, -30 },
  { 2155, 24, 30, 31, 4, -30 },
  { 2245, 17, 30, 23, 4, -30 },
  { 2309, 17, 30, 23, 4, -30 },
  { 2373, 25, 30, 30, 2, -30 },
  { 2467, 24, 30, 32, 4, -30 },
  { 2557, 13, 30, 16, 1, -30 },
  { 2606, 12, 38, 13, -3, -30 },
  { 2663, 23, 30, 27, 4, -30 },
  { 2750, 18, 30, 23, 4, -30 },
  { 2818, 31, 30, 39, 4, -30 },
  { 2935, 25, 30, 33, 4, -30 },
  { 3029, 29, 30, 33, 2, -30 },
  { 3138, 20, 30, 26, 4, -30 },
  { 3213, 29, 37, 33, 2, -30 },
  { 3348, 23, 30, 27, 4, -30 },
  { 3435, 19, 30, 23, 2, -30 },
  { 3507, 22, 30, 24, 1, -30 },
  { 3590, 24, 30, 31, 4, -30 },
  { 3680, 27, 30, 27, 0, -30 },
  { 3782, 40, 30, 40, 0, -30 },
  { 3932, 27, 30, 27, 0, -30 },
  { 4034, 25, 30, 25, 0, -30 },
  { 4128, 22, 30, 24, 1, -30 },
  { 4211, 10, 37, 14, 3, -30 },
  { 4258, 16, 30, 17, 0, -30 },
  { 4318, 10, 37, 14, 1, -30 },
  { 4365, 22, 19, 24, 1, -30 },
  { 4418, 18, 3, 18, 0, 4 },
  { 4425, 10, 7, 14, 2, -32 },
  { 4434, 19, 23, 25, 2, -23 },
  { 4489, 21, 32, 26, 3, -32 },
  { 4573, 18, 23, 21, 2, -23 },
  { 4625, 21, 32, 26, 2, -32 },
  { 4709, 21, 23, 25, 2, -23 },
  { 4770, 16, 32, 16, 1, -32 },
  { 4834, 21, 33, 26, 2, -23 },
  { 4921, 21, 32, 27, 3, -32 },
  { 5005, 6, 32, 12, 3, -32 },
  { 5029, 11, 42, 12, -2, -32 },
  { 5087, 22, 32, 25, 3, -32 },
  { 5175, 6, 32, 12, 3, -32 },
  { 5199, 34, 23, 40, 3, -23 },
  { 5297, 21, 23, 27, 3, -23 },
  { 5358, 22, 23, 26, 2, -23 },
  { 5422, 21, 33, 26, 3, -23 },
  { 5509, 21, 33, 26, 2, -23 },
  { 5596, 15, 23, 18, 3, -23 },
  { 5640, 17, 23, 21, 2, -23 },
  { 5689, 15, 28, 17, 1, -28 },
  { 5742, 21, 23, 27, 3, -23 },
  { 5803, 23, 23, 23, 0, -23 },
  { 5870, 34, 23, 35, 0, -23 },
  { 5968, 23, 23, 24, 0, -23 },
  { 6035, 23, 33, 23, 0, -23 },
  { 6130, 18, 23, 20, 1, -23 },
  { 6182, 14, 37, 16, 1, -30 },
  { 6247, 4, 42, 23, 10, -32 },
  { 6268, 14, 37, 16, 2, -30 },
  { 6333, 20, 6, 24, 2, -18 },
};

const GFXfont NotoSans_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMIBOLD42PT7B_H_
