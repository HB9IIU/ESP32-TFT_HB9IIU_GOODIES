#ifndef _NOTOSANS_SEMIBOLD35PT7B_H_
#define _NOTOSANS_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0xF9, 0xFF, 0x1F, 0xF1,
  0xEF, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE0, 0x01, 0xE1,
  0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xE1, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF0,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xF9, 0x86, 0xF1, 0x80, 0xF1, 0x80,
  0xF9, 0x80, 0xFD, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0x81, 0x8F, 0xF1, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1F, 0x80, 0x1E, 0x03, 0xFC, 0x01, 0xC0, 0x7F, 0xE0, 0x3C,
  0x07, 0x9E, 0x07, 0x80, 0x70, 0xE0, 0x78, 0x0F, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0xE0, 0x0F, 0x0F, 0x1E, 0x00, 0xF0, 0xF1, 0xC0, 0x0F, 0x0F, 0x3C,
  0x00, 0x70, 0xE3, 0x8F, 0xC7, 0x1E, 0x79, 0xFE, 0x7F, 0xEF, 0x3F, 0xE3,
  0xFC, 0xF3, 0x8F, 0x1F, 0x9E, 0x78, 0xF0, 0x01, 0xC7, 0x87, 0x00, 0x3C,
  0x78, 0x70, 0x03, 0x87, 0x87, 0x00, 0x78, 0x78, 0x70, 0x07, 0x07, 0x87,
  0x00, 0xF0, 0x78, 0xF0, 0x1E, 0x03, 0x8F, 0x01, 0xE0, 0x3F, 0xE0, 0x3C,
  0x01, 0xFE, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3E, 0x7F, 0xF0, 0x3C,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x7C, 0xF0, 0x3E, 0xF8, 0xF0, 0x1F, 0xF8,
  0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFF, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFE, 0x7C, 0x0F, 0xF8, 0x3F, 0xFF, 0xBD, 0xE7,
  0x39, 0xCE, 0x70, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x0E, 0x09, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0x18, 0x30, 0x04,
  0x10, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B,
  0xEF, 0xFE, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x3C, 0x0F, 0x1F, 0x03,
  0xE7, 0x80, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0x7B,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0xCF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xF9, 0xF3, 0x1F, 0x21, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFD, 0xFC, 0x38, 0x0F, 0x84, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F,
  0xFF, 0xCF, 0xC7, 0xE3, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0xC1, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xC7, 0x80,
  0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE3, 0xC0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x80, 0x3F, 0xF9, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x04, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3E, 0x07, 0xBF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xBF, 0xBF, 0x03, 0xEF, 0xC0, 0x79, 0xE0, 0x1F,
  0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F,
  0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3E,
  0x3E, 0x1F, 0x0F, 0xCF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0x83, 0xE3, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x07, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFC,
  0x7C, 0x0F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE,
  0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x3F, 0x7F, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF,
  0x78, 0x3F, 0x9E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x08, 0x3F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBE,
  0xFF, 0xE7, 0x80, 0x3C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x70,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0xF9,
  0xFF, 0xF3, 0xE3, 0xF2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x02, 0x01, 0xC7, 0x83, 0xFF, 0x1E, 0x78,
  0x7F, 0xF0, 0xE7, 0x0F, 0x87, 0x0E, 0xF0, 0xF0, 0x70, 0xFE, 0x1E, 0x07,
  0x0F, 0xE1, 0xC0, 0x70, 0xFE, 0x1C, 0x0F, 0x0F, 0xE1, 0xC0, 0xF0, 0xEE,
  0x1C, 0x0F, 0x0E, 0xE1, 0xE0, 0xF0, 0xEE, 0x1E, 0x1F, 0x1E, 0xF0, 0xFF,
  0xBF, 0xCF, 0x0F, 0xFB, 0xF8, 0x70, 0x3E, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x1F, 0x80, 0x38, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x1E, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0x04, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x04, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x81,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xEF, 0xE3, 0xF8, 0x02, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0x8F,
  0xF9, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xEF, 0xFD, 0xFF, 0x3F, 0xC7, 0xE0, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x78, 0x03, 0xBF, 0xDE, 0x01, 0xEF,
  0xF7, 0x80, 0x7B, 0xFC, 0xF0, 0x1C, 0xFF, 0x3C, 0x0F, 0x3F, 0xCF, 0x03,
  0xCF, 0xF1, 0xE0, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC3,
  0xC7, 0x0F, 0xF0, 0xF3, 0xC3, 0xFC, 0x3C, 0xF0, 0xFF, 0x07, 0xB8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0,
  0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0x7C, 0x07, 0xFD, 0xF0, 0x1F, 0xF3, 0xE0, 0x7F, 0xC7, 0xC1, 0xFF,
  0x1F, 0x07, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC1, 0xF1, 0xFF, 0x03,
  0xE7, 0xFC, 0x0F, 0x8F, 0xF0, 0x1F, 0x3F, 0xC0, 0x7C, 0xFF, 0x00, 0xFB,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x7C, 0x7C, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC3,
  0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x7E, 0xF8, 0x04, 0xF8, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x1E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x03, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x87,
  0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0xDE, 0x00, 0xF8, 0x03, 0xEF, 0x00,
  0xFE, 0x01, 0xE7, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3F, 0x80, 0xF8, 0xF0,
  0x1D, 0xE0, 0x7C, 0x78, 0x1E, 0xF0, 0x3C, 0x3E, 0x0F, 0x78, 0x1E, 0x0F,
  0x07, 0x9C, 0x1F, 0x07, 0x83, 0xCF, 0x0F, 0x03, 0xC3, 0xC7, 0x87, 0x81,
  0xF1, 0xE3, 0xC3, 0xC0, 0x78, 0xF0, 0xF3, 0xE0, 0x3C, 0xF0, 0x79, 0xE0,
  0x1E, 0x78, 0x3C, 0xF0, 0x0F, 0xBC, 0x1E, 0x78, 0x03, 0xDE, 0x07, 0xBC,
  0x01, 0xEE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x7C,
  0x78, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0x38, 0xF0, 0x1E, 0x1C,
  0x07, 0x07, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1E, 0x01, 0xE7,
  0x00, 0x3B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1C, 0x07, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0x83, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xDF, 0x83, 0xEF, 0x81, 0xF7, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x7E, 0xF8,
  0x7F, 0x7F, 0xFF, 0x9F, 0xFB, 0xC7, 0xF0, 0xE0, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xEF, 0x81, 0xF7,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7D, 0xFC, 0xFE, 0xFF,
  0xFE, 0x7B, 0xFE, 0x38, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xF3,
  0xF9, 0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x01, 0x3F, 0x9E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F,
  0xE7, 0x9F, 0xFB, 0xCF, 0xFF, 0xEF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F,
  0xFB, 0xC3, 0xF8, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC3,
  0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xF4, 0x1F,
  0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F,
  0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0xE7, 0x9F,
  0xFB, 0xCF, 0xFF, 0xEF, 0xC7, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F, 0xFB, 0xC3,
  0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7D, 0x00, 0x3E, 0xF0, 0x7E,
  0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF3, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF, 0xC7, 0xEF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x7E, 0x3F, 0xFF, 0xFF, 0x7F, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F, 0x0F,
  0x87, 0x8F, 0x83, 0xCF, 0x81, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0xBE, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xF1, 0xE0, 0x7C,
  0xF0, 0x3F, 0x78, 0x0F, 0xBC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF8, 0x3F,
  0x8F, 0x7F, 0xE7, 0xFC, 0xFF, 0xFE, 0xFF, 0xEF, 0xE7, 0xFE, 0x3F, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xF0, 0xE3, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF, 0xC7,
  0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7C, 0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0xE3, 0xF8, 0x7B, 0xFF, 0x3F, 0xFF, 0x9F, 0xC7,
  0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7D,
  0xFC, 0x7E, 0xFF, 0xFE, 0x7B, 0xFE, 0x3C, 0xFE, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xE7, 0x9F, 0xFB, 0xCF, 0xFF, 0xEF, 0xC7, 0xF7, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x7F,
  0x7F, 0xFF, 0x9F, 0xFB, 0xC3, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0xE1, 0xFE, 0x7F, 0xF7, 0xEF, 0xFE, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0xBE, 0x0C,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x3E, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF1, 0x1F, 0xF1, 0xFF,
  0x07, 0xF0, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFB, 0xCF, 0xF1, 0xE0, 0xF8, 0x03, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x0F, 0x0F, 0x83, 0xE0,
  0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0xCF, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xFB, 0xC0, 0x7C, 0x07,
  0x9E, 0x07, 0xF0, 0x3C, 0xF8, 0x3F, 0x83, 0xE3, 0xC1, 0xDC, 0x1E, 0x1E,
  0x0E, 0xE0, 0xF0, 0xF0, 0xF7, 0x87, 0x87, 0xC7, 0xBC, 0x7C, 0x1E, 0x38,
  0xE3, 0xC0, 0xF3, 0xC7, 0x9E, 0x07, 0x9E, 0x3C, 0xF0, 0x1E, 0xF1, 0xEF,
  0x00, 0xF7, 0x07, 0x78, 0x07, 0xB8, 0x3B, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF9, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x3C, 0x07,
  0xC7, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x0F, 0x80,
  0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xE3, 0xE0,
  0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFC,
  0x3F, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x07,
  0xF0, 0x1F, 0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 25, 10, 2, -25 },
  { 20, 12, 9, 16, 2, -25 },
  { 34, 21, 25, 23, 1, -25 },
  { 100, 16, 29, 20, 2, -27 },
  { 158, 28, 25, 31, 1, -25 },
  { 246, 24, 25, 26, 2, -25 },
  { 321, 5, 9, 9, 2, -25 },
  { 327, 9, 31, 11, 1, -25 },
  { 362, 9, 31, 11, 1, -25 },
  { 397, 17, 17, 19, 1, -27 },
  { 434, 16, 17, 20, 2, -21 },
  { 468, 6, 9, 10, 1, -4 },
  { 475, 9, 3, 11, 1, -11 },
  { 479, 6, 5, 10, 2, -5 },
  { 483, 14, 25, 14, 0, -25 },
  { 527, 18, 25, 20, 1, -25 },
  { 584, 12, 25, 20, 2, -25 },
  { 622, 18, 25, 20, 1, -25 },
  { 679, 17, 25, 20, 1, -25 },
  { 733, 18, 25, 20, 1, -25 },
  { 790, 16, 25, 20, 2, -25 },
  { 840, 18, 25, 20, 1, -25 },
  { 897, 18, 25, 20, 1, -25 },
  { 954, 18, 25, 20, 1, -25 },
  { 1011, 18, 25, 20, 1, -25 },
  { 1068, 6, 19, 10, 2, -19 },
  { 1083, 7, 24, 10, 1, -19 },
  { 1104, 16, 18, 20, 2, -22 },
  { 1140, 16, 10, 20, 2, -17 },
  { 1160, 16, 18, 20, 2, -22 },
  { 1196, 15, 25, 16, 0, -25 },
  { 1243, 28, 28, 31, 2, -25 },
  { 1341, 23, 25, 24, 0, -25 },
  { 1413, 18, 25, 23, 3, -25 },
  { 1470, 19, 25, 22, 2, -25 },
  { 1530, 21, 25, 26, 3, -25 },
  { 1596, 14, 25, 20, 3, -25 },
  { 1640, 14, 25, 19, 3, -25 },
  { 1684, 21, 25, 25, 2, -25 },
  { 1750, 20, 25, 26, 3, -25 },
  { 1813, 11, 25, 13, 1, -25 },
  { 1848, 11, 32, 11, -3, -25 },
  { 1892, 20, 25, 23, 3, -25 },
  { 1955, 15, 25, 19, 3, -25 },
  { 2002, 26, 25, 33, 3, -25 },
  { 2084, 22, 25, 28, 3, -25 },
  { 2153, 24, 25, 28, 2, -25 },
  { 2228, 17, 25, 22, 3, -25 },
  { 2282, 24, 31, 28, 2, -25 },
  { 2375, 19, 25, 23, 3, -25 },
  { 2435, 16, 25, 19, 2, -25 },
  { 2485, 18, 25, 20, 1, -25 },
  { 2542, 20, 25, 26, 3, -25 },
  { 2605, 22, 25, 22, 0, -25 },
  { 2674, 33, 25, 33, 0, -25 },
  { 2778, 22, 25, 22, 0, -25 },
  { 2847, 21, 25, 21, 0, -25 },
  { 2913, 18, 25, 20, 1, -25 },
  { 2970, 8, 31, 12, 3, -25 },
  { 3001, 14, 25, 14, 0, -25 },
  { 3045, 8, 31, 12, 1, -25 },
  { 3076, 18, 16, 20, 1, -25 },
  { 3112, 15, 2, 15, 0, 3 },
  { 3116, 9, 6, 12, 1, -27 },
  { 3123, 17, 19, 20, 1, -19 },
  { 3164, 17, 27, 22, 3, -27 },
  { 3222, 15, 19, 18, 2, -19 },
  { 3258, 17, 27, 22, 2, -27 },
  { 3316, 17, 19, 20, 2, -19 },
  { 3357, 14, 27, 13, 1, -27 },
  { 3405, 17, 27, 22, 2, -19 },
  { 3463, 17, 27, 22, 3, -27 },
  { 3521, 4, 26, 10, 3, -26 },
  { 3534, 9, 34, 10, -2, -26 },
  { 3573, 17, 27, 21, 3, -27 },
  { 3631, 4, 27, 10, 3, -27 },
  { 3645, 28, 19, 34, 3, -19 },
  { 3712, 17, 19, 22, 3, -19 },
  { 3753, 18, 19, 22, 2, -19 },
  { 3796, 17, 27, 22, 3, -19 },
  { 3854, 17, 27, 22, 2, -19 },
  { 3912, 12, 19, 15, 3, -19 },
  { 3941, 14, 19, 17, 2, -19 },
  { 3975, 12, 23, 14, 1, -23 },
  { 4010, 17, 19, 22, 3, -19 },
  { 4051, 19, 19, 19, 0, -19 },
  { 4097, 29, 19, 29, 0, -19 },
  { 4166, 19, 19, 20, 0, -19 },
  { 4212, 19, 27, 19, 0, -19 },
  { 4277, 15, 19, 17, 1, -19 },
  { 4313, 11, 31, 14, 1, -25 },
  { 4356, 3, 35, 19, 8, -27 },
  { 4370, 12, 31, 14, 1, -25 },
  { 4417, 16, 5, 20, 2, -15 },
};

const GFXfont NotoSans_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMIBOLD35PT7B_H_
