#ifndef _NOTOSANS_SEMIBOLD25PT7B_H_
#define _NOTOSANS_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x17, 0xFC, 0xE7, 0xE7, 0xE7, 0xC6,
  0xC6, 0xC6, 0xC6, 0x06, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xE7,
  0x1F, 0xFF, 0xFF, 0xFF, 0x86, 0x30, 0x1C, 0x60, 0x39, 0xC0, 0x63, 0x87,
  0xFF, 0xEF, 0xFF, 0xC7, 0x18, 0x0E, 0x70, 0x18, 0xE0, 0x31, 0x80, 0x63,
  0x00, 0x06, 0x00, 0x60, 0x1F, 0xC7, 0xFF, 0x7F, 0xEF, 0x62, 0xE6, 0x0F,
  0x60, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x06, 0x70, 0x67, 0x86, 0x7F,
  0xFF, 0xFF, 0xE3, 0xF8, 0x06, 0x00, 0x60, 0x3C, 0x07, 0x07, 0xE0, 0x60,
  0xE7, 0x0E, 0x0E, 0x70, 0xC0, 0xC7, 0x1C, 0x0C, 0x71, 0x80, 0xC7, 0x38,
  0x0E, 0x77, 0x3C, 0xE7, 0x77, 0xE7, 0xEE, 0xE6, 0x3C, 0xCE, 0x70, 0x1C,
  0xC7, 0x01, 0x8C, 0x70, 0x38, 0xC7, 0x03, 0x0E, 0x70, 0x70, 0xE7, 0x0E,
  0x07, 0xE0, 0xE0, 0x3C, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xDE, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x8F, 0xE1, 0xC7, 0xBC, 0x73, 0xC7, 0xBC, 0xE0, 0xFE, 0x38, 0x1F, 0x8F,
  0x03, 0xC1, 0xF7, 0xF8, 0x7F, 0xFF, 0x07, 0xF1, 0xF0, 0xFF, 0xED, 0xB0,
  0x1C, 0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0x71, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x0E, 0x38, 0xE1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0x80, 0x0E, 0x00,
  0xE0, 0x06, 0x08, 0x61, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF0, 0x1B, 0x83,
  0x9C, 0x71, 0xC1, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x7E,
  0xEC, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x38, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x77, 0x07, 0x70, 0xF7, 0x9E, 0x3F, 0xC1, 0xF8, 0x07, 0x1F, 0x3F, 0x7F,
  0xF7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x1F, 0x87, 0xFC, 0xFF, 0xE6, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFE, 0x7F, 0xE4, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x7C, 0x1F, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x80, 0xFE, 0x1E, 0xFF, 0xE7, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x07, 0x3C, 0x18, 0xF0,
  0xE3, 0xC7, 0x0F, 0x18, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xF8, 0x7F, 0xE2, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0xFF, 0x3E, 0xFF, 0xC7, 0xF8, 0x07, 0xE1, 0xFE, 0x3F, 0xA3,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF, 0x8F, 0xF0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0xDF, 0x3F, 0xE1, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x1F, 0x83, 0xFE, 0x79, 0xE7, 0x0F, 0x70, 0x77, 0x0F, 0x78, 0xE3,
  0xFC, 0x1F, 0x83, 0xFC, 0x79, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x3F, 0x70, 0xC7, 0x00, 0x70,
  0x0E, 0x01, 0xE4, 0x7C, 0x7F, 0x87, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0x7F,
  0xC0, 0x77, 0x77, 0x00, 0x00, 0x00, 0x07, 0x77, 0xEE, 0xC0, 0x00, 0x30,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF0, 0x3E, 0x1F, 0x87, 0xE0, 0xF0, 0x0C, 0x00, 0x3F, 0x9F, 0xF9,
  0xFF, 0xA0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1, 0xC0, 0x1E, 0x38, 0x00, 0xE7, 0x0F,
  0xE7, 0x71, 0xFE, 0x36, 0x38, 0xE3, 0xE7, 0x0E, 0x3E, 0x70, 0xE3, 0xE7,
  0x0E, 0x3E, 0x70, 0xE7, 0xE3, 0x1E, 0x66, 0x3F, 0xFE, 0x61, 0xF3, 0xC7,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x30, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x39, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x0E, 0x07, 0x07, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0xC0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x07,
  0x78, 0x03, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xDF, 0xFE, 0xFF, 0xC7, 0xFF, 0xB8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xF1, 0xFF, 0xCF, 0x02, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0x03,
  0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xB8, 0x1E, 0x7F, 0xFC, 0xFF,
  0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xE0, 0x27, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0xFF, 0xE1, 0xFD, 0xC3, 0xFB, 0x80, 0x77,
  0x00, 0xEF, 0x01, 0xCF, 0x03, 0x9F, 0xDF, 0x1F, 0xFE, 0x0F, 0xF8, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFD, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0xFF,
  0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xBE, 0x00, 0xF0, 0x3F,
  0xC1, 0xEF, 0x0F, 0x3C, 0x38, 0xF1, 0xC3, 0xCF, 0x0F, 0x78, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0F,
  0x3C, 0x1C, 0xF0, 0x3B, 0xC0, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xDC, 0x0D, 0xFB, 0x83, 0xBF,
  0x70, 0x77, 0xE7, 0x0C, 0xFC, 0xE3, 0x9F, 0x9C, 0x63, 0xF1, 0xDC, 0x7E,
  0x3B, 0x8F, 0xC7, 0x61, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xE0, 0xFC,
  0x1C, 0x1C, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xEF, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xE7,
  0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80,
  0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0xC0, 0x38, 0xF0, 0x3C, 0x7F, 0xFC,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xFF, 0xFE, 0xFF, 0xCE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B,
  0xC0, 0x38, 0xF0, 0x3C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0x38, 0x3C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF8, 0x38, 0xF0, 0xE1, 0xC3, 0x83, 0x8E, 0x0F, 0x38, 0x1C, 0xE0,
  0x7B, 0x80, 0xF0, 0x1F, 0xC3, 0xFE, 0x7F, 0xE7, 0x02, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x80, 0xFF, 0xBE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x77, 0x03, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0xE0, 0x0F,
  0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x70, 0x7E,
  0x1E, 0x38, 0x7E, 0x1C, 0x38, 0x6E, 0x1C, 0x38, 0xE6, 0x1C, 0x38, 0xE7,
  0x3C, 0x1C, 0xE7, 0x38, 0x1C, 0xC7, 0x38, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3,
  0xB8, 0x0D, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xE0, 0x07, 0x01, 0xE0, 0xF0, 0x0E, 0x78, 0x1E, 0x38, 0x3C, 0x1C, 0x38,
  0x1E, 0x78, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x38, 0x1C,
  0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3,
  0xC7, 0x83, 0x8E, 0x07, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF,
  0xF0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xFC, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xB8, 0x0C, 0xC0,
  0xC3, 0x06, 0x18, 0x70, 0x63, 0x03, 0xB8, 0x0D, 0x80, 0x70, 0xFF, 0xFF,
  0xFC, 0xF1, 0xE3, 0xC3, 0x0F, 0x87, 0xFE, 0x3F, 0xE2, 0x0F, 0x00, 0x70,
  0x07, 0x3F, 0xF7, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0xFF, 0x1F, 0x7F, 0xF3,
  0xE7, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF,
  0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x0F, 0xF9, 0xFF, 0xFE, 0xEF, 0xC0, 0x07, 0x83, 0xFC, 0xFF, 0x3C, 0x27,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3E, 0x73, 0xFE,
  0x3F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0x1C,
  0xFE, 0xEF, 0xFF, 0x78, 0x7B, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC1, 0xEE, 0x0F, 0x7C, 0xF9, 0xFD, 0xC7, 0xCE, 0x0F, 0x81, 0xFC,
  0x3F, 0xE7, 0x07, 0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0xC3, 0x3F, 0xF0, 0xFE, 0x0F, 0xC7, 0xF1, 0xEC, 0x70, 0x1C,
  0x0F, 0xEF, 0xFB, 0xFE, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x0E, 0x39, 0xFD, 0xDF, 0xFE, 0xF0,
  0xF7, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E,
  0xF1, 0xF3, 0xFB, 0x8F, 0x9C, 0x00, 0xE0, 0x0F, 0x40, 0x73, 0xFF, 0x9F,
  0xF8, 0x7F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78,
  0xEF, 0xEF, 0xFF, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x7F, 0xA1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x71, 0xC2, 0x00, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFE, 0xF0, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3B, 0x83, 0x9C, 0x38,
  0xE3, 0x87, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xF0, 0x7B, 0x83, 0x8E, 0x1C,
  0x78, 0xE1, 0xE7, 0x07, 0x38, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC7, 0x83, 0xCE, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0x0F, 0x8F,
  0xF0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xC7, 0x8E, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3B, 0x81, 0xDC, 0x1E, 0xF1, 0xE3, 0xFE, 0x0F, 0xE0, 0xE7, 0x8E, 0xFE,
  0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xFF, 0x9F, 0xFF, 0xEE, 0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x39, 0xFD, 0xDF, 0xFE, 0xF0, 0xF7, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x1E, 0xFB, 0xF3, 0xFB,
  0x8F, 0x9C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0xC7, 0xF7, 0xBF, 0xDF, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x1F, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x3E, 0x07,
  0xF0, 0x7E, 0x07, 0xC0, 0x70, 0x1F, 0x0F, 0xFF, 0xBF, 0xC0, 0x18, 0x0C,
  0x06, 0x07, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xE0, 0xFA, 0x3F, 0x0F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x1F,
  0x7F, 0xF3, 0xF7, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x38, 0x70,
  0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x70, 0x77, 0x0F, 0x07, 0x70, 0xF8, 0x77,
  0x0F, 0x87, 0x70, 0xD8, 0xE3, 0x9D, 0xCE, 0x39, 0xDC, 0xE3, 0x99, 0xDC,
  0x1B, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0xF0, 0x3D, 0xE1, 0xE3, 0x87, 0x07, 0x38, 0x1F, 0xE0,
  0x3F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0E, 0x1C,
  0x78, 0x7B, 0xC0, 0xF0, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x37, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0x87, 0xC3,
  0xE1, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x1E, 0x3E, 0x1F, 0x03, 0xC0,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xE0, 0xF8, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x1C, 0x0F, 0x0F, 0x1E, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0xF8, 0xF8, 0xE0, 0x38, 0x1F, 0xF3, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 18, 7, 2, -18 },
  { 8, 8, 7, 11, 2, -18 },
  { 15, 15, 18, 16, 1, -18 },
  { 49, 12, 20, 14, 1, -19 },
  { 79, 20, 18, 22, 1, -18 },
  { 124, 18, 18, 19, 1, -18 },
  { 165, 3, 7, 6, 2, -18 },
  { 168, 6, 22, 8, 1, -18 },
  { 185, 6, 22, 8, 1, -18 },
  { 202, 12, 12, 14, 1, -19 },
  { 220, 12, 12, 14, 1, -15 },
  { 238, 4, 6, 7, 1, -3 },
  { 241, 6, 3, 8, 1, -8 },
  { 244, 3, 4, 7, 2, -4 },
  { 246, 10, 18, 10, 0, -18 },
  { 269, 12, 18, 14, 1, -18 },
  { 296, 8, 18, 14, 2, -18 },
  { 314, 12, 18, 14, 1, -18 },
  { 341, 12, 18, 14, 1, -18 },
  { 368, 14, 18, 14, 0, -18 },
  { 400, 12, 18, 14, 1, -18 },
  { 427, 12, 18, 14, 1, -18 },
  { 454, 12, 18, 14, 1, -18 },
  { 481, 12, 18, 14, 1, -18 },
  { 508, 12, 18, 14, 1, -18 },
  { 535, 3, 14, 7, 2, -14 },
  { 541, 4, 17, 7, 1, -14 },
  { 550, 12, 12, 14, 1, -15 },
  { 568, 12, 7, 14, 1, -12 },
  { 579, 12, 12, 14, 1, -15 },
  { 597, 11, 18, 12, 0, -18 },
  { 622, 20, 20, 22, 1, -18 },
  { 672, 17, 18, 17, 0, -18 },
  { 711, 13, 18, 16, 2, -18 },
  { 741, 14, 18, 16, 1, -18 },
  { 773, 15, 18, 18, 2, -18 },
  { 807, 10, 18, 14, 2, -18 },
  { 830, 10, 18, 13, 2, -18 },
  { 853, 15, 18, 18, 1, -18 },
  { 887, 15, 18, 19, 2, -18 },
  { 921, 7, 18, 9, 1, -18 },
  { 937, 7, 23, 8, -2, -18 },
  { 958, 14, 18, 16, 2, -18 },
  { 990, 11, 18, 14, 2, -18 },
  { 1015, 19, 18, 23, 2, -18 },
  { 1058, 16, 18, 20, 2, -18 },
  { 1094, 17, 18, 20, 1, -18 },
  { 1133, 12, 18, 15, 2, -18 },
  { 1160, 17, 22, 20, 1, -18 },
  { 1207, 14, 18, 16, 2, -18 },
  { 1239, 12, 18, 14, 1, -18 },
  { 1266, 14, 18, 14, 0, -18 },
  { 1298, 14, 18, 19, 2, -18 },
  { 1330, 16, 18, 16, 0, -18 },
  { 1366, 24, 18, 24, 0, -18 },
  { 1420, 16, 18, 16, 0, -18 },
  { 1456, 15, 18, 15, 0, -18 },
  { 1490, 13, 18, 14, 1, -18 },
  { 1520, 6, 22, 8, 2, -18 },
  { 1537, 10, 18, 10, 0, -18 },
  { 1560, 5, 22, 8, 1, -18 },
  { 1574, 13, 12, 14, 1, -18 },
  { 1594, 11, 2, 11, 0, 2 },
  { 1597, 6, 4, 8, 1, -19 },
  { 1600, 12, 14, 15, 1, -14 },
  { 1621, 12, 19, 16, 2, -19 },
  { 1650, 11, 14, 13, 1, -14 },
  { 1670, 13, 19, 16, 1, -19 },
  { 1701, 12, 14, 15, 1, -14 },
  { 1722, 10, 19, 9, 0, -19 },
  { 1746, 13, 20, 16, 1, -14 },
  { 1779, 12, 19, 16, 2, -19 },
  { 1808, 3, 19, 7, 2, -19 },
  { 1816, 6, 25, 7, -1, -19 },
  { 1835, 13, 19, 15, 2, -19 },
  { 1866, 3, 19, 7, 2, -19 },
  { 1874, 20, 14, 24, 2, -14 },
  { 1909, 12, 14, 16, 2, -14 },
  { 1930, 13, 14, 15, 1, -14 },
  { 1953, 12, 20, 16, 2, -14 },
  { 1983, 13, 20, 16, 1, -14 },
  { 2016, 9, 14, 11, 2, -14 },
  { 2032, 10, 14, 12, 1, -14 },
  { 2050, 9, 17, 10, 0, -17 },
  { 2070, 12, 14, 16, 2, -14 },
  { 2091, 14, 14, 14, 0, -14 },
  { 2116, 20, 14, 21, 0, -14 },
  { 2151, 14, 14, 14, 0, -14 },
  { 2176, 14, 20, 14, 0, -14 },
  { 2211, 10, 14, 12, 1, -14 },
  { 2229, 9, 22, 10, 0, -18 },
  { 2254, 2, 25, 14, 6, -19 },
  { 2261, 8, 22, 10, 1, -18 },
  { 2283, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMIBOLD25PT7B_H_
