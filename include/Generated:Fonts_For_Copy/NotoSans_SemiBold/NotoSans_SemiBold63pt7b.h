#ifndef _NOTOSANS_SEMIBOLD63PT7B_H_
#define _NOTOSANS_SEMIBOLD63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F,
  0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x07, 0x80, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC7, 0x83, 0xE3, 0xFE, 0x1E, 0x01, 0x8F, 0xF0, 0x78, 0x00, 0x3F,
  0xC1, 0xE0, 0x00, 0xFF, 0x07, 0x80, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xF8,
  0x78, 0x00, 0x1F, 0xF9, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x79, 0xFF, 0xC0,
  0x01, 0xE1, 0xFF, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x1E, 0x0F, 0xF0, 0x00,
  0x78, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xC0, 0x07, 0x83, 0xFF, 0xE0, 0x1E,
  0x1F, 0xFF, 0xF8, 0x7B, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0x00, 0x3F, 0x01, 0xF8, 0x7F, 0x07,
  0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC3, 0xFF, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xFF, 0xF8,
  0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0xFE, 0x1F, 0x87, 0xE0, 0x3F, 0x01, 0xFF,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x07, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0xBF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0B, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x40, 0x0F, 0xC0, 0x05, 0xE0, 0x3F, 0x01, 0xE7, 0xF0,
  0x7C, 0x3F, 0xDF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x00, 0x60, 0x08, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x7F, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x3F,
  0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xBF, 0xFF, 0xF9, 0xFE, 0xFF, 0x8F, 0xF3, 0xF0, 0x7F, 0x8F, 0x03, 0xFC,
  0x70, 0x1F, 0xE1, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x7C, 0x00, 0x1F,
  0xF0, 0x70, 0x00, 0x3F, 0xE0, 0x40, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF0, 0x1F, 0xFC, 0x3E, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x01, 0xFF, 0xBF,
  0x00, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x80, 0x00, 0x0F,
  0xFB, 0xC0, 0x00, 0x7F, 0xCF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x08, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xFC,
  0x07, 0xF1, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xCF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0xCF, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0,
  0x1F, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1,
  0xFC, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0x78, 0x07,
  0x81, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFC, 0x07, 0xFE, 0x1C, 0x00, 0x1F, 0xE1, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xFF, 0xFE, 0x07,
  0xE1, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xDF, 0x81, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x1F, 0x80,
  0x0F, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0x01,
  0xF8, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xF9, 0xF8,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFC, 0x7E, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0x1F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0xE7, 0xFF, 0xC1,
  0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0x07, 0xFF, 0x00,
  0x00, 0x41, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x30, 0x3F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0x00,
  0x01, 0xC0, 0x7F, 0xF0, 0x00, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0xF8, 0x03,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFA, 0x07, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xFF, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xFF, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0xFF, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0xFF, 0x3F, 0x80, 0x01, 0xFC,
  0xFF, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFF, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0xFF, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF,
  0x80, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x07, 0xFF, 0xE3,
  0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x1F,
  0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xF8, 0x00,
  0x7F, 0xC7, 0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE,
  0xFF, 0x00, 0x3F, 0xF3, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F,
  0xFB, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xC3, 0xFC, 0x00, 0x02, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x74, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0xF0, 0x03,
  0xFF, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0xF1, 0xF8, 0xFF, 0xFE, 0x0F, 0xC1,
  0xFF, 0xE0, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x7F, 0x8F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xC1, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xE0,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF,
  0xFE, 0x1F, 0xCF, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0x7E, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x3C, 0x3F, 0xF0, 0x00, 0x87,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x63, 0xFF, 0xC0, 0x7C, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0x81, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x07,
  0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x41,
  0xFF, 0x80, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFC, 0x18, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x3F, 0xE0, 0x07,
  0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFC,
  0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x0E, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x20, 0x00, 0x07,
  0xFE, 0x3C, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xE0, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF,
  0xE3, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x3F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xFC, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE,
  0x07, 0xF3, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0x00,
  0x7F, 0xEF, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF,
  0x03, 0xFC, 0x3F, 0xF8, 0x07, 0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x03,
  0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x3F,
  0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x00,
  0x0F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xEF, 0xC1, 0xFF, 0xBF, 0x8F, 0xFE, 0xFE, 0x7F,
  0xFB, 0xFB, 0xFF, 0xEF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x01, 0xF9, 0xFE, 0x00,
  0x1C, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x10, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x9F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFC,
  0x3F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x00, 0x7F, 0x87,
  0xF0, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x0F, 0xC3, 0xFC, 0x00, 0xFE,
  0x1F, 0x81, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x03,
  0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x7E, 0x7F, 0x80,
  0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x01, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x80, 0x00,
  0xFF, 0xE2, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 10, 46, 17, 4, -45 },
  { 59, 21, 16, 28, 4, -45 },
  { 101, 38, 45, 41, 1, -45 },
  { 315, 30, 52, 36, 3, -48 },
  { 510, 51, 47, 55, 2, -46 },
  { 810, 44, 47, 47, 3, -46 },
  { 1069, 8, 16, 16, 4, -45 },
  { 1085, 16, 55, 20, 3, -45 },
  { 1195, 16, 55, 20, 2, -45 },
  { 1305, 30, 29, 34, 2, -48 },
  { 1414, 30, 31, 36, 3, -38 },
  { 1531, 11, 15, 18, 2, -7 },
  { 1552, 16, 6, 20, 2, -20 },
  { 1564, 10, 10, 17, 4, -9 },
  { 1577, 25, 45, 25, 0, -45 },
  { 1718, 30, 47, 36, 3, -46 },
  { 1895, 21, 45, 36, 4, -45 },
  { 2014, 31, 46, 36, 3, -46 },
  { 2193, 30, 47, 36, 3, -46 },
  { 2370, 34, 45, 36, 1, -45 },
  { 2562, 30, 46, 36, 3, -45 },
  { 2735, 31, 47, 36, 3, -46 },
  { 2918, 32, 45, 36, 2, -45 },
  { 3098, 30, 47, 36, 3, -46 },
  { 3275, 31, 47, 36, 2, -46 },
  { 3458, 10, 36, 17, 4, -35 },
  { 3503, 12, 43, 18, 2, -35 },
  { 3568, 30, 32, 36, 3, -39 },
  { 3688, 30, 18, 36, 3, -31 },
  { 3756, 30, 32, 36, 3, -39 },
  { 3876, 28, 47, 29, 0, -46 },
  { 4041, 50, 50, 57, 3, -45 },
  { 4354, 42, 45, 42, 0, -45 },
  { 4591, 32, 45, 42, 6, -45 },
  { 4771, 34, 47, 40, 4, -46 },
  { 4971, 36, 45, 46, 6, -45 },
  { 5174, 25, 45, 35, 6, -45 },
  { 5315, 25, 45, 34, 6, -45 },
  { 5456, 37, 47, 46, 4, -46 },
  { 5674, 36, 45, 48, 6, -45 },
  { 5877, 19, 45, 23, 2, -45 },
  { 5984, 19, 58, 19, -5, -45 },
  { 6122, 35, 45, 41, 6, -45 },
  { 6319, 27, 45, 34, 6, -45 },
  { 6471, 47, 45, 59, 6, -45 },
  { 6736, 38, 45, 50, 6, -45 },
  { 6950, 42, 47, 50, 4, -46 },
  { 7197, 30, 45, 39, 6, -45 },
  { 7366, 42, 57, 50, 4, -46 },
  { 7666, 34, 45, 41, 6, -45 },
  { 7858, 29, 47, 35, 3, -46 },
  { 8029, 34, 45, 36, 1, -45 },
  { 8221, 37, 46, 47, 5, -45 },
  { 8434, 40, 45, 40, 0, -45 },
  { 8659, 60, 45, 60, 0, -45 },
  { 8997, 40, 45, 40, 0, -45 },
  { 9222, 38, 45, 38, 0, -45 },
  { 9436, 32, 45, 36, 2, -45 },
  { 9616, 14, 55, 21, 5, -45 },
  { 9713, 25, 45, 25, 0, -45 },
  { 9854, 14, 55, 21, 2, -45 },
  { 9951, 32, 29, 36, 2, -45 },
  { 10067, 27, 4, 27, 0, 6 },
  { 10081, 15, 10, 21, 3, -48 },
  { 10100, 29, 36, 37, 3, -35 },
  { 10231, 31, 49, 39, 5, -48 },
  { 10421, 27, 36, 32, 3, -35 },
  { 10543, 32, 49, 39, 3, -48 },
  { 10739, 31, 36, 37, 3, -35 },
  { 10879, 25, 48, 23, 1, -48 },
  { 11029, 32, 50, 39, 3, -35 },
  { 11229, 30, 48, 40, 5, -48 },
  { 11409, 8, 47, 18, 5, -47 },
  { 11456, 16, 62, 18, -3, -47 },
  { 11580, 32, 48, 37, 5, -48 },
  { 11772, 8, 48, 18, 5, -48 },
  { 11820, 51, 35, 60, 5, -35 },
  { 12044, 30, 35, 40, 5, -35 },
  { 12176, 33, 36, 39, 3, -35 },
  { 12325, 31, 50, 39, 5, -35 },
  { 12519, 32, 50, 39, 3, -35 },
  { 12719, 22, 35, 27, 5, -35 },
  { 12816, 25, 36, 31, 3, -35 },
  { 12929, 23, 43, 26, 1, -42 },
  { 13053, 30, 35, 40, 5, -34 },
  { 13185, 34, 34, 34, 0, -34 },
  { 13330, 51, 34, 52, 1, -34 },
  { 13547, 34, 34, 35, 1, -34 },
  { 13692, 35, 49, 35, 0, -34 },
  { 13907, 26, 34, 30, 2, -34 },
  { 14018, 21, 55, 25, 1, -45 },
  { 14163, 6, 63, 35, 14, -48 },
  { 14211, 21, 55, 25, 2, -45 },
  { 14356, 30, 10, 36, 3, -27 },
};

const GFXfont NotoSans_SemiBold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMIBOLD63PT7B_H_
