#ifndef _NOTOSANS_SEMIBOLD8PT7B_H_
#define _NOTOSANS_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xF4, 0x31, 0xBE, 0xAF, 0xB0, 0x2F, 0x63, 0xB6, 0x49,
  0x52, 0xD2, 0xD2, 0xAD, 0x80, 0x71, 0x47, 0x1B, 0x99, 0xF0, 0xE0, 0x5A,
  0x94, 0x95, 0x5C, 0x2F, 0x67, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25,
  0x00, 0x65, 0x99, 0x97, 0x75, 0x50, 0x69, 0x12, 0x4F, 0xE1, 0x17, 0x1F,
  0x13, 0x59, 0xF1, 0x74, 0x61, 0x1F, 0x34, 0xAD, 0x97, 0xF1, 0x12, 0x24,
  0x69, 0x77, 0x97, 0x69, 0x97, 0x16, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF,
  0x86, 0x3C, 0xE1, 0x24, 0x04, 0x38, 0x8A, 0xED, 0x5B, 0xC8, 0x0E, 0x00,
  0x21, 0x94, 0xA7, 0xC4, 0xE9, 0xAF, 0x9E, 0x3A, 0x11, 0x84, 0x3C, 0xE9,
  0x99, 0x9E, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x11, 0xB4, 0xBC,
  0x99, 0x9F, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0x9A, 0xCE, 0xA9,
  0x92, 0x49, 0xC0, 0x8F, 0x3D, 0x75, 0xB6, 0x90, 0x8E, 0x73, 0x5B, 0xCC,
  0x39, 0x3C, 0x71, 0x4D, 0xE0, 0xEB, 0xBE, 0x88, 0x39, 0x3C, 0x71, 0x4D,
  0xE0, 0xC0, 0xEB, 0xAE, 0xA9, 0x7C, 0x43, 0x1F, 0xF2, 0x22, 0x22, 0x99,
  0x99, 0x9F, 0x8C, 0x54, 0xA5, 0x10, 0x91, 0x9A, 0x5A, 0x6A, 0x6A, 0x64,
  0x8A, 0x8C, 0x45, 0x44, 0x8A, 0x94, 0x42, 0x10, 0xF1, 0x26, 0x4F, 0xFE,
  0x91, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0, 0x77, 0x97, 0x88,
  0xE9, 0xBE, 0x78, 0xC7, 0x11, 0x79, 0xD7, 0x7F, 0x87, 0x6B, 0xA4, 0x80,
  0x79, 0xD7, 0x17, 0x88, 0xEB, 0xBB, 0xBC, 0x45, 0x56, 0x89, 0xAC, 0xEB,
  0xFC, 0xFE, 0x9A, 0x69, 0xEB, 0xBB, 0x74, 0xF4, 0xE0, 0xE9, 0xBE, 0x88,
  0x79, 0xD7, 0x11, 0xEA, 0xF6, 0x3E, 0x5D, 0x26, 0xB6, 0xF0, 0x95, 0x66,
  0x96, 0xE9, 0xB3, 0x40, 0xD6, 0x6D, 0x95, 0x62, 0x2C, 0xF2, 0x4F, 0x29,
  0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 5, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 2, 7, 3, 0, -6 },
  { 27, 4, 4, 4, 0, -6 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 2, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 2, 1, 2, 0, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 2, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 4, 6, 5, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 4, 4, 5, 0, -5 },
  { 71, 4, 2, 5, 0, -4 },
  { 72, 4, 4, 5, 0, -5 },
  { 74, 4, 6, 4, 0, -6 },
  { 77, 7, 7, 7, 0, -6 },
  { 84, 5, 6, 5, 0, -6 },
  { 88, 4, 6, 5, 1, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 6, 1, -6 },
  { 98, 3, 6, 4, 1, -6 },
  { 101, 3, 6, 4, 1, -6 },
  { 104, 5, 6, 6, 0, -6 },
  { 108, 4, 6, 6, 1, -6 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 3, 8, 2, -1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 6, 6, 7, 1, -6 },
  { 128, 5, 6, 6, 1, -6 },
  { 132, 6, 6, 6, 0, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 6, 7, 6, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 6, 5, 0, -6 },
  { 155, 4, 6, 6, 1, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 8, 6, 8, 0, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 4, 6, 5, 0, -6 },
  { 179, 1, 7, 3, 1, -6 },
  { 180, 3, 6, 3, 0, -6 },
  { 183, 2, 7, 3, 0, -6 },
  { 185, 4, 4, 5, 0, -6 },
  { 187, 3, 1, 3, 0, 0 },
  { 188, 2, 1, 3, 0, -6 },
  { 189, 4, 4, 5, 0, -4 },
  { 191, 4, 6, 5, 1, -6 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 4, 6, 5, 0, -6 },
  { 199, 4, 4, 5, 0, -4 },
  { 201, 3, 6, 3, 0, -6 },
  { 204, 4, 6, 5, 0, -4 },
  { 207, 4, 6, 5, 1, -6 },
  { 210, 1, 6, 2, 1, -6 },
  { 211, 2, 8, 2, 0, -6 },
  { 213, 4, 6, 5, 1, -6 },
  { 216, 1, 6, 2, 1, -6 },
  { 217, 6, 4, 8, 1, -4 },
  { 220, 4, 4, 5, 1, -4 },
  { 222, 5, 4, 5, 0, -4 },
  { 225, 4, 6, 5, 1, -4 },
  { 228, 4, 6, 5, 0, -4 },
  { 231, 2, 4, 3, 1, -4 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 3, 5, 3, 0, -5 },
  { 236, 3, 4, 5, 1, -4 },
  { 238, 4, 4, 4, 0, -4 },
  { 240, 7, 4, 7, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 4, 6, 4, 0, -4 },
  { 249, 4, 4, 4, 0, -4 },
  { 251, 3, 7, 3, 0, -6 },
  { 254, 1, 8, 4, 2, -6 },
  { 255, 3, 7, 3, 0, -6 },
  { 258, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMIBOLD8PT7B_H_
