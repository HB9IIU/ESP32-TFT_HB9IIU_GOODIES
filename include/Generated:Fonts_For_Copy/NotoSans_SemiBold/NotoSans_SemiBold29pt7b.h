#ifndef _NOTOSANS_SEMIBOLD29PT7B_H_
#define _NOTOSANS_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x76, 0x60, 0x0F, 0xFF, 0xF0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x8E, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC3,
  0x07, 0xFF, 0xFB, 0xFF, 0xFC, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x30, 0x06,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x7E, 0x0F,
  0xFF, 0x7F, 0xF9, 0xFC, 0xEF, 0x30, 0x3C, 0xC0, 0x7B, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x33, 0xC0, 0xC7, 0x83, 0x1F,
  0xCD, 0xFF, 0xFF, 0xBF, 0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x1E, 0x00, 0xE0, 0xFE, 0x03, 0x81, 0xFE, 0x07, 0x07, 0x1C, 0x1C, 0x0E,
  0x38, 0x38, 0x1C, 0x70, 0xE0, 0x38, 0x63, 0x80, 0x71, 0xC7, 0x00, 0xE3,
  0x9C, 0x71, 0xC7, 0x3B, 0xF9, 0xFE, 0xE7, 0xF3, 0xF9, 0xDC, 0x71, 0xE7,
  0x38, 0xE0, 0x0E, 0x71, 0xC0, 0x38, 0xE3, 0x80, 0xE1, 0xC7, 0x01, 0xC3,
  0x8E, 0x07, 0x07, 0x1C, 0x0E, 0x07, 0x78, 0x38, 0x0F, 0xE0, 0xF0, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x78, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3C, 0x7F, 0xC3, 0xC7, 0x9F, 0x1E, 0x3C,
  0x7C, 0xE3, 0xC1, 0xFF, 0x1E, 0x07, 0xF0, 0xF0, 0x1F, 0x83, 0xC0, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xF7, 0xC1, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x0E, 0x0F, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x3C, 0x71,
  0xC0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0xE3, 0x1B, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0F, 0x3C, 0x18, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x7B, 0xDC, 0xE7, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0x1E, 0x78,
  0x39, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F, 0x78, 0x3D, 0xE1, 0xE3,
  0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x83, 0xC7, 0xE7, 0xF7, 0xBF, 0x9D,
  0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9E, 0x1E,
  0x20, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9C,
  0x1E, 0x20, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0xE1, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0xE1, 0xFF, 0x8F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x77, 0xF3, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xDC, 0x07, 0x78, 0x3D, 0xE0, 0xF3, 0xFF, 0x87, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9E, 0x1F, 0x70, 0x3D, 0xC0, 0xF7, 0x83,
  0xDF, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xFC, 0x7C, 0x79, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0xCF, 0xDF, 0xFF, 0x3F, 0xDC,
  0x1C, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC3, 0xFF, 0x0F, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7B, 0xDE,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE, 0x77, 0xB9, 0xC0, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC0, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0xC7, 0xFF, 0x1F, 0xFC,
  0xE1, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x38, 0x7F, 0x8E, 0x70, 0xFF, 0x8E, 0x71, 0xE3, 0x86, 0x71, 0xC3, 0x87,
  0x63, 0x83, 0x87, 0x63, 0x83, 0x87, 0xE3, 0x83, 0x86, 0xE3, 0x83, 0x8E,
  0x61, 0xC7, 0x8E, 0x71, 0xFF, 0xFC, 0x70, 0xFC, 0xF8, 0x70, 0x38, 0x70,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3B, 0x80, 0x07, 0x78, 0x01, 0xE7, 0x00, 0x3C, 0xF0, 0x07, 0x1E,
  0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x07,
  0xBC, 0x00, 0xFF, 0x00, 0x1E, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x07,
  0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0xF9, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3D, 0xC0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0x0E, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1C, 0x3F, 0x8E,
  0x03, 0xE7, 0x00, 0xFB, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x3D, 0xC0,
  0x3E, 0xE0, 0x3E, 0x70, 0x7E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xE0, 0xE7, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBF, 0x03,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x1F, 0xDF, 0xFF,
  0xF8, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x9F, 0xFE, 0xFC, 0xF8, 0xE0, 0x1F, 0xE0, 0x3E, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0xC0, 0xE7, 0x80, 0xEF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFB, 0xC0, 0xE3, 0xE0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1F, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xDF, 0xB8, 0x0E,
  0xFD, 0xC0, 0x77, 0xEF, 0x07, 0x3F, 0x38, 0x39, 0xF9, 0xC1, 0xCF, 0xCF,
  0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xCF, 0x1F, 0x8F, 0x70, 0xFC, 0x3B, 0x87,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F,
  0x03, 0x80, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xBC, 0x0F, 0xCF, 0x07, 0xE7, 0x83, 0xF1, 0xE1, 0xF8,
  0xF0, 0xFC, 0x3C, 0x7E, 0x0F, 0x3F, 0x07, 0x9F, 0x81, 0xEF, 0xC0, 0xF7,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xF8, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x7D, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0xC1, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0xFE, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x83, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07, 0xC7,
  0xC0, 0x7D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0xC1, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xFC, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xE1, 0xF8,
  0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3E, 0xE0, 0x1F, 0x0F, 0xE0,
  0xFF, 0xE3, 0xFF, 0x9F, 0x0E, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0x81, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x80, 0xE1, 0xE0,
  0x38, 0x70, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x3D, 0xC0, 0x7C, 0x07, 0xBC, 0x0F, 0x80,
  0xF7, 0x81, 0xF8, 0x1C, 0xF0, 0x3F, 0x03, 0x8E, 0x0E, 0xE0, 0xF1, 0xE1,
  0xDE, 0x1E, 0x3C, 0x39, 0xC3, 0x83, 0x8F, 0x38, 0x70, 0x71, 0xC7, 0x1E,
  0x0F, 0x38, 0xF3, 0xC1, 0xE7, 0x0E, 0x70, 0x1D, 0xE1, 0xCE, 0x03, 0xB8,
  0x3B, 0xC0, 0x77, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x78, 0x03,
  0xDE, 0x01, 0xE3, 0xC0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0xF3, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x1E, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x79, 0xE0, 0x1E, 0xF8, 0x03, 0xC0, 0xF0, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78,
  0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0x9C, 0x07, 0x38,
  0x0C, 0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x1C, 0x0F, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x84, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xCF, 0xFF, 0x7F, 0xFD, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7D, 0xF7, 0xF7, 0xFD, 0xCF, 0xE7, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8,
  0x7B, 0xF8, 0xFF, 0xF9, 0xF0, 0xFB, 0xE0, 0xF7, 0x80, 0xEF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0x7B, 0xE0, 0xF7, 0xFF,
  0xCF, 0xFF, 0x9C, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0xF8, 0x27,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0xC1, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xE7, 0x8F, 0xFF, 0x3F, 0xFE,
  0xF8, 0x7D, 0xE0, 0x7B, 0xC0, 0xF7, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0x70, 0x1E, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF, 0xF3, 0xFE, 0xE1, 0xF9,
  0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xCE, 0x03,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x47, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x0F, 0xE3, 0xFC, 0xFF, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0xF7, 0xFE, 0xFF, 0xC7, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x8E, 0x3F, 0xDC, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xEF,
  0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0,
  0xF7, 0x83, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0xEF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7B, 0x01, 0xE7, 0xFF, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFE,
  0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x70, 0x6F, 0xF7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x06, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xFE, 0xFE, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xF8, 0x3C, 0xF0, 0xF1, 0xE3, 0xE3,
  0xCF, 0x87, 0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xF1,
  0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0,
  0xF8, 0xEF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFE, 0xFC, 0x7E, 0x1E, 0xF8, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xE3, 0xF3,
  0x9F, 0xEF, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xEF,
  0x03, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0xC0,
  0xF7, 0xC3, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0xE3, 0xE1, 0xEF, 0xF3,
  0xFF, 0xE7, 0xC3, 0xEF, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0xC1, 0xEF, 0x83, 0xDF, 0xFF, 0x3F, 0xFE,
  0x7B, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x8E, 0x3F, 0xDC, 0xFF, 0xFB, 0xE1, 0xF7,
  0x81, 0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0,
  0x7B, 0xC0, 0xF7, 0x83, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0xEF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0xE3, 0xF9, 0xFF, 0xFF, 0xFD, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xC3, 0xFF, 0x7F,
  0xEF, 0x02, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x00,
  0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x18, 0x0E, 0x03, 0x81,
  0xFF, 0xFF, 0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3F, 0xCF, 0xF1, 0xFC, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFD, 0xCF, 0xE7,
  0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x70,
  0x3C, 0x0E, 0x78, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x38,
  0x66, 0x1C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C, 0xE7, 0x38, 0x1D,
  0xC3, 0xB8, 0x1D, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x78, 0x1E,
  0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x78, 0x1E,
  0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x1F, 0x8F, 0x87, 0xC3, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x7F, 0x07, 0xC1, 0xF1, 0xF8, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC3, 0xF0, 0xF8, 0x20,
  0x00, 0x7F, 0x07, 0xFF, 0xFE, 0x7F, 0xE0, 0x3E,
};

const GFXglyph NotoSans_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 8, 13, 2, -21 },
  { 21, 17, 21, 19, 1, -21 },
  { 66, 14, 24, 17, 1, -22 },
  { 108, 23, 21, 25, 1, -21 },
  { 169, 21, 21, 22, 1, -21 },
  { 225, 3, 8, 7, 2, -21 },
  { 228, 8, 26, 9, 1, -21 },
  { 254, 7, 26, 9, 1, -21 },
  { 277, 14, 13, 16, 1, -22 },
  { 300, 14, 14, 17, 1, -17 },
  { 325, 5, 7, 8, 1, -3 },
  { 330, 7, 3, 9, 1, -9 },
  { 333, 4, 4, 8, 2, -4 },
  { 335, 11, 21, 12, 0, -21 },
  { 364, 14, 21, 17, 1, -21 },
  { 401, 9, 21, 17, 2, -21 },
  { 425, 14, 21, 17, 1, -21 },
  { 462, 14, 21, 17, 1, -21 },
  { 499, 15, 21, 17, 1, -21 },
  { 539, 13, 21, 17, 2, -21 },
  { 574, 14, 21, 17, 1, -21 },
  { 611, 14, 21, 17, 1, -21 },
  { 648, 14, 21, 17, 1, -21 },
  { 685, 14, 21, 17, 1, -21 },
  { 722, 4, 16, 8, 2, -16 },
  { 730, 5, 20, 8, 1, -16 },
  { 743, 14, 15, 17, 1, -18 },
  { 770, 14, 8, 17, 1, -14 },
  { 784, 14, 15, 17, 1, -18 },
  { 811, 13, 21, 13, 0, -21 },
  { 846, 24, 23, 26, 1, -21 },
  { 915, 19, 21, 19, 0, -21 },
  { 965, 15, 21, 19, 3, -21 },
  { 1005, 16, 21, 19, 2, -21 },
  { 1047, 17, 21, 21, 3, -21 },
  { 1092, 11, 21, 16, 3, -21 },
  { 1121, 11, 21, 16, 3, -21 },
  { 1150, 17, 21, 21, 2, -21 },
  { 1195, 16, 21, 22, 3, -21 },
  { 1237, 9, 21, 11, 1, -21 },
  { 1261, 8, 27, 9, -2, -21 },
  { 1288, 16, 21, 19, 3, -21 },
  { 1330, 12, 21, 16, 3, -21 },
  { 1362, 21, 21, 27, 3, -21 },
  { 1418, 17, 21, 23, 3, -21 },
  { 1463, 19, 21, 23, 2, -21 },
  { 1513, 14, 21, 18, 3, -21 },
  { 1550, 19, 26, 23, 2, -21 },
  { 1612, 16, 21, 19, 3, -21 },
  { 1654, 14, 21, 16, 1, -21 },
  { 1691, 16, 21, 17, 0, -21 },
  { 1733, 16, 21, 22, 3, -21 },
  { 1775, 18, 21, 18, 0, -21 },
  { 1823, 27, 21, 28, 0, -21 },
  { 1894, 18, 21, 19, 0, -21 },
  { 1942, 17, 21, 17, 0, -21 },
  { 1987, 15, 21, 17, 1, -21 },
  { 2027, 7, 26, 10, 2, -21 },
  { 2050, 11, 21, 12, 0, -21 },
  { 2079, 6, 26, 10, 1, -21 },
  { 2099, 15, 13, 17, 1, -21 },
  { 2124, 12, 2, 12, 0, 3 },
  { 2127, 8, 4, 10, 1, -22 },
  { 2131, 14, 16, 17, 1, -16 },
  { 2159, 15, 22, 18, 2, -22 },
  { 2201, 13, 16, 15, 1, -16 },
  { 2227, 15, 22, 18, 1, -22 },
  { 2269, 15, 16, 17, 1, -16 },
  { 2299, 11, 22, 11, 1, -22 },
  { 2330, 15, 23, 18, 1, -16 },
  { 2374, 14, 22, 19, 2, -22 },
  { 2413, 4, 22, 8, 2, -22 },
  { 2424, 8, 29, 8, -2, -22 },
  { 2453, 15, 22, 17, 2, -22 },
  { 2495, 4, 22, 8, 2, -22 },
  { 2506, 24, 16, 28, 2, -16 },
  { 2554, 14, 16, 19, 2, -16 },
  { 2582, 15, 16, 18, 1, -16 },
  { 2612, 15, 23, 18, 2, -16 },
  { 2656, 15, 23, 18, 1, -16 },
  { 2700, 10, 16, 13, 2, -16 },
  { 2720, 12, 16, 14, 1, -16 },
  { 2744, 10, 19, 12, 1, -19 },
  { 2768, 14, 16, 19, 2, -16 },
  { 2796, 16, 16, 16, 0, -16 },
  { 2828, 24, 16, 24, 0, -16 },
  { 2876, 16, 16, 16, 0, -16 },
  { 2908, 16, 23, 16, 0, -16 },
  { 2954, 12, 16, 14, 1, -16 },
  { 2978, 9, 26, 11, 1, -21 },
  { 3008, 2, 29, 16, 7, -22 },
  { 3016, 10, 26, 11, 1, -21 },
  { 3049, 14, 4, 17, 1, -12 },
};

const GFXfont NotoSans_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMIBOLD29PT7B_H_
