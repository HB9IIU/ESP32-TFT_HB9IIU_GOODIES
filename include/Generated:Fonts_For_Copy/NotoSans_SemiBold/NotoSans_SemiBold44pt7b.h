#ifndef _NOTOSANS_SEMIBOLD44PT7B_H_
#define _NOTOSANS_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0xDF, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC4, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x79, 0xE1, 0xE7, 0x07, 0x80, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE,
  0x70, 0x67, 0xE3, 0x80, 0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xE7, 0x00,
  0x3F, 0xB8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0x7F, 0x80, 0x38, 0xFC,
  0x01, 0xC3, 0xE0, 0x0E, 0x1F, 0x80, 0x70, 0xFF, 0x03, 0x8F, 0xFF, 0xDF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xC0,
  0x07, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xF0,
  0xF0, 0x0F, 0x00, 0x3C, 0x1F, 0x03, 0xE0, 0x07, 0x83, 0xE0, 0x78, 0x00,
  0xF0, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xF0, 0xF8,
  0x00, 0x78, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0xC7, 0xC0, 0x01, 0xE0, 0xF9,
  0xF1, 0xFC, 0x3E, 0x1E, 0x3C, 0x7F, 0xC3, 0xC7, 0xCF, 0x9F, 0xFC, 0x7F,
  0xF9, 0xE3, 0xEF, 0xC7, 0xFE, 0x7C, 0xF8, 0xF8, 0x7F, 0x8F, 0x1F, 0x0F,
  0x03, 0xC3, 0xE3, 0xC1, 0xF0, 0x00, 0x78, 0x78, 0x3E, 0x00, 0x1F, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xF0, 0x3C, 0x1F, 0x00, 0x3E,
  0x07, 0x83, 0xE0, 0x07, 0x80, 0xF0, 0x7C, 0x01, 0xF0, 0x1E, 0x0F, 0x00,
  0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x80, 0x3E, 0xFC, 0x01, 0xE0, 0x07, 0xFF,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x01, 0xF8, 0x7F, 0xFE, 0x03, 0xF1, 0xFE, 0xFE, 0x0F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x8F, 0xE0, 0xFE, 0x3E, 0x1F, 0x80, 0xFE, 0xFC, 0x3F, 0x00,
  0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x81, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDC, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20,
  0x3C, 0x05, 0xE1, 0xE1, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0x01, 0xC0, 0xE0,
  0x02, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C, 0xF1, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF1, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01,
  0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7, 0xF7, 0xFF, 0x9F, 0x78, 0x7C, 0xC1,
  0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0x03, 0xF8, 0xE0, 0x0F, 0xC2, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3E, 0x03, 0xF8, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFD, 0xF0, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF6, 0x00, 0x3F, 0xBF, 0x07, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x7F, 0x03, 0xE7, 0xFF, 0x0F, 0xBF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F, 0xE1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFD, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xE7, 0xF8, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0x83, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xBE, 0x1F, 0xF9, 0xF0, 0x3E, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0x10, 0x1F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x70, 0x0F,
  0xC8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x3F, 0xF0,
  0x78, 0xF8, 0x1F, 0xFF, 0x0F, 0x1E, 0x07, 0xFF, 0xE0, 0xF7, 0xC1, 0xF8,
  0x7C, 0x1E, 0xF0, 0x7C, 0x0F, 0x83, 0xDE, 0x0F, 0x01, 0xF0, 0x7B, 0xC3,
  0xE0, 0x3E, 0x0F, 0xF8, 0x7C, 0x07, 0xC1, 0xFE, 0x0F, 0x00, 0xF8, 0x3F,
  0xC1, 0xE0, 0x1F, 0x07, 0xF8, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xC0, 0x7C,
  0x1F, 0xF0, 0xF8, 0x1F, 0x87, 0xBE, 0x0F, 0x03, 0xF0, 0xF3, 0xC1, 0xF9,
  0xFF, 0x7C, 0x78, 0x1F, 0xFD, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0xE1, 0xF0,
  0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0x9F, 0x80, 0x3F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF9, 0xF8, 0x07, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x3C, 0x3F, 0x80, 0x04, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x04, 0x1F, 0xFC,
  0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xC3, 0xFC, 0x00,
  0x10, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x03, 0xF3, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xFD, 0xFF,
  0xCF, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7E,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xBF, 0xF7,
  0xC0, 0x07, 0xDF, 0xFB, 0xE0, 0x03, 0xCF, 0xFD, 0xF0, 0x01, 0xE7, 0xFE,
  0x7C, 0x01, 0xF3, 0xFF, 0x3E, 0x00, 0xF3, 0xFF, 0x9F, 0x00, 0xF9, 0xFF,
  0xC7, 0xC0, 0x7C, 0xFF, 0xE3, 0xE0, 0x3C, 0x7F, 0xF1, 0xF0, 0x3E, 0x3F,
  0xF8, 0x7C, 0x1F, 0x1F, 0xFC, 0x3E, 0x0F, 0x0F, 0xFE, 0x1F, 0x0F, 0x87,
  0xFF, 0x07, 0xC7, 0xC3, 0xFF, 0x83, 0xE3, 0xC1, 0xFF, 0xC1, 0xF3, 0xE0,
  0xFF, 0xE0, 0x7D, 0xF0, 0x7F, 0xF0, 0x3E, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFE,
  0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xDF, 0x80, 0x1F, 0xFB, 0xF0, 0x03, 0xFF, 0x3F, 0x00, 0x7F,
  0xE7, 0xF0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0x87, 0xE0, 0x3F, 0xF0, 0xFC,
  0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x1F, 0x83, 0xFF,
  0x01, 0xF8, 0x7F, 0xE0, 0x3F, 0x8F, 0xFC, 0x03, 0xF1, 0xFF, 0x80, 0x7F,
  0x3F, 0xF0, 0x07, 0xE7, 0xFE, 0x00, 0x7E, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0x7E, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB, 0xF0, 0x7F, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xFB, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF0, 0x1E, 0x7E, 0x00, 0x47, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F,
  0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x00, 0x0F,
  0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC3,
  0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x00,
  0xF7, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x0F, 0x81, 0xF3, 0xE0, 0x7C,
  0x03, 0xE0, 0xF8, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x87, 0xC3, 0xF0, 0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0x01, 0xF1, 0xF0,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF8,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0E, 0x07, 0xF0, 0x80, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xEF, 0x3F, 0xFC, 0xF1, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFC,
  0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xEF, 0xF0, 0x1F, 0xBF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0xFF,
  0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3E, 0x7F, 0xF8, 0xF8, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFC,
  0x7C, 0xFE, 0x00, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0x1F, 0xE1,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xE1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF, 0xFC, 0xFF, 0x1F,
  0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3,
  0xFF, 0x9F, 0x07, 0xFC, 0x3C, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x8F, 0xE0, 0x1C,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x3C, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xCF, 0xFF, 0xFF, 0x3F,
  0x87, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD,
  0xF0, 0xFF, 0xE7, 0xC1, 0xFF, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x20, 0x01, 0xF8, 0xE0, 0x0F, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x02, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x7B, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC3, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x08, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0xEF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E,
  0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xBF, 0x80, 0xFC, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x3E, 0x07, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7F, 0x3E,
  0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0x9F,
  0xFE, 0x3F, 0xFC, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x87, 0xFF, 0x8F, 0xEF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x7F, 0xC3, 0xE7, 0xFF, 0x8F,
  0xBF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xC3, 0xFB, 0xFC, 0x07, 0xEF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x00,
  0x7C, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xF8, 0x7F, 0x83,
  0xE3, 0xFF, 0x0F, 0xDF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xFB, 0xFC,
  0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xBF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC,
  0x3F, 0x1F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xCF, 0xFF, 0xFF, 0x3F, 0x87, 0xFD,
  0xFC, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF,
  0xE7, 0xC1, 0xFF, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x3F, 0xF8, 0xFE, 0xF9, 0xFE, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0x07, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC1, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x03, 0xE7, 0xE0,
  0x3F, 0xC0, 0x3E, 0x3E, 0x03, 0xFE, 0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x7E,
  0x3F, 0x07, 0xDE, 0x07, 0xC1, 0xF0, 0x7D, 0xE0, 0x7C, 0x1F, 0x07, 0x9F,
  0x0F, 0xC1, 0xF0, 0x79, 0xF0, 0xF8, 0x1F, 0x8F, 0x8F, 0x0F, 0x80, 0xF8,
  0xF8, 0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x9F, 0x80, 0xF8, 0xF0, 0xF9, 0xF0,
  0x0F, 0xDF, 0x07, 0x9F, 0x00, 0x7D, 0xF0, 0x79, 0xF0, 0x07, 0xDE, 0x07,
  0xFE, 0x00, 0x7D, 0xE0, 0x7F, 0xE0, 0x03, 0xDE, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F,
  0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0,
  0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFA, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 14, 11, 20, 3, -31 },
  { 45, 26, 31, 28, 1, -31 },
  { 146, 21, 36, 25, 2, -33 },
  { 241, 35, 32, 39, 2, -32 },
  { 381, 31, 32, 33, 2, -32 },
  { 505, 5, 11, 11, 3, -31 },
  { 512, 11, 38, 14, 2, -31 },
  { 565, 12, 38, 14, 1, -31 },
  { 622, 21, 20, 24, 1, -33 },
  { 675, 21, 21, 25, 2, -26 },
  { 731, 7, 11, 12, 2, -5 },
  { 741, 12, 5, 14, 1, -14 },
  { 749, 6, 7, 12, 3, -6 },
  { 755, 17, 32, 18, 0, -32 },
  { 823, 21, 32, 25, 2, -32 },
  { 907, 14, 31, 25, 3, -31 },
  { 962, 21, 32, 25, 2, -32 },
  { 1046, 21, 32, 25, 2, -32 },
  { 1130, 23, 32, 25, 1, -32 },
  { 1222, 21, 31, 25, 2, -31 },
  { 1304, 22, 32, 25, 2, -32 },
  { 1392, 22, 31, 25, 1, -31 },
  { 1478, 21, 32, 25, 2, -32 },
  { 1562, 21, 32, 25, 2, -32 },
  { 1646, 6, 25, 12, 3, -24 },
  { 1665, 8, 30, 12, 1, -24 },
  { 1695, 21, 22, 25, 2, -27 },
  { 1753, 21, 13, 25, 2, -22 },
  { 1788, 21, 22, 25, 2, -27 },
  { 1846, 19, 33, 20, 0, -32 },
  { 1925, 35, 36, 40, 2, -32 },
  { 2083, 30, 32, 30, 0, -32 },
  { 2203, 23, 31, 29, 4, -31 },
  { 2293, 24, 32, 28, 3, -32 },
  { 2389, 26, 31, 32, 4, -31 },
  { 2490, 18, 31, 25, 4, -31 },
  { 2560, 18, 31, 24, 4, -31 },
  { 2630, 26, 32, 32, 3, -32 },
  { 2734, 25, 31, 33, 4, -31 },
  { 2831, 13, 31, 16, 2, -31 },
  { 2882, 13, 40, 14, -3, -31 },
  { 2947, 24, 31, 28, 4, -31 },
  { 3040, 19, 31, 24, 4, -31 },
  { 3114, 33, 31, 41, 4, -31 },
  { 3242, 27, 31, 35, 4, -31 },
  { 3347, 29, 32, 35, 3, -32 },
  { 3463, 21, 31, 27, 4, -31 },
  { 3545, 29, 39, 35, 3, -32 },
  { 3687, 24, 31, 28, 4, -31 },
  { 3780, 20, 32, 24, 2, -32 },
  { 3860, 23, 31, 25, 1, -31 },
  { 3950, 25, 31, 33, 4, -31 },
  { 4047, 28, 31, 28, 0, -31 },
  { 4156, 42, 31, 42, 0, -31 },
  { 4319, 28, 31, 28, 0, -31 },
  { 4428, 27, 31, 27, 0, -31 },
  { 4533, 23, 31, 25, 1, -31 },
  { 4623, 10, 38, 15, 3, -31 },
  { 4671, 17, 32, 18, 0, -32 },
  { 4739, 10, 38, 15, 1, -31 },
  { 4787, 23, 21, 25, 1, -32 },
  { 4848, 19, 3, 19, 0, 4 },
  { 4856, 11, 7, 15, 2, -34 },
  { 4866, 20, 24, 26, 2, -24 },
  { 4926, 22, 33, 28, 3, -33 },
  { 5017, 19, 24, 22, 2, -24 },
  { 5074, 22, 33, 28, 2, -33 },
  { 5165, 22, 24, 26, 2, -24 },
  { 5231, 17, 34, 16, 1, -34 },
  { 5304, 22, 35, 28, 2, -24 },
  { 5401, 22, 33, 28, 3, -33 },
  { 5492, 6, 33, 12, 3, -33 },
  { 5517, 11, 44, 12, -2, -33 },
  { 5578, 22, 33, 26, 4, -33 },
  { 5669, 6, 33, 12, 3, -33 },
  { 5694, 36, 24, 42, 3, -24 },
  { 5802, 22, 24, 28, 3, -24 },
  { 5868, 23, 24, 27, 2, -24 },
  { 5937, 22, 35, 28, 3, -24 },
  { 6034, 22, 35, 28, 2, -24 },
  { 6131, 16, 24, 19, 3, -24 },
  { 6179, 18, 24, 22, 2, -24 },
  { 6233, 16, 29, 18, 1, -29 },
  { 6291, 22, 24, 28, 3, -24 },
  { 6357, 24, 24, 24, 0, -24 },
  { 6429, 36, 24, 37, 0, -24 },
  { 6537, 24, 24, 25, 0, -24 },
  { 6609, 24, 35, 24, 0, -24 },
  { 6714, 19, 24, 21, 1, -24 },
  { 6771, 14, 38, 17, 1, -31 },
  { 6838, 4, 43, 24, 10, -33 },
  { 6860, 14, 38, 17, 2, -31 },
  { 6927, 21, 7, 25, 2, -19 },
};

const GFXfont NotoSans_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMIBOLD44PT7B_H_
