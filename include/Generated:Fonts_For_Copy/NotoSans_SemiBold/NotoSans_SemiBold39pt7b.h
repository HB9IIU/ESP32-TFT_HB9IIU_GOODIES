#ifndef _NOTOSANS_SEMIBOLD39PT7B_H_
#define _NOTOSANS_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x79, 0xE7, 0x80, 0x00, 0x01, 0x1F, 0xFF, 0xFF, 0xDF, 0x10, 0xF8,
  0xFB, 0xC7, 0xDE, 0x3E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0xC1, 0x9F, 0x18,
  0x03, 0xE3, 0x00, 0x7C, 0x60, 0x0F, 0xEC, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x67,
  0xE0, 0x0C, 0x7C, 0x01, 0x87, 0xE0, 0x30, 0xF7, 0x06, 0x3E, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0xE0, 0x07,
  0x80, 0x3F, 0xF0, 0x0F, 0x00, 0x7C, 0xF0, 0x0F, 0x00, 0x78, 0x78, 0x1E,
  0x00, 0x78, 0x78, 0x1E, 0x00, 0x70, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x78, 0x00, 0x70, 0x78, 0xF0,
  0x00, 0x78, 0x79, 0xE3, 0xF0, 0x78, 0x79, 0xE7, 0xF8, 0x7C, 0xF3, 0xCF,
  0xFC, 0x3F, 0xF3, 0xCF, 0x3E, 0x1F, 0xE7, 0x8F, 0x1E, 0x0F, 0xC7, 0x9E,
  0x1E, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x1E,
  0x1E, 0x00, 0x78, 0x0E, 0x1E, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0xF0, 0x0F,
  0xFC, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0x8F, 0xFE, 0x03, 0xE3,
  0xFF, 0xE0, 0x7C, 0x7E, 0x7E, 0x0F, 0x9F, 0x87, 0xE3, 0xE3, 0xE0, 0x7E,
  0x7C, 0x7C, 0x07, 0xFF, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x07, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0x7E, 0x07, 0xFE, 0x07, 0xF0, 0xFB, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xC0, 0x07, 0x87, 0xC3, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x1E, 0x38, 0x73, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xC7,
  0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x80, 0xC1, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x79, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xFF, 0xFF, 0xFD, 0xF1,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3F, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x0F, 0x9F, 0x03,
  0xF3, 0xF0, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF7, 0xFF, 0xFD, 0xFF,
  0x9F, 0x71, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC1, 0xF8, 0xE0, 0x1F, 0x88, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0x81, 0xF8, 0x40, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF6, 0x00, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC4, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE1, 0xE0, 0x7D, 0xFF, 0x8F, 0x7F, 0xF9, 0xFF, 0xFF, 0x3F,
  0x83, 0xF7, 0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF3,
  0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xFC, 0x7C, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7E, 0x1F, 0x9F,
  0x81, 0xFB, 0xE0, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xC1, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xDF,
  0xFF, 0xFB, 0xFF, 0xDE, 0x3F, 0xF3, 0xC1, 0xFC, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x31, 0xFF, 0xFF,
  0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xFF, 0xFF,
  0xFD, 0xF1, 0x00, 0x18, 0x7D, 0xFB, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3C,
  0x78, 0xE3, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0x81, 0xF9, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1E, 0x1F, 0x00, 0xE0, 0x1E, 0x3C, 0x0F, 0xFE, 0x3C, 0xF0,
  0x7F, 0xFC, 0x39, 0xE0, 0xFD, 0xF8, 0x7B, 0x83, 0xE0, 0xF0, 0xFF, 0x0F,
  0x81, 0xE1, 0xFE, 0x1E, 0x03, 0xC3, 0xFC, 0x3C, 0x07, 0x87, 0xF8, 0x78,
  0x0E, 0x0F, 0xF0, 0xF0, 0x3C, 0x1F, 0xE1, 0xE0, 0x78, 0x3F, 0xC3, 0xC0,
  0xF0, 0x77, 0x87, 0x83, 0xF1, 0xEF, 0x07, 0xDF, 0xF7, 0x8E, 0x0F, 0xFD,
  0xFF, 0x1E, 0x0F, 0xF1, 0xFC, 0x3C, 0x07, 0x80, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x7F, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0, 0xFF, 0x7E, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xF9, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x1F,
  0x87, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0x70,
  0xFE, 0x00, 0x43, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x0E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xC1, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFE, 0x7E, 0x0F, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x01,
  0xC3, 0xF0, 0x00, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x03, 0xE7, 0xE0,
  0x07, 0xCF, 0xE0, 0x0F, 0x8F, 0xE0, 0x1F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE8, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x3E,
  0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F,
  0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0xF0, 0x03, 0xDF, 0xF7, 0x80, 0x1E, 0xFF, 0xBE,
  0x01, 0xF7, 0xFC, 0xF0, 0x0F, 0x3F, 0xE7, 0x80, 0x79, 0xFF, 0x3E, 0x07,
  0x8F, 0xF8, 0xF0, 0x3C, 0x7F, 0xC7, 0x81, 0xE3, 0xFE, 0x3E, 0x1E, 0x1F,
  0xF0, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0x87, 0xFC, 0x3E, 0x78, 0x3F, 0xE0,
  0xF3, 0xC1, 0xFF, 0x07, 0x9E, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x80, 0xFC, 0x07,
  0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xFB, 0xE0, 0x0F, 0xF7, 0xE0, 0x1F, 0xE7, 0xC0,
  0x3F, 0xC7, 0xC0, 0x7F, 0x8F, 0xC0, 0xFF, 0x0F, 0x81, 0xFE, 0x1F, 0x83,
  0xFC, 0x1F, 0x07, 0xF8, 0x1F, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x3E, 0x3F,
  0xC0, 0x7E, 0x7F, 0x80, 0x7E, 0xFF, 0x00, 0x7D, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC3, 0xFD,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF9, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFC, 0x1F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07,
  0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7E, 0x07, 0x3F, 0x00, 0x4F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7E,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x07, 0xDF, 0x00, 0x7F,
  0x00, 0x7C, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x1E,
  0x00, 0xFE, 0x00, 0xF8, 0xF8, 0x0F, 0x78, 0x0F, 0x87, 0xC0, 0x7B, 0xC0,
  0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xE0, 0xF0, 0x1E, 0xF8, 0x1F, 0x07, 0xC1,
  0xF7, 0xC1, 0xF0, 0x3E, 0x0F, 0x1E, 0x0F, 0x81, 0xF0, 0x78, 0xF0, 0x7C,
  0x07, 0x87, 0xC7, 0xC3, 0xE0, 0x3E, 0x3E, 0x1E, 0x1E, 0x01, 0xF1, 0xE0,
  0xF1, 0xF0, 0x0F, 0x8F, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x3E, 0x78, 0x01,
  0xF7, 0x80, 0xF3, 0xC0, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x3D,
  0xF0, 0x01, 0xEF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC7, 0xC0, 0x03,
  0xE7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xDF, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0,
  0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03,
  0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x40, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E, 0x1F, 0x84, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0x7F, 0xF3, 0xC7, 0xF8, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x30, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFB, 0xFD, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0x3F, 0xF1, 0xE3, 0xFC, 0x00, 0x00, 0x20,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7E, 0x02, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0x3F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x83, 0xE1, 0xFE, 0x7C, 0x7F, 0xF7, 0x9F, 0xFE, 0xF7, 0xFF,
  0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0x9F, 0xFE,
  0xF1, 0xFF, 0x9E, 0x1F, 0xE3, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x00, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x08, 0xFF, 0xBF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xF8, 0x43, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x83,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xFE,
  0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7, 0xFB, 0xFE, 0xFC, 0x0F, 0xDF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0x9F, 0xFE, 0xF1, 0xFF, 0xBE, 0x1F, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7D, 0x80, 0x1F,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x10, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0xFF, 0xFF,
  0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xFF,
  0xFF, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F,
  0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0x80,
  0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x80, 0xF1, 0xFE, 0x0F, 0xF8, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xBF, 0xFF, 0xFE, 0xFE,
  0x0F, 0xF0, 0x3E, 0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x3E, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x10, 0x1E, 0x3F, 0xE3,
  0xCF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xC0,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x9F,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x1E, 0x3F, 0xC3,
  0xCF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFB, 0xFD, 0xFC, 0x0F, 0xBF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xBF, 0xF1, 0xF3, 0xFC, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xFE, 0x3C, 0x7F, 0xF7, 0x9F, 0xFE, 0xF7, 0xFB, 0xFE, 0xFC, 0x0F, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0x9F, 0xFE, 0xF1, 0xFF, 0xBE, 0x1F,
  0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x17, 0x87, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0x80, 0x1F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x1C, 0xF8, 0x04, 0xF8,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0xFC,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x9F, 0xFC, 0xF1, 0xFF, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x78,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x1E, 0x7C,
  0x07, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x3E, 0x3E,
  0x0F, 0x70, 0x3C, 0x3E, 0x0F, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x7C, 0x1F,
  0x1E, 0x78, 0x78, 0x1F, 0x1E, 0x3C, 0x78, 0x1F, 0x1E, 0x3C, 0xF8, 0x0F,
  0x3C, 0x3C, 0xF8, 0x0F, 0xBC, 0x3C, 0xF0, 0x0F, 0xBC, 0x1C, 0xF0, 0x0F,
  0xB8, 0x1F, 0xF0, 0x07, 0xB8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF9, 0xF0, 0x1F, 0x87, 0xC0, 0xF8, 0x3F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x3E, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xC0,
  0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0xFC, 0x03, 0xEF, 0xC0, 0x0F, 0x80, 0xF8,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80,
  0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x7E, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x0F,
  0xC1, 0xFE, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 29, 11, 2, -28 },
  { 23, 13, 10, 18, 2, -28 },
  { 40, 23, 28, 25, 1, -28 },
  { 121, 19, 32, 22, 2, -30 },
  { 197, 32, 28, 34, 1, -28 },
  { 309, 27, 28, 29, 2, -28 },
  { 404, 5, 10, 10, 2, -28 },
  { 411, 9, 34, 13, 2, -28 },
  { 450, 10, 34, 13, 1, -28 },
  { 493, 19, 18, 21, 1, -30 },
  { 536, 18, 19, 22, 2, -23 },
  { 579, 7, 10, 11, 1, -5 },
  { 588, 10, 5, 12, 1, -13 },
  { 595, 6, 7, 11, 2, -6 },
  { 601, 15, 28, 16, 0, -28 },
  { 654, 19, 28, 22, 2, -28 },
  { 721, 12, 28, 22, 3, -28 },
  { 763, 19, 28, 22, 2, -28 },
  { 830, 19, 28, 22, 2, -28 },
  { 897, 21, 28, 22, 1, -28 },
  { 971, 18, 28, 22, 2, -28 },
  { 1034, 19, 28, 22, 2, -28 },
  { 1101, 20, 28, 22, 1, -28 },
  { 1171, 19, 28, 22, 2, -28 },
  { 1238, 19, 28, 22, 2, -28 },
  { 1305, 6, 23, 11, 2, -22 },
  { 1323, 7, 27, 11, 1, -22 },
  { 1347, 18, 20, 22, 2, -24 },
  { 1392, 18, 11, 22, 2, -19 },
  { 1417, 18, 20, 22, 2, -24 },
  { 1462, 17, 29, 18, 0, -28 },
  { 1524, 31, 31, 35, 2, -28 },
  { 1645, 26, 28, 26, 0, -28 },
  { 1736, 21, 28, 26, 3, -28 },
  { 1810, 22, 28, 25, 2, -28 },
  { 1887, 23, 28, 29, 3, -28 },
  { 1968, 15, 28, 22, 4, -28 },
  { 2021, 15, 28, 21, 4, -28 },
  { 2074, 23, 28, 28, 2, -28 },
  { 2155, 22, 28, 29, 4, -28 },
  { 2232, 12, 28, 14, 1, -28 },
  { 2274, 12, 36, 12, -3, -28 },
  { 2328, 21, 28, 25, 4, -28 },
  { 2402, 17, 28, 21, 3, -28 },
  { 2462, 29, 28, 36, 4, -28 },
  { 2564, 23, 28, 31, 4, -28 },
  { 2645, 26, 28, 31, 2, -28 },
  { 2736, 19, 28, 24, 3, -28 },
  { 2803, 26, 35, 31, 2, -28 },
  { 2917, 22, 28, 25, 3, -28 },
  { 2994, 18, 28, 21, 2, -28 },
  { 3057, 21, 28, 22, 1, -28 },
  { 3131, 23, 28, 29, 3, -28 },
  { 3212, 25, 28, 25, 0, -28 },
  { 3300, 37, 28, 37, 0, -28 },
  { 3430, 25, 28, 25, 0, -28 },
  { 3518, 24, 28, 24, 0, -28 },
  { 3602, 20, 28, 22, 1, -28 },
  { 3672, 9, 34, 13, 3, -28 },
  { 3711, 15, 28, 16, 0, -28 },
  { 3764, 9, 34, 13, 1, -28 },
  { 3803, 20, 18, 22, 1, -28 },
  { 3848, 17, 2, 17, 0, 4 },
  { 3853, 9, 6, 13, 2, -30 },
  { 3860, 18, 22, 23, 2, -22 },
  { 3910, 19, 30, 24, 3, -30 },
  { 3982, 16, 22, 20, 2, -22 },
  { 4026, 19, 30, 24, 2, -30 },
  { 4098, 19, 22, 23, 2, -22 },
  { 4151, 15, 30, 14, 1, -30 },
  { 4208, 19, 31, 24, 2, -22 },
  { 4282, 19, 30, 25, 3, -30 },
  { 4354, 5, 29, 11, 3, -29 },
  { 4373, 10, 38, 11, -2, -29 },
  { 4421, 20, 30, 23, 3, -30 },
  { 4496, 5, 30, 11, 3, -30 },
  { 4515, 32, 22, 37, 3, -22 },
  { 4603, 19, 22, 25, 3, -22 },
  { 4656, 20, 22, 24, 2, -22 },
  { 4711, 19, 31, 24, 3, -22 },
  { 4785, 19, 31, 24, 2, -22 },
  { 4859, 13, 22, 17, 3, -22 },
  { 4895, 16, 22, 19, 2, -22 },
  { 4939, 14, 26, 16, 1, -26 },
  { 4985, 19, 21, 25, 3, -21 },
  { 5035, 21, 21, 21, 0, -21 },
  { 5091, 32, 21, 32, 0, -21 },
  { 5175, 21, 21, 22, 0, -21 },
  { 5231, 21, 30, 21, 0, -21 },
  { 5310, 17, 21, 19, 1, -21 },
  { 5355, 13, 34, 15, 1, -28 },
  { 5411, 4, 39, 21, 9, -30 },
  { 5431, 13, 34, 15, 1, -28 },
  { 5487, 18, 6, 22, 2, -17 },
};

const GFXfont NotoSans_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMIBOLD39PT7B_H_
