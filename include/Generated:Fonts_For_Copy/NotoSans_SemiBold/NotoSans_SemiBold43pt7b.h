#ifndef _NOTOSANS_SEMIBOLD43PT7B_H_
#define _NOTOSANS_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC8, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x7B, 0xE1, 0xEF,
  0x87, 0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0x73, 0xE7, 0xE3, 0x82, 0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00,
  0x3F, 0x38, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x39, 0xF8,
  0x01, 0xC7, 0xE0, 0x0E, 0x3F, 0x00, 0x71, 0xFE, 0x03, 0x8F, 0xBF, 0x1F,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x80, 0x3C, 0x1E,
  0x03, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0xF0,
  0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x87, 0xC0, 0x03,
  0xC1, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0xF8, 0x78, 0x3C, 0x1E, 0x3C, 0x7F,
  0x8F, 0x8F, 0x9F, 0x3F, 0xF1, 0xFF, 0xC7, 0x9F, 0xFE, 0x7F, 0xF3, 0xE7,
  0xC7, 0x8F, 0xF8, 0xF1, 0xE1, 0xF0, 0xFC, 0x78, 0xF8, 0x7C, 0x00, 0x3E,
  0x3E, 0x0F, 0x00, 0x0F, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xC0, 0xF0, 0x01,
  0xE0, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x87, 0xC0,
  0x1F, 0x01, 0xE1, 0xF0, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x1F, 0x3E,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x7C, 0x3F, 0xFE, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xE3, 0xF8, 0x3E,
  0x3F, 0x87, 0xF1, 0xF8, 0xFC, 0x0F, 0xE7, 0xC3, 0xF0, 0x1F, 0xFF, 0x0F,
  0xC0, 0x3F, 0xF8, 0x3F, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xBC, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0, 0x4F, 0x8E, 0x3F,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0x3E, 0x03, 0xC1, 0xE0, 0x06, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF2, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF9, 0xFE, 0x3F,
  0x03, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xF7, 0xFF, 0xBF, 0x7C, 0xFD,
  0xE3, 0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3E, 0x03, 0xF0, 0xC0, 0x0F, 0xC4, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xF1, 0xFE, 0x1C, 0x03, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF4, 0x00, 0x3F, 0xBC, 0x03, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xFB,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xE0,
  0x78, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x18, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x02,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x38, 0x0F, 0x8F, 0xF8, 0x7D, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E,
  0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x1F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFD, 0xFE, 0x1F, 0xC3,
  0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x80, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0x03,
  0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xEF, 0xE1, 0xFF, 0x7F, 0xFE, 0xF9, 0xFF, 0xF7, 0xC7, 0xFF, 0x7C, 0x0F,
  0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xFF, 0x20, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF3, 0xFC, 0x60, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0xF8, 0x07, 0x8F, 0x81, 0xFF, 0xE1, 0xE3, 0xC0, 0xFF, 0xF8,
  0x3D, 0xF0, 0x7F, 0xFE, 0x0F, 0x78, 0x3E, 0x07, 0x83, 0xDE, 0x0F, 0x01,
  0xE0, 0xF7, 0x87, 0xC0, 0x78, 0x3F, 0xE1, 0xE0, 0x1E, 0x0F, 0xF0, 0x78,
  0x07, 0x83, 0xFC, 0x1E, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x78, 0x3F, 0xC1,
  0xE0, 0x3E, 0x0F, 0xF0, 0x78, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xE1, 0xEF,
  0x83, 0xE3, 0xFC, 0xF9, 0xE0, 0xFF, 0xEF, 0xFC, 0x78, 0x1F, 0xF9, 0xFE,
  0x1F, 0x03, 0xF8, 0x3F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xE0, 0x0F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3, 0xE0,
  0x1F, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x81, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0E, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x02, 0x1F, 0xF8, 0x3E, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xC0, 0x3F, 0xE3, 0xE0, 0x07, 0xF9, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xFD, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0xFE, 0x7C, 0x01, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x30, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xFC, 0x0F,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0x07, 0xC0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xDF, 0xFB, 0xC0, 0x07, 0xDF,
  0xFB, 0xE0, 0x07, 0xDF, 0xFB, 0xE0, 0x07, 0x9F, 0xF9, 0xE0, 0x0F, 0x9F,
  0xF9, 0xF0, 0x0F, 0x9F, 0xF9, 0xF0, 0x0F, 0x1F, 0xF8, 0xF0, 0x1F, 0x1F,
  0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x1E, 0x1F, 0xF8, 0x78, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3C, 0x1F, 0xF8, 0x7C, 0x3C, 0x1F, 0xF8, 0x3C, 0x7C, 0x1F,
  0xF8, 0x3E, 0x78, 0x1F, 0xF8, 0x3E, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFB, 0xF0, 0x07, 0xFE, 0xFC, 0x01,
  0xFF, 0x9F, 0x80, 0x7F, 0xE3, 0xF0, 0x1F, 0xF8, 0xFC, 0x07, 0xFE, 0x1F,
  0x81, 0xFF, 0x87, 0xE0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x1F, 0x87, 0xFE,
  0x07, 0xE1, 0xFF, 0x80, 0xFC, 0x7F, 0xE0, 0x3F, 0x1F, 0xF8, 0x07, 0xE7,
  0xFE, 0x00, 0xFD, 0xFF, 0x80, 0x3F, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7C, 0x07, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0x7C, 0x01, 0xFB, 0xE0, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFE, 0x3E,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xE0, 0x0C, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x7E, 0xFC, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xBE,
  0x00, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF1, 0xF0, 0x07, 0xFC, 0x01,
  0xF0, 0xF8, 0x03, 0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x3F,
  0x00, 0xF7, 0x80, 0x7E, 0x0F, 0x80, 0xFB, 0xE0, 0x3E, 0x07, 0xC0, 0x7D,
  0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0xF8, 0x0F, 0x81, 0xF8, 0x3E, 0x3C, 0x0F,
  0xC0, 0x7C, 0x1F, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x1F,
  0x07, 0x87, 0xC1, 0xF0, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x03, 0xE3, 0xE0,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x1E, 0x3E,
  0x00, 0x7E, 0xF8, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00,
  0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x78,
  0x07, 0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x8F, 0xE0,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF8, 0xF1, 0xFF, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0xF8, 0x0F, 0xCF, 0xF8, 0x3F, 0x7F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xE0,
  0x1F, 0xBF, 0x80, 0xFE, 0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xCF, 0xBF, 0xFE,
  0x3E, 0x7F, 0xF0, 0xF8, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xE0, 0x67, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x04, 0xFE, 0x07, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xC3, 0xF0, 0x7F, 0xCF, 0xC7, 0xFF, 0xBF, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0x9F, 0x07, 0xF8, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0x81, 0xF9, 0xF8,
  0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF1, 0xF1, 0xFF, 0xE7, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC,
  0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0xDF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xEF,
  0xC1, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x20, 0x01, 0xF8, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xF0, 0x3F, 0x3F, 0xF1,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x7B, 0xFF,
  0xFF, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x1F, 0xBF, 0xF7, 0xFE, 0xFF, 0x9F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xDF, 0x80, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E,
  0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x78, 0x1F, 0x1F, 0xF0, 0x7F,
  0xE3, 0xE7, 0xFF, 0x9F, 0xFE, 0x7D, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x7F,
  0xF0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x3F, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x0F,
  0x80, 0x1F, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xF0,
  0x07, 0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x3F,
  0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0xBF, 0xE1, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xDF,
  0xFC, 0x3F, 0x3F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF1, 0xF1, 0xFF, 0xE7, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC, 0x0F,
  0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0xDF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xEF, 0xC1,
  0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xEF,
  0xE1, 0xF7, 0xE0, 0x1B, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xE1, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC1,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0x9F, 0xFF, 0x7C, 0x3F, 0xE1, 0xE0,
  0xFC, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xEF, 0x80, 0x7F, 0x00, 0xFD, 0xF8, 0x0F, 0xF0, 0x1F, 0x1F, 0x01,
  0xFE, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x7C, 0x0F, 0x78, 0x1F, 0x8F,
  0xC1, 0xEF, 0x83, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x1F, 0x0F, 0x9E, 0x0F,
  0x83, 0xE1, 0xF3, 0xE3, 0xE0, 0x7E, 0x3C, 0x7C, 0x7C, 0x07, 0xC7, 0x87,
  0x8F, 0x80, 0xF9, 0xF0, 0xF3, 0xF0, 0x1F, 0x3C, 0x1F, 0x7C, 0x01, 0xF7,
  0x83, 0xEF, 0x80, 0x3E, 0xF0, 0x3D, 0xF0, 0x07, 0xDE, 0x07, 0xBC, 0x00,
  0xFF, 0x80, 0xF7, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x83,
  0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xFC,
  0x3F, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x40, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 14, 11, 19, 3, -31 },
  { 45, 26, 31, 28, 1, -31 },
  { 146, 21, 36, 25, 2, -33 },
  { 241, 34, 31, 38, 2, -31 },
  { 373, 30, 31, 32, 2, -31 },
  { 490, 5, 11, 11, 3, -31 },
  { 497, 11, 38, 14, 2, -31 },
  { 550, 11, 38, 14, 1, -31 },
  { 603, 21, 20, 23, 1, -33 },
  { 656, 21, 21, 25, 2, -26 },
  { 712, 8, 11, 12, 1, -5 },
  { 723, 11, 5, 14, 1, -14 },
  { 730, 6, 7, 12, 3, -6 },
  { 736, 17, 31, 17, 0, -31 },
  { 802, 21, 31, 25, 2, -31 },
  { 884, 14, 31, 25, 3, -31 },
  { 939, 21, 31, 25, 2, -31 },
  { 1021, 21, 31, 25, 2, -31 },
  { 1103, 23, 31, 25, 1, -31 },
  { 1193, 20, 31, 25, 2, -31 },
  { 1271, 21, 31, 25, 2, -31 },
  { 1353, 22, 31, 25, 1, -31 },
  { 1439, 21, 31, 25, 2, -31 },
  { 1521, 21, 31, 25, 2, -31 },
  { 1603, 6, 25, 12, 3, -24 },
  { 1622, 8, 30, 12, 1, -24 },
  { 1652, 21, 22, 25, 2, -27 },
  { 1710, 20, 12, 25, 2, -21 },
  { 1740, 21, 22, 25, 2, -27 },
  { 1798, 19, 32, 20, 0, -31 },
  { 1874, 34, 35, 39, 2, -31 },
  { 2023, 29, 31, 29, 0, -31 },
  { 2136, 22, 31, 28, 4, -31 },
  { 2222, 24, 31, 27, 2, -31 },
  { 2315, 25, 31, 31, 4, -31 },
  { 2412, 17, 31, 24, 4, -31 },
  { 2478, 17, 31, 23, 4, -31 },
  { 2544, 25, 31, 31, 3, -31 },
  { 2641, 25, 31, 33, 4, -31 },
  { 2738, 13, 31, 16, 1, -31 },
  { 2789, 12, 40, 13, -3, -31 },
  { 2849, 24, 31, 28, 4, -31 },
  { 2942, 18, 31, 23, 4, -31 },
  { 3012, 32, 31, 40, 4, -31 },
  { 3136, 26, 31, 34, 4, -31 },
  { 3237, 29, 31, 34, 2, -31 },
  { 3350, 21, 31, 26, 4, -31 },
  { 3432, 29, 38, 34, 2, -31 },
  { 3570, 23, 31, 28, 4, -31 },
  { 3660, 20, 31, 24, 2, -31 },
  { 3738, 23, 31, 24, 1, -31 },
  { 3828, 24, 31, 32, 4, -31 },
  { 3921, 27, 31, 27, 0, -31 },
  { 4026, 41, 31, 41, 0, -31 },
  { 4185, 27, 31, 27, 0, -31 },
  { 4290, 26, 31, 26, 0, -31 },
  { 4391, 23, 31, 25, 1, -31 },
  { 4481, 10, 38, 14, 3, -31 },
  { 4529, 17, 31, 17, 0, -31 },
  { 4595, 10, 38, 14, 1, -31 },
  { 4643, 22, 20, 25, 1, -31 },
  { 4698, 18, 3, 18, 0, 4 },
  { 4705, 11, 7, 14, 2, -33 },
  { 4715, 20, 24, 25, 2, -24 },
  { 4775, 22, 33, 27, 3, -33 },
  { 4866, 18, 24, 22, 2, -24 },
  { 4920, 22, 33, 27, 2, -33 },
  { 5011, 21, 24, 25, 2, -24 },
  { 5074, 17, 33, 16, 1, -33 },
  { 5145, 22, 34, 27, 2, -24 },
  { 5239, 21, 33, 27, 3, -33 },
  { 5326, 6, 32, 12, 3, -32 },
  { 5350, 11, 42, 12, -2, -32 },
  { 5408, 22, 33, 25, 3, -33 },
  { 5499, 6, 33, 12, 3, -33 },
  { 5524, 35, 24, 41, 3, -24 },
  { 5629, 21, 24, 27, 3, -24 },
  { 5692, 22, 24, 27, 2, -24 },
  { 5758, 22, 34, 27, 3, -24 },
  { 5852, 22, 34, 27, 2, -24 },
  { 5946, 15, 24, 19, 3, -24 },
  { 5991, 17, 24, 21, 2, -24 },
  { 6042, 15, 28, 17, 1, -28 },
  { 6095, 21, 23, 27, 3, -23 },
  { 6156, 24, 23, 24, 0, -23 },
  { 6225, 35, 23, 36, 0, -23 },
  { 6326, 24, 23, 24, 0, -23 },
  { 6395, 24, 33, 24, 0, -23 },
  { 6494, 18, 23, 21, 1, -23 },
  { 6546, 14, 38, 17, 1, -31 },
  { 6613, 4, 43, 24, 10, -33 },
  { 6635, 14, 38, 17, 2, -31 },
  { 6702, 21, 6, 25, 2, -18 },
};

const GFXfont NotoSans_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMIBOLD43PT7B_H_
