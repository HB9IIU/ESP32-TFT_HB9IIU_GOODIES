#ifndef _NOTOSANS_SEMIBOLD51PT7B_H_
#define _NOTOSANS_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x18, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x38, 0x38, 0xFC,
  0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFE,
  0x38, 0x00, 0xFF, 0xB8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3B, 0xFE, 0x00, 0x38, 0xFF, 0x00, 0x38, 0x7F, 0x00,
  0x38, 0x7F, 0x00, 0x38, 0x7F, 0x80, 0x38, 0x7F, 0xE0, 0x38, 0xFE, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x1F, 0x1F, 0xFC, 0x3E,
  0x1F, 0x9F, 0x9F, 0xFE, 0x1F, 0xDF, 0x8F, 0x8F, 0xFF, 0x87, 0xFF, 0xCF,
  0xCF, 0xC7, 0xE1, 0xFF, 0xC7, 0xC7, 0xC1, 0xF0, 0x7F, 0xC7, 0xC3, 0xE0,
  0xF8, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC1,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xFC, 0x01, 0xFC,
  0x1F, 0xFF, 0xE0, 0x1F, 0x83, 0xFC, 0xFF, 0x03, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0xC7, 0xF0, 0x7E, 0x01, 0xFE, 0x7F, 0x0F, 0xE0,
  0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0x83, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFB, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0xC0, 0x3C, 0x06, 0xFC, 0x3C, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0x81, 0xC0,
  0x00, 0x81, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xBF, 0xFE, 0x3F, 0x7C, 0x3F, 0x78, 0x3F, 0x30, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x78, 0x00, 0xFE, 0x18,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0x3F,
  0xF0, 0xF0, 0x03, 0xF8, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFA, 0x00, 0x03, 0xFD, 0xE0, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3E, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xE0,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x80, 0x01, 0xFE, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x30, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0x80,
  0xF8, 0xFF, 0xF0, 0xFC, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xDF, 0xF8, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF1,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0xF7, 0xFF,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xE1, 0xFE,
  0x03, 0xF8, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x7F,
  0xDF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0xFF, 0xFC,
  0xFC, 0x1F, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x3F, 0x1F, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0x3F, 0xF3, 0xC0, 0x1F, 0xC8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0xC0, 0x7E, 0x3E, 0x01, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xF8, 0x3E,
  0x7C, 0x07, 0xFF, 0xF8, 0x1F, 0x7C, 0x0F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0xF8, 0x3E, 0x01, 0xF8, 0x3E,
  0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0xF8, 0x1F, 0x83, 0xFC, 0x7C, 0xF8, 0x1F,
  0xFF, 0xBF, 0xFC, 0xF8, 0x0F, 0xFF, 0x3F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F,
  0xF0, 0x7C, 0x03, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xEF, 0xC0, 0x07, 0xFB, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xEF,
  0xC0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x01, 0xC1, 0xFE, 0x00, 0x04, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x21, 0xFF, 0xC0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0x9F, 0x80, 0x03,
  0xFC, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x3F, 0xCF, 0xC0, 0x03, 0xFE, 0x7E, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0x07, 0xFC, 0x00,
  0x04, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFF, 0x00, 0x03, 0xF1,
  0xFF, 0x00, 0x0F, 0xC7, 0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x83, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC3, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFC,
  0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x0F,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0xCF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xBE, 0x00, 0x03, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0xBF, 0xFB,
  0xF0, 0x00, 0x7E, 0xFF, 0xE7, 0xC0, 0x01, 0xF3, 0xFF, 0x9F, 0x00, 0x07,
  0xCF, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0xF8, 0xF8, 0x00, 0xF8, 0xFF, 0xF3,
  0xE0, 0x03, 0xE3, 0xFF, 0xCF, 0xC0, 0x1F, 0x9F, 0xFF, 0x1F, 0x00, 0x7C,
  0x7F, 0xFC, 0x7C, 0x01, 0xF1, 0xFF, 0xF1, 0xF8, 0x0F, 0xC7, 0xFF, 0xC3,
  0xE0, 0x3E, 0x1F, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xFC, 0x3F, 0x07, 0xE1,
  0xFF, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xC1, 0xF8, 0x7C, 0x1F, 0xFF, 0x07,
  0xE3, 0xF0, 0x7F, 0xFC, 0x0F, 0x8F, 0x81, 0xFF, 0xF0, 0x3F, 0x3E, 0x07,
  0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFF, 0x01, 0xF7, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x7F, 0xF3,
  0xF8, 0x00, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0x8F,
  0xF0, 0x07, 0xFF, 0x0F, 0xE0, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0xFE, 0x1F,
  0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F,
  0x81, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x80, 0x7F,
  0x0F, 0xFF, 0x00, 0xFF, 0x1F, 0xFE, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0xFE,
  0x7F, 0xF8, 0x01, 0xFE, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFE, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x3C, 0x7F, 0x00, 0x04,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0xFE, 0x01, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x7C, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x7C, 0x01, 0xFC, 0x1F, 0xC0, 0x3E,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x3E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7C,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xF8,
  0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF0,
  0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0,
  0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0xFE, 0x04,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0x7F, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0x1F,
  0xFF, 0x1F, 0x0F, 0xFC, 0x1F, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xC7, 0xFF,
  0x07, 0xE7, 0xFF, 0xC3, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1,
  0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x7F, 0xE0, 0x7F, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xDF, 0xFF, 0xC7, 0xC7, 0xFF, 0xC3, 0xE0, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xF0, 0x79, 0xFE, 0x00, 0x4F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x05, 0xFF,
  0x01, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x7F, 0xF1, 0xF8, 0xFF,
  0xFC, 0xFC, 0x7F, 0xFF, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xBF, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFB, 0xF1, 0xFF,
  0xFD, 0xF8, 0x7F, 0xFC, 0xFC, 0x0F, 0xF8, 0x3E, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x86, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF,
  0xE7, 0xE3, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFD, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF,
  0xEF, 0xC3, 0xFF, 0xEF, 0xE0, 0x7F, 0xC7, 0xF0, 0x02, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x30,
  0x00, 0x3F, 0x9F, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x0F, 0xC7,
  0xFF, 0x87, 0xE7, 0xFF, 0xE3, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC0, 0xFF, 0x7F, 0xC0, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x7D,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x87, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x3F, 0x3F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7C, 0x3F, 0xFC, 0x1F, 0xFE,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xBF, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x1F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFE, 0x07, 0xFB, 0xFE, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x3F, 0xF8, 0x3F,
  0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFE, 0x0F, 0xFB,
  0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFB, 0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7E,
  0xFF, 0xFE, 0x3F, 0x3F, 0xFE, 0x1F, 0x87, 0xFC, 0x0F, 0xC0, 0x60, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0x83, 0xFF, 0x8F, 0xC7, 0xFF, 0xE7, 0xE3, 0xFF, 0xFB, 0xF3, 0xFF,
  0xFF, 0xFB, 0xFE, 0x0F, 0xFD, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xEF, 0xC3, 0xFF, 0xEF, 0xE0, 0x7F,
  0xC7, 0xF0, 0x02, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0x00, 0x73, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x9F, 0xFF, 0xCF,
  0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xC3, 0xF0, 0x06, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xBF, 0x80,
  0x3F, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xFE, 0x01, 0xF8,
  0x7E, 0x03, 0xEF, 0x81, 0xFC, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x1F, 0x81,
  0xF3, 0xE0, 0x7E, 0x0F, 0xE0, 0xF9, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x7C,
  0x3F, 0x81, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x1F, 0x0F, 0xC0,
  0x7F, 0x1F, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x83, 0xE7, 0xE0, 0x0F, 0xCF,
  0x81, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x7C,
  0xFC, 0x00, 0xFD, 0xF0, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC,
  0x00, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFB, 0x00, 0x3F, 0xF9, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 37, 14, 3, -36 },
  { 38, 17, 13, 23, 3, -36 },
  { 66, 31, 36, 33, 1, -36 },
  { 206, 24, 42, 29, 3, -39 },
  { 332, 41, 37, 45, 2, -37 },
  { 522, 36, 38, 38, 2, -37 },
  { 693, 7, 13, 13, 3, -36 },
  { 705, 13, 44, 17, 2, -36 },
  { 777, 12, 44, 17, 2, -36 },
  { 843, 24, 24, 28, 2, -39 },
  { 915, 25, 24, 29, 2, -30 },
  { 990, 9, 13, 14, 2, -6 },
  { 1005, 13, 5, 16, 2, -16 },
  { 1014, 8, 8, 14, 3, -7 },
  { 1022, 20, 37, 20, 0, -37 },
  { 1115, 25, 38, 29, 2, -37 },
  { 1234, 16, 36, 29, 4, -36 },
  { 1306, 25, 37, 29, 2, -37 },
  { 1422, 25, 38, 29, 2, -37 },
  { 1541, 27, 37, 29, 1, -37 },
  { 1666, 24, 37, 29, 3, -36 },
  { 1777, 25, 38, 29, 2, -37 },
  { 1896, 25, 36, 29, 2, -36 },
  { 2009, 25, 38, 29, 2, -37 },
  { 2128, 25, 38, 29, 2, -37 },
  { 2247, 8, 29, 14, 3, -28 },
  { 2276, 9, 35, 14, 2, -28 },
  { 2316, 25, 27, 29, 2, -32 },
  { 2401, 25, 14, 29, 2, -25 },
  { 2445, 25, 27, 29, 2, -32 },
  { 2530, 22, 38, 24, 0, -37 },
  { 2635, 40, 41, 46, 3, -37 },
  { 2840, 34, 37, 34, 0, -37 },
  { 2998, 26, 36, 34, 5, -36 },
  { 3115, 28, 38, 33, 3, -37 },
  { 3248, 29, 36, 37, 5, -36 },
  { 3379, 20, 36, 28, 5, -36 },
  { 3469, 20, 36, 27, 5, -36 },
  { 3559, 30, 38, 37, 3, -37 },
  { 3702, 29, 36, 39, 5, -36 },
  { 3833, 15, 36, 19, 2, -36 },
  { 3901, 15, 46, 16, -4, -36 },
  { 3988, 28, 36, 33, 5, -36 },
  { 4114, 21, 36, 28, 5, -36 },
  { 4209, 38, 36, 47, 5, -36 },
  { 4380, 31, 36, 40, 5, -36 },
  { 4520, 34, 38, 40, 3, -37 },
  { 4682, 24, 36, 31, 5, -36 },
  { 4790, 34, 46, 40, 3, -37 },
  { 4986, 28, 36, 33, 5, -36 },
  { 5112, 24, 38, 28, 2, -37 },
  { 5226, 27, 36, 29, 1, -36 },
  { 5348, 30, 37, 38, 4, -36 },
  { 5487, 32, 36, 32, 0, -36 },
  { 5631, 48, 36, 49, 0, -36 },
  { 5847, 32, 36, 33, 0, -36 },
  { 5991, 31, 36, 31, 0, -36 },
  { 6131, 27, 36, 29, 1, -36 },
  { 6253, 12, 44, 17, 4, -36 },
  { 6319, 20, 37, 20, 0, -37 },
  { 6412, 12, 44, 17, 1, -36 },
  { 6478, 27, 24, 29, 1, -37 },
  { 6559, 22, 3, 22, 0, 5 },
  { 6568, 13, 8, 17, 2, -39 },
  { 6581, 24, 29, 30, 2, -28 },
  { 6668, 25, 40, 32, 4, -39 },
  { 6793, 21, 29, 26, 3, -28 },
  { 6870, 25, 40, 32, 3, -39 },
  { 6995, 24, 29, 30, 3, -28 },
  { 7082, 20, 39, 19, 1, -39 },
  { 7180, 25, 40, 32, 3, -28 },
  { 7305, 25, 39, 33, 4, -39 },
  { 7427, 7, 38, 14, 4, -38 },
  { 7461, 14, 50, 14, -3, -38 },
  { 7549, 26, 39, 30, 4, -39 },
  { 7676, 6, 39, 14, 4, -39 },
  { 7706, 41, 28, 49, 4, -28 },
  { 7850, 25, 28, 33, 4, -28 },
  { 7938, 26, 29, 31, 3, -28 },
  { 8033, 25, 40, 32, 4, -28 },
  { 8158, 25, 40, 32, 3, -28 },
  { 8283, 17, 28, 22, 4, -28 },
  { 8343, 21, 29, 25, 2, -28 },
  { 8420, 18, 35, 21, 1, -34 },
  { 8499, 25, 29, 33, 4, -28 },
  { 8590, 28, 28, 28, 0, -28 },
  { 8688, 41, 28, 42, 1, -28 },
  { 8832, 27, 28, 29, 1, -28 },
  { 8927, 28, 40, 28, 0, -28 },
  { 9067, 21, 28, 25, 2, -28 },
  { 9141, 17, 44, 20, 1, -36 },
  { 9235, 4, 51, 28, 12, -39 },
  { 9261, 17, 44, 20, 2, -36 },
  { 9355, 25, 8, 29, 2, -22 },
};

const GFXfont NotoSans_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMIBOLD51PT7B_H_
