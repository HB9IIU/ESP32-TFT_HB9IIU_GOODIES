#ifndef _NOTOSANS_SEMIBOLD47PT7B_H_
#define _NOTOSANS_SEMIBOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x01, 0xC7, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8, 0x60, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x1F, 0x78,
  0x3E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFE, 0x70,
  0xF3, 0xF8, 0xE0, 0x27, 0xE1, 0xC0, 0x0F, 0xC3, 0x80, 0x1F, 0xC7, 0x00,
  0x1F, 0xCE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x38, 0x7E, 0x00, 0x70, 0xFC, 0x00,
  0xE1, 0xFE, 0x01, 0xC7, 0xFF, 0x83, 0x9F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFE,
  0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0,
  0x00, 0x7C, 0x1F, 0x1F, 0x07, 0x03, 0xE0, 0xF8, 0xF0, 0xFF, 0x1F, 0x0F,
  0x8F, 0x8F, 0xFC, 0x7C, 0x7C, 0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xCF, 0xDF,
  0x8F, 0xFE, 0x7C, 0x7C, 0x3E, 0x3F, 0xE3, 0xE3, 0xC1, 0xF0, 0xFC, 0x3E,
  0x3E, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x81, 0xE0,
  0x00, 0xF0, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x78, 0x00, 0xF8, 0x1F,
  0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x7C, 0x03, 0xC1, 0xF0, 0x03,
  0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x7E, 0x07, 0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0xE0, 0x1F, 0x87, 0xF3, 0xF8,
  0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE3, 0xF8, 0x0F,
  0xE7, 0xE1, 0xF8, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0x7E, 0x00,
  0x3F, 0xF0, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x08, 0x07, 0x80, 0x7C, 0x1E, 0x0E,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x03, 0x80,
  0x04, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xFD, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0xFF, 0x3E,
  0xFC, 0xFC, 0xE1, 0xF8, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xE0, 0x7F, 0x0F, 0x00, 0x7F, 0x08, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF4, 0x00, 0x0F, 0xEE, 0x00, 0x3F,
  0xDF, 0xC7, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xA0, 0x00, 0xFE, 0xC0, 0x07, 0xF3, 0xFD, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x40, 0x1F, 0x8F, 0xF8, 0x3F, 0x7F, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0x87, 0xFB, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC7,
  0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1,
  0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFE,
  0x7F, 0x87, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xCF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F,
  0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFB, 0xF0, 0xFF, 0xE7, 0xC0, 0x7F, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x06, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8, 0x60, 0x1F, 0x1F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1E, 0x03, 0xF8, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7C, 0x01, 0xFE, 0x03, 0xC1,
  0xF0, 0x1F, 0xFF, 0x0F, 0x8F, 0x81, 0xFF, 0xFC, 0x1E, 0x3C, 0x0F, 0xFF,
  0xF0, 0x79, 0xF0, 0x7F, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x1F, 0x07, 0xDE,
  0x0F, 0x80, 0x7C, 0x1F, 0x78, 0x3E, 0x01, 0xF0, 0x7D, 0xE0, 0xF8, 0x07,
  0xC1, 0xFF, 0x83, 0xC0, 0x1F, 0x07, 0xFE, 0x0F, 0x00, 0x78, 0x1F, 0xF8,
  0x3C, 0x01, 0xE0, 0x7B, 0xE0, 0xF8, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0x3E,
  0x07, 0x9E, 0x0F, 0x81, 0xFC, 0x3E, 0x78, 0x1F, 0x0F, 0xF1, 0xF1, 0xE0,
  0x7F, 0xFF, 0xFF, 0x87, 0xC0, 0xFF, 0xE7, 0xFE, 0x1F, 0x01, 0xFF, 0x0F,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xF3,
  0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x1F, 0xF7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xC1,
  0xFE, 0x00, 0x30, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF8, 0xFC, 0x03, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0x87, 0xF8, 0x00, 0x21,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x7C, 0xFE, 0x00, 0x0F, 0x9F, 0xE0, 0x01, 0xF1, 0xFE,
  0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x06, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF3,
  0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xDF, 0x00, 0x07, 0xDF, 0xFF, 0xE0,
  0x00, 0xFB, 0xFF, 0xBE, 0x00, 0x1F, 0x7F, 0xF7, 0xC0, 0x07, 0xCF, 0xFE,
  0xF8, 0x00, 0xF9, 0xFF, 0xCF, 0x80, 0x1F, 0x3F, 0xF9, 0xF0, 0x07, 0xC7,
  0xFF, 0x3E, 0x00, 0xF8, 0xFF, 0xE3, 0xE0, 0x1F, 0x1F, 0xFC, 0x7C, 0x07,
  0xC3, 0xFF, 0x8F, 0x80, 0xF8, 0x7F, 0xF0, 0xF8, 0x1F, 0x0F, 0xFE, 0x1F,
  0x07, 0xC1, 0xFF, 0xC3, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x1F, 0x07, 0xFF,
  0x07, 0xC7, 0xC0, 0xFF, 0xE0, 0xF8, 0xF8, 0x1F, 0xFC, 0x0F, 0x9E, 0x03,
  0xFF, 0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0x00, 0x7C, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xF8, 0x01,
  0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0x7F, 0x00, 0x7F, 0xF9, 0xF8, 0x03, 0xFF,
  0xCF, 0xE0, 0x1F, 0xFE, 0x3F, 0x80, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0x87,
  0xF0, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x03, 0xF8,
  0x7F, 0xF8, 0x0F, 0xC1, 0xFF, 0xC0, 0x7F, 0x0F, 0xFE, 0x01, 0xFC, 0x7F,
  0xF0, 0x0F, 0xE3, 0xFF, 0x80, 0x3F, 0x9F, 0xFC, 0x00, 0xFC, 0xFF, 0xE0,
  0x07, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x87,
  0xFF, 0xBF, 0x00, 0xFF, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xBF, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x03, 0xFF,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x07,
  0xC7, 0xF0, 0x03, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x3F, 0x01,
  0xFB, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x1F,
  0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x01, 0xF8, 0xFC, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E,
  0x00, 0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x07, 0xCF, 0xC0, 0x03,
  0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF0, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0xF8, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xDF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0xF7, 0xDF, 0xFF, 0xDF,
  0x3F, 0xFE, 0x7C, 0x3F, 0xE0, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x07, 0xE7, 0xFE, 0x0F, 0xDF, 0xFE, 0x1F, 0x7F, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0x81, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F,
  0xF7, 0xFC, 0xFF, 0xFF, 0xF9, 0xF7, 0xFF, 0xE3, 0xE7, 0xFF, 0x87, 0x83,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFC, 0x0E, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x33, 0xFF, 0x7F, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xFC, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xE7, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x47, 0xFC, 0x0F, 0x87, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0xFF, 0x3F, 0xE7, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF,
  0x0F, 0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x38, 0x01, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0x3F, 0xF8,
  0xF9, 0xFF, 0xF3, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80,
  0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F,
  0x80, 0xFE, 0x3F, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x03, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFF, 0x3E,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xFC,
  0x0F, 0xEF, 0xE0, 0x1F, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0x80, 0x7E, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x83, 0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0xFE,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x01, 0xF1, 0xFF, 0x83, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF,
  0xFD, 0xFF, 0x3F, 0xFF, 0xFE, 0x7D, 0xFF, 0xF8, 0xFD, 0xFF, 0xE1, 0xF8,
  0xFF, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0xFF, 0x3F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFB, 0xFE, 0xFB, 0xFE, 0xFF,
  0xFE, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xF9, 0xFD, 0xF8, 0x03, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x61, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xFC,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xEF, 0x8F, 0xFF, 0x9F, 0x07, 0xFC,
  0x1E, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0xF0, 0x0F, 0x87,
  0xE0, 0x3D, 0xE0, 0x3F, 0x0F, 0xC0, 0x7B, 0xC0, 0x7E, 0x1F, 0x81, 0xF7,
  0xC0, 0xFC, 0x1F, 0x83, 0xEF, 0x81, 0xF0, 0x3F, 0x07, 0x9F, 0x07, 0xE0,
  0x7E, 0x1F, 0x1E, 0x0F, 0xC0, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0xFC, 0x7C,
  0x7C, 0x7E, 0x01, 0xF8, 0xF0, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0xF9, 0xF8,
  0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0x07, 0xCF, 0x83, 0xEF, 0xC0, 0x0F, 0xDE,
  0x07, 0xDF, 0x80, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xA0, 0x01, 0xFC,
  0x00,
};

const GFXglyph NotoSans_SemiBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 15, 13, 21, 3, -34 },
  { 57, 28, 34, 30, 1, -34 },
  { 176, 23, 39, 27, 2, -36 },
  { 289, 37, 34, 41, 2, -34 },
  { 447, 33, 34, 35, 2, -34 },
  { 588, 6, 13, 12, 3, -34 },
  { 598, 12, 41, 15, 2, -34 },
  { 660, 12, 41, 15, 1, -34 },
  { 722, 22, 22, 26, 2, -36 },
  { 783, 23, 23, 27, 2, -28 },
  { 850, 8, 11, 13, 2, -5 },
  { 861, 12, 5, 15, 2, -15 },
  { 869, 7, 8, 13, 3, -7 },
  { 876, 18, 34, 19, 0, -34 },
  { 953, 23, 34, 27, 2, -34 },
  { 1051, 15, 34, 27, 3, -34 },
  { 1115, 23, 34, 27, 2, -34 },
  { 1213, 23, 34, 27, 2, -34 },
  { 1311, 25, 34, 27, 1, -34 },
  { 1418, 22, 34, 27, 3, -34 },
  { 1512, 23, 34, 27, 2, -34 },
  { 1610, 23, 34, 27, 2, -34 },
  { 1708, 23, 34, 27, 2, -34 },
  { 1806, 23, 34, 27, 2, -34 },
  { 1904, 7, 27, 13, 3, -26 },
  { 1928, 9, 32, 13, 1, -26 },
  { 1964, 23, 24, 27, 2, -29 },
  { 2033, 23, 13, 27, 2, -23 },
  { 2071, 23, 24, 27, 2, -29 },
  { 2140, 21, 35, 22, 0, -34 },
  { 2232, 38, 38, 42, 2, -34 },
  { 2413, 32, 34, 32, 0, -34 },
  { 2549, 25, 34, 31, 4, -34 },
  { 2656, 26, 34, 30, 3, -34 },
  { 2767, 28, 34, 34, 4, -34 },
  { 2886, 19, 34, 26, 4, -34 },
  { 2967, 19, 34, 25, 4, -34 },
  { 3048, 27, 34, 34, 3, -34 },
  { 3163, 27, 34, 36, 4, -34 },
  { 3278, 14, 34, 17, 2, -34 },
  { 3338, 14, 44, 15, -4, -34 },
  { 3415, 26, 34, 30, 4, -34 },
  { 3526, 20, 34, 26, 4, -34 },
  { 3611, 35, 34, 44, 4, -34 },
  { 3760, 29, 34, 37, 4, -34 },
  { 3884, 31, 34, 37, 3, -34 },
  { 4016, 23, 34, 29, 4, -34 },
  { 4114, 31, 42, 37, 3, -34 },
  { 4277, 26, 34, 30, 4, -34 },
  { 4388, 22, 34, 26, 2, -34 },
  { 4482, 25, 34, 27, 1, -34 },
  { 4589, 27, 34, 35, 4, -34 },
  { 4704, 30, 34, 30, 0, -34 },
  { 4832, 45, 34, 45, 0, -34 },
  { 5024, 30, 34, 30, 0, -34 },
  { 5152, 28, 34, 28, 0, -34 },
  { 5271, 25, 34, 27, 1, -34 },
  { 5378, 11, 41, 16, 3, -34 },
  { 5435, 18, 34, 19, 0, -34 },
  { 5512, 11, 41, 16, 1, -34 },
  { 5569, 25, 22, 27, 1, -34 },
  { 5638, 20, 3, 20, 0, 4 },
  { 5646, 12, 8, 16, 2, -36 },
  { 5658, 22, 26, 28, 2, -26 },
  { 5730, 23, 36, 29, 4, -36 },
  { 5834, 20, 26, 24, 2, -26 },
  { 5899, 24, 36, 29, 2, -36 },
  { 6007, 23, 26, 28, 2, -26 },
  { 6082, 19, 36, 17, 1, -36 },
  { 6168, 24, 37, 29, 2, -26 },
  { 6279, 22, 36, 30, 4, -36 },
  { 6378, 7, 35, 13, 3, -35 },
  { 6409, 12, 46, 13, -2, -35 },
  { 6478, 23, 36, 28, 4, -36 },
  { 6582, 6, 36, 13, 4, -36 },
  { 6609, 38, 26, 45, 4, -26 },
  { 6733, 22, 26, 30, 4, -26 },
  { 6805, 25, 26, 29, 2, -26 },
  { 6887, 23, 37, 29, 4, -26 },
  { 6994, 24, 37, 29, 2, -26 },
  { 7105, 16, 26, 20, 4, -26 },
  { 7157, 19, 26, 23, 2, -26 },
  { 7219, 17, 31, 19, 1, -31 },
  { 7285, 23, 25, 30, 3, -25 },
  { 7357, 26, 25, 26, 0, -25 },
  { 7439, 39, 26, 39, 0, -26 },
  { 7566, 26, 25, 26, 0, -25 },
  { 7648, 26, 36, 26, 0, -25 },
  { 7765, 19, 25, 23, 2, -25 },
  { 7825, 16, 41, 18, 1, -34 },
  { 7907, 4, 47, 26, 11, -36 },
  { 7931, 15, 41, 18, 2, -34 },
  { 8008, 23, 7, 27, 2, -20 },
};

const GFXfont NotoSans_SemiBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMIBOLD47PT7B_H_
