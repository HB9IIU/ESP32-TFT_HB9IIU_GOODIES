#ifndef _NOTOSANS_SEMIBOLD36PT7B_H_
#define _NOTOSANS_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF9, 0xFF, 0x8F,
  0xF8, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF6, 0x79,
  0xF3, 0x04, 0xF1, 0x80, 0x78, 0xC0, 0x3E, 0x60, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xC7, 0xC0,
  0x63, 0xE0, 0x31, 0xF8, 0x18, 0xFF, 0xCD, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0x7F, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F,
  0x80, 0x0F, 0x01, 0xFE, 0x00, 0xF0, 0x1F, 0xF8, 0x07, 0x00, 0xF3, 0xC0,
  0x78, 0x07, 0x0F, 0x03, 0x80, 0x78, 0x78, 0x3C, 0x03, 0xC3, 0xC1, 0xC0,
  0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x87, 0x8F, 0x00, 0x1C,
  0x3C, 0xF1, 0xE0, 0xE1, 0xE7, 0x9F, 0xC7, 0x9E, 0x79, 0xFF, 0x1F, 0xF3,
  0x9F, 0x78, 0xFF, 0x3C, 0xF1, 0xE1, 0xF1, 0xC7, 0x0F, 0x00, 0x1E, 0x38,
  0x78, 0x01, 0xE1, 0xC1, 0xC0, 0x0F, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0xF0,
  0x07, 0x83, 0x87, 0x80, 0x78, 0x1C, 0x3C, 0x03, 0x80, 0xF1, 0xE0, 0x3C,
  0x03, 0xFE, 0x01, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0xF1, 0xFF, 0xE0, 0xF9, 0xF9, 0xF8, 0x78,
  0xF8, 0x7E, 0x7C, 0x7C, 0x1F, 0xBE, 0x3C, 0x07, 0xFE, 0x1E, 0x01, 0xFF,
  0x0F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x7E, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0xFE, 0xF7, 0x39,
  0xCE, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x04, 0x1C, 0x0B, 0xCE, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xF1,
  0xF0, 0xF8, 0x78, 0x0C, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1C,
  0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0x79, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1E, 0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xFB,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x3F,
  0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0x7F, 0x8F, 0x61, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFE, 0x38, 0x0F, 0x88, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x03, 0xEF, 0xC7, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x03, 0x9F,
  0x00, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x0F, 0x81, 0xE1, 0xF0, 0x78, 0x3E,
  0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xF0, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF4, 0x00, 0xFB, 0xF7, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xFF,
  0x1E, 0xFF, 0xCF, 0xFF, 0xF7, 0xF0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x7D,
  0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFC, 0xFE, 0x7C, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x79,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x7E, 0x7C, 0x0F, 0x9E, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x01, 0xF7, 0xE0, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x9F, 0x03, 0xE7, 0x80, 0x7B, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x07, 0xC7, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0xC2, 0x0F, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB,
  0xF3, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x79, 0xF3, 0xC7, 0x8F, 0x1C, 0x78, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x70, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xE3, 0xC0, 0xFF, 0x0E, 0x78, 0x3F, 0xF8, 0xF7, 0x07,
  0xFF, 0x87, 0x70, 0xF8, 0x78, 0x7F, 0x0F, 0x07, 0x87, 0xF1, 0xE0, 0x78,
  0x7E, 0x1E, 0x07, 0x87, 0xE1, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0x87, 0xE1,
  0xE0, 0x78, 0x7E, 0x1E, 0x0F, 0x8F, 0xF0, 0xF0, 0xF8, 0xEF, 0x0F, 0xFF,
  0xFE, 0xF0, 0x7F, 0x9F, 0xC7, 0x83, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xE0,
  0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3E, 0x0F, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0x80, 0xE3, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x02,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x81, 0xFE, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x03, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xF3, 0xE0, 0x07, 0x9F, 0xC0, 0x3C, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7D, 0xFF, 0xBF, 0xE7, 0xFC, 0xFE,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0x00, 0x3F, 0xFD, 0xE0, 0x07, 0x7F, 0xBC, 0x01,
  0xEF, 0xF3, 0x80, 0x3D, 0xFE, 0x78, 0x0F, 0x3F, 0xCF, 0x01, 0xE7, 0xF8,
  0xF0, 0x3C, 0xFF, 0x1E, 0x0F, 0x1F, 0xE3, 0xC1, 0xE3, 0xFC, 0x3C, 0x3C,
  0x7F, 0x87, 0x8F, 0x0F, 0xF0, 0xF1, 0xE1, 0xFE, 0x0F, 0x38, 0x3F, 0xC1,
  0xEF, 0x07, 0xF8, 0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03,
  0xE0, 0x3C, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x7C, 0x03, 0xFD, 0xF0, 0x0F,
  0xF3, 0xE0, 0x3F, 0xC7, 0xC0, 0xFF, 0x1F, 0x03, 0xFC, 0x3E, 0x0F, 0xF0,
  0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0x03, 0xE3, 0xFC, 0x0F, 0x8F, 0xF0, 0x1F,
  0x3F, 0xC0, 0x7C, 0xFF, 0x00, 0xFB, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x80, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x80, 0xFC, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F,
  0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3F,
  0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0xFC, 0x0E, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xE7, 0xC0,
  0x1F, 0x3F, 0x01, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xDE, 0x00,
  0x7C, 0x01, 0xF7, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x1E, 0x7C,
  0x03, 0xF0, 0x0F, 0x8F, 0x01, 0xFE, 0x03, 0xE3, 0xC0, 0x7F, 0x80, 0xF8,
  0xF8, 0x1F, 0xE0, 0x3C, 0x3E, 0x07, 0xBC, 0x0F, 0x07, 0x83, 0xCF, 0x07,
  0xC1, 0xE0, 0xF3, 0xC1, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x1F, 0x0F, 0x1E,
  0x1E, 0x03, 0xC7, 0x87, 0x8F, 0x80, 0xF1, 0xE1, 0xE3, 0xC0, 0x3C, 0x78,
  0x7C, 0xF0, 0x0F, 0xBC, 0x0F, 0x3C, 0x01, 0xEF, 0x03, 0xDF, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x1E, 0xF0, 0x1D, 0xE0, 0x07, 0xB8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xEF, 0x80, 0x03,
  0xDE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0x9F,
  0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x0E,
  0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x70,
  0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x07,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x10, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F,
  0xE7, 0x3F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0xF3, 0xFC, 0x3D,
  0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xBE, 0x03, 0xEF, 0xC0, 0xFB, 0xFD, 0xFC, 0xFF, 0xFF, 0x3D,
  0xFF, 0x8E, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7,
  0xE0, 0x4F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0x7F, 0xBE,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x1F,
  0x1F, 0xF7, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xFC, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFC, 0xF0, 0xFE, 0x3C, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0x7F, 0x07, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x08, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7D, 0xF0, 0x3F, 0x7F, 0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x9F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7D, 0x00, 0x3E, 0x70, 0x1F, 0x9F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE1, 0xF0, 0xF3, 0xFE, 0x7B, 0xFF, 0xBF, 0xFF, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0, 0xF7, 0xFF, 0xE6, 0x00, 0x1E,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC,
  0x07, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0xFF, 0xBF, 0xCF, 0xE1, 0xE0, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x3F, 0xF0, 0x1F, 0xBC, 0x0F, 0xCF, 0x03, 0xE3, 0xC1, 0xF0,
  0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x07,
  0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xF8, 0x0F, 0x87, 0x9F, 0xF1, 0xFF, 0x3D, 0xFF, 0xDF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xC1, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0x80, 0x7C, 0x07,
  0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xF8,
  0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x03, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x0F,
  0x80, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x01,
  0xF0, 0xE0, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xF0, 0xF8, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3,
  0xFF, 0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xEF, 0x80, 0xFB, 0xF0, 0x3E, 0xFF, 0x3F, 0x3F, 0xFF, 0xCF, 0x7F, 0xE3,
  0xCF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3F, 0x7F,
  0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xE0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xF0, 0x0B, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x03, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF1, 0x8F, 0xFC, 0x3F, 0xE0,
  0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFE,
  0x7F, 0xBF, 0xFF, 0xDF, 0xFD, 0xE3, 0xFC, 0xF0, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3E,
  0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00,
  0xF1, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7B, 0xC0, 0x7E, 0x03, 0xDE, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x81,
  0xF7, 0xC1, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0, 0x78, 0xF8, 0x77, 0x87, 0xC7,
  0xC7, 0x9C, 0x3C, 0x1E, 0x3C, 0xF1, 0xE0, 0xF1, 0xE7, 0x8F, 0x07, 0xCE,
  0x3C, 0xF8, 0x3E, 0xF0, 0xE7, 0x80, 0xF7, 0x87, 0xBC, 0x07, 0xBC, 0x3D,
  0xE0, 0x3D, 0xC1, 0xEF, 0x00, 0xEE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x9F,
  0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x7E, 0x03, 0xEF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C,
  0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0x7F, 0x00,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 12, 10, 16, 2, -26 },
  { 36, 21, 26, 23, 1, -26 },
  { 105, 17, 29, 21, 2, -27 },
  { 167, 29, 26, 32, 1, -26 },
  { 262, 25, 26, 27, 2, -26 },
  { 344, 5, 10, 9, 2, -26 },
  { 351, 10, 32, 12, 1, -26 },
  { 391, 9, 32, 12, 1, -26 },
  { 427, 17, 16, 20, 1, -27 },
  { 461, 17, 17, 21, 2, -21 },
  { 498, 7, 9, 10, 1, -4 },
  { 506, 9, 4, 12, 1, -12 },
  { 511, 6, 5, 10, 2, -5 },
  { 515, 14, 26, 14, 0, -26 },
  { 561, 18, 26, 21, 1, -26 },
  { 620, 11, 26, 21, 3, -26 },
  { 656, 17, 26, 21, 2, -26 },
  { 712, 18, 26, 21, 1, -26 },
  { 771, 19, 26, 21, 1, -26 },
  { 833, 17, 26, 21, 2, -26 },
  { 889, 17, 26, 21, 2, -26 },
  { 945, 18, 26, 21, 1, -26 },
  { 1004, 18, 26, 21, 1, -26 },
  { 1063, 18, 26, 21, 1, -26 },
  { 1122, 6, 20, 10, 2, -20 },
  { 1137, 7, 25, 10, 1, -20 },
  { 1159, 17, 18, 21, 2, -22 },
  { 1198, 17, 10, 21, 2, -18 },
  { 1220, 17, 18, 21, 2, -22 },
  { 1259, 16, 26, 17, 0, -26 },
  { 1311, 28, 29, 32, 2, -26 },
  { 1413, 24, 26, 24, 0, -26 },
  { 1491, 19, 26, 24, 3, -26 },
  { 1553, 20, 26, 23, 2, -26 },
  { 1618, 21, 26, 26, 3, -26 },
  { 1687, 15, 26, 20, 3, -26 },
  { 1736, 15, 26, 19, 3, -26 },
  { 1785, 21, 26, 26, 2, -26 },
  { 1854, 21, 26, 27, 3, -26 },
  { 1923, 11, 26, 13, 1, -26 },
  { 1959, 11, 33, 11, -3, -26 },
  { 2005, 20, 26, 23, 3, -26 },
  { 2070, 16, 26, 20, 3, -26 },
  { 2122, 27, 26, 33, 3, -26 },
  { 2210, 22, 26, 29, 3, -26 },
  { 2282, 24, 26, 28, 2, -26 },
  { 2360, 18, 26, 22, 3, -26 },
  { 2419, 24, 32, 28, 2, -26 },
  { 2515, 20, 26, 23, 3, -26 },
  { 2580, 16, 26, 20, 2, -26 },
  { 2632, 19, 26, 20, 1, -26 },
  { 2694, 21, 26, 27, 3, -26 },
  { 2763, 23, 26, 23, 0, -26 },
  { 2838, 34, 26, 34, 0, -26 },
  { 2949, 23, 26, 23, 0, -26 },
  { 3024, 22, 26, 22, 0, -26 },
  { 3096, 19, 26, 21, 1, -26 },
  { 3158, 8, 32, 12, 3, -26 },
  { 3190, 14, 26, 14, 0, -26 },
  { 3236, 8, 32, 12, 1, -26 },
  { 3268, 19, 17, 21, 1, -26 },
  { 3309, 15, 3, 15, 0, 3 },
  { 3315, 10, 6, 12, 1, -28 },
  { 3323, 16, 20, 21, 2, -20 },
  { 3363, 18, 27, 23, 3, -27 },
  { 3424, 15, 20, 18, 2, -20 },
  { 3462, 18, 27, 23, 2, -27 },
  { 3523, 17, 20, 21, 2, -20 },
  { 3566, 14, 28, 13, 1, -28 },
  { 3615, 18, 29, 23, 2, -20 },
  { 3681, 17, 27, 23, 3, -27 },
  { 3739, 5, 27, 10, 3, -27 },
  { 3756, 10, 36, 10, -2, -27 },
  { 3801, 18, 27, 21, 3, -27 },
  { 3862, 4, 27, 10, 3, -27 },
  { 3876, 29, 20, 35, 3, -20 },
  { 3949, 17, 20, 23, 3, -20 },
  { 3992, 18, 20, 22, 2, -20 },
  { 4037, 18, 29, 23, 3, -20 },
  { 4103, 18, 29, 23, 2, -20 },
  { 4169, 12, 20, 16, 3, -20 },
  { 4199, 14, 20, 18, 2, -20 },
  { 4234, 13, 24, 15, 1, -24 },
  { 4273, 17, 20, 23, 3, -20 },
  { 4316, 20, 20, 20, 0, -20 },
  { 4366, 29, 20, 30, 0, -20 },
  { 4439, 20, 20, 20, 0, -20 },
  { 4489, 20, 29, 20, 0, -20 },
  { 4562, 15, 20, 17, 1, -20 },
  { 4600, 12, 32, 14, 1, -26 },
  { 4648, 4, 35, 20, 8, -27 },
  { 4666, 12, 32, 14, 1, -26 },
  { 4714, 17, 5, 21, 2, -15 },
};

const GFXfont NotoSans_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMIBOLD36PT7B_H_
