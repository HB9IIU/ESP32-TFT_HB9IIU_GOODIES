#ifndef _NOTOSANS_SEMIBOLD53PT7B_H_
#define _NOTOSANS_SEMIBOLD53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0x8F, 0x07, 0x1F, 0xC7, 0x80, 0x0F, 0xC3, 0xC0,
  0x07, 0xE1, 0xE0, 0x03, 0xF8, 0xF0, 0x01, 0xFE, 0x78, 0x00, 0xFF, 0xBC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1E, 0x7F, 0xC0, 0x0F, 0x1F, 0xE0, 0x07, 0x87, 0xF0,
  0x03, 0xC3, 0xF8, 0x01, 0xE1, 0xFF, 0x00, 0xF0, 0xFF, 0xF0, 0x79, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x3F, 0x0F, 0xE0, 0x7C,
  0x1F, 0x8F, 0x87, 0xFE, 0x1F, 0x07, 0xC7, 0xE3, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0xFE, 0x3E, 0x3F,
  0x0F, 0x87, 0xFF, 0x1F, 0x8F, 0x83, 0xF0, 0x7F, 0x0F, 0xC3, 0xE0, 0x7C,
  0x00, 0x03, 0xE1, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x1F,
  0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xF7, 0xF8, 0x07,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x01,
  0xFE, 0x3F, 0x83, 0xF8, 0x07, 0xF9, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xC1,
  0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x7C, 0x0E, 0xFE, 0x3E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E,
  0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x1F,
  0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFF, 0x7F, 0xBF, 0xFF, 0x9F, 0xDF, 0x8F, 0xE7, 0x07, 0xF3,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC3, 0xF0, 0x07, 0xF0, 0x70, 0x01, 0xFE, 0x08, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xC0, 0x07, 0xF0, 0x40, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFB, 0x00, 0x01, 0xFE, 0xFC, 0x01, 0xFF, 0xBF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFD, 0x80, 0x03, 0xFC, 0xFC,
  0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x40, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFF, 0x01, 0xF9, 0xFF,
  0xF0, 0x7E, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x81, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xF8,
  0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x1F, 0xF7, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xC7,
  0xFF, 0xF3, 0xF0, 0xFF, 0xF9, 0xFC, 0x0F, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0x1F, 0x1F, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xCE, 0x00, 0x3F,
  0x90, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC1, 0xF0, 0x03, 0xFF, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0xF8, 0x7E,
  0x3E, 0x03, 0xFF, 0xFE, 0x0F, 0x9F, 0x81, 0xFF, 0xFF, 0x83, 0xE7, 0xC0,
  0xFF, 0x07, 0xE0, 0x79, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xFC, 0x1F, 0x80,
  0x7C, 0x07, 0xFE, 0x07, 0xE0, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0xC0,
  0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xFE,
  0x0F, 0xC0, 0x1F, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0xFC,
  0x01, 0xF0, 0x3E, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xBE, 0x07, 0xC0, 0x3F,
  0x03, 0xEF, 0x81, 0xF8, 0x1F, 0xC1, 0xF3, 0xE0, 0x7F, 0x0F, 0xF8, 0xFC,
  0xF8, 0x0F, 0xFF, 0xDF, 0xFE, 0x1F, 0x01, 0xFF, 0xE7, 0xFF, 0x07, 0xC0,
  0x3F, 0xF0, 0xFF, 0x81, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xBF, 0x80, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xC7, 0xF8,
  0x3F, 0xE0, 0x03, 0x83, 0xFE, 0x00, 0x04, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x06, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0x80, 0x3F, 0xF8, 0x7F, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xFC,
  0x7F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x83,
  0xFF, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x1F,
  0x8F, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x83,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x3C,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00,
  0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFB, 0xE0, 0x00, 0x3E, 0xFF, 0xF7, 0xE0, 0x00, 0xFD, 0xFF, 0xEF, 0xC0,
  0x01, 0xFB, 0xFF, 0xCF, 0xC0, 0x03, 0xE7, 0xFF, 0x9F, 0x80, 0x0F, 0xCF,
  0xFF, 0x3F, 0x00, 0x1F, 0x1F, 0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xFC, 0x7E,
  0x00, 0xFC, 0x7F, 0xF8, 0xFC, 0x01, 0xF0, 0xFF, 0xF0, 0xFC, 0x03, 0xE1,
  0xFF, 0xE1, 0xF8, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x1F, 0x07, 0xFF, 0x83,
  0xF0, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0xF0,
  0x3F, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0xF0,
  0x3F, 0x1F, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x3F,
  0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x3F, 0xFC, 0x03,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x3F, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x00,
  0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0x3F, 0xFC, 0x00,
  0x7F, 0xBF, 0xFC, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xFD,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0xFF, 0x00, 0x1C,
  0xFE, 0x00, 0x04, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x03,
  0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFB, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF1,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x01,
  0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0xF9, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0xF8, 0x10,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0x7F, 0xC0, 0x3F, 0xBF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFF, 0xE1, 0xF0, 0xFF, 0xE0, 0xF8, 0x03,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x7F, 0xF8, 0x3F, 0xBF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xBF, 0xE0, 0x1F,
  0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0x3F, 0xFF, 0x8F, 0xC7, 0xFF, 0xC3, 0xE0, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xC7, 0xC7, 0xF8, 0x01, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x8F, 0xF8, 0x1E, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xFF, 0x9F, 0xC3, 0xFF, 0xF7,
  0xF1, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xDF, 0xE0,
  0x1F, 0xF7, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xEF, 0xC7, 0xFF, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC,
  0x1F, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF9,
  0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x04, 0x7F, 0x80, 0x0E, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x50, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x40, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xC1, 0xFF, 0xE3, 0xF0, 0xFF, 0xFC,
  0xFC, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xF7, 0xF8,
  0x07, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFE, 0x7F, 0x03, 0xFF,
  0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF4, 0x00, 0x07, 0xF9, 0xE0, 0x03, 0xFE,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0xFE,
  0x7F, 0xFC, 0x3F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0xBF, 0xE0, 0x0F, 0xEF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0x3E, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xF9, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0x8F, 0xFF,
  0x83, 0xFF, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xBF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0xF8, 0x1F, 0xF0, 0x3F, 0x1F, 0xFF, 0x0F, 0xCF,
  0xFF, 0xE3, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xEF,
  0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x1F, 0xE0,
  0x3F, 0x1F, 0xFE, 0x0F, 0xCF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF8, 0x7F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFB,
  0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF,
  0xE3, 0xF9, 0xFF, 0xF0, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0x40, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xC1, 0xFF, 0xE3, 0xF0, 0xFF, 0xFC, 0xFC,
  0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xF7, 0xF8, 0x07,
  0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFB, 0xF1, 0xFF, 0xFD, 0xFC, 0x1F, 0xFE, 0x7F, 0x03, 0xFF, 0x1F,
  0xC0, 0x08, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0x00, 0xF3, 0xF0, 0x00, 0x9F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x43, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x04, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF3, 0xFF,
  0xFC, 0xFC, 0x7F, 0xFE, 0x3F, 0x07, 0xFE, 0x0F, 0xC0, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0xC0, 0x1F,
  0x9F, 0xC0, 0x3F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0xFC,
  0x07, 0xDF, 0x80, 0xFC, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x0F, 0xE0, 0x7C,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x3E, 0x07, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF8, 0x1F, 0x83, 0xE1, 0xF0, 0x7E, 0x07, 0xF0, 0xF8, 0x7C, 0x3F, 0x80,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC0, 0xF8, 0xFC, 0x03, 0xF9, 0xF0, 0x3E, 0x7F, 0x00, 0x7E, 0xFC, 0x0F,
  0x9F, 0x80, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0x7D, 0xF8,
  0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x4F, 0xFE,
  0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 39, 15, 3, -38 },
  { 40, 18, 14, 24, 3, -38 },
  { 72, 32, 38, 34, 1, -38 },
  { 224, 25, 43, 30, 3, -40 },
  { 359, 42, 38, 46, 2, -38 },
  { 559, 37, 39, 39, 2, -38 },
  { 740, 7, 14, 13, 3, -38 },
  { 753, 14, 46, 17, 2, -38 },
  { 834, 13, 46, 17, 2, -38 },
  { 909, 25, 24, 29, 2, -40 },
  { 984, 26, 26, 30, 2, -32 },
  { 1069, 9, 13, 15, 2, -6 },
  { 1084, 13, 6, 17, 2, -17 },
  { 1094, 8, 9, 15, 3, -8 },
  { 1103, 21, 38, 21, 0, -38 },
  { 1203, 26, 39, 30, 2, -38 },
  { 1330, 17, 38, 30, 4, -38 },
  { 1411, 26, 38, 30, 2, -38 },
  { 1535, 26, 39, 30, 2, -38 },
  { 1662, 28, 38, 30, 1, -38 },
  { 1795, 25, 39, 30, 3, -38 },
  { 1917, 26, 39, 30, 2, -38 },
  { 2044, 26, 38, 30, 2, -38 },
  { 2168, 26, 39, 30, 2, -38 },
  { 2295, 26, 39, 30, 2, -38 },
  { 2422, 8, 30, 15, 3, -29 },
  { 2452, 9, 36, 15, 2, -29 },
  { 2493, 26, 27, 30, 2, -33 },
  { 2581, 25, 15, 30, 3, -26 },
  { 2628, 26, 27, 30, 2, -33 },
  { 2716, 23, 39, 24, 0, -38 },
  { 2829, 42, 42, 48, 3, -38 },
  { 3050, 36, 38, 36, 0, -38 },
  { 3221, 27, 38, 35, 5, -38 },
  { 3350, 29, 39, 34, 3, -38 },
  { 3492, 31, 38, 39, 5, -38 },
  { 3640, 21, 38, 30, 5, -38 },
  { 3740, 21, 38, 29, 5, -38 },
  { 3840, 31, 39, 38, 3, -38 },
  { 3992, 30, 38, 40, 5, -38 },
  { 4135, 16, 38, 20, 2, -38 },
  { 4211, 16, 49, 16, -4, -38 },
  { 4309, 29, 38, 34, 5, -38 },
  { 4447, 22, 38, 29, 5, -38 },
  { 4552, 39, 38, 49, 5, -38 },
  { 4738, 32, 38, 42, 5, -38 },
  { 4890, 36, 39, 42, 3, -38 },
  { 5066, 25, 38, 33, 5, -38 },
  { 5185, 36, 47, 42, 3, -38 },
  { 5397, 29, 38, 34, 5, -38 },
  { 5535, 24, 39, 29, 3, -38 },
  { 5652, 28, 38, 30, 1, -38 },
  { 5785, 30, 39, 40, 5, -38 },
  { 5932, 33, 38, 33, 0, -38 },
  { 6089, 50, 38, 51, 0, -38 },
  { 6327, 34, 38, 34, 0, -38 },
  { 6489, 32, 38, 32, 0, -38 },
  { 6641, 27, 38, 31, 2, -38 },
  { 6770, 12, 46, 17, 4, -38 },
  { 6839, 21, 38, 21, 0, -38 },
  { 6939, 13, 46, 17, 1, -38 },
  { 7014, 27, 24, 30, 2, -38 },
  { 7095, 23, 3, 22, 0, 5 },
  { 7104, 14, 9, 18, 2, -41 },
  { 7120, 25, 30, 31, 2, -29 },
  { 7214, 26, 41, 33, 4, -40 },
  { 7348, 22, 30, 27, 3, -29 },
  { 7431, 26, 41, 33, 3, -40 },
  { 7565, 25, 30, 31, 3, -29 },
  { 7659, 21, 41, 20, 1, -41 },
  { 7767, 26, 42, 33, 3, -29 },
  { 7904, 26, 40, 34, 4, -40 },
  { 8034, 7, 40, 15, 4, -40 },
  { 8069, 14, 53, 15, -3, -40 },
  { 8162, 27, 40, 31, 4, -40 },
  { 8297, 7, 40, 15, 4, -40 },
  { 8332, 43, 29, 51, 4, -29 },
  { 8488, 26, 29, 34, 4, -29 },
  { 8583, 27, 30, 33, 3, -29 },
  { 8685, 26, 42, 33, 4, -29 },
  { 8822, 26, 42, 33, 3, -29 },
  { 8959, 18, 29, 23, 4, -29 },
  { 9025, 21, 30, 26, 3, -29 },
  { 9104, 19, 36, 22, 1, -35 },
  { 9190, 26, 30, 34, 4, -29 },
  { 9288, 29, 29, 29, 0, -29 },
  { 9394, 42, 29, 44, 1, -29 },
  { 9547, 28, 29, 30, 1, -29 },
  { 9649, 29, 42, 29, 0, -29 },
  { 9802, 22, 29, 26, 2, -29 },
  { 9882, 18, 46, 21, 1, -38 },
  { 9986, 5, 52, 29, 12, -40 },
  { 10019, 18, 46, 21, 2, -38 },
  { 10123, 26, 8, 30, 2, -23 },
};

const GFXfont NotoSans_SemiBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMIBOLD53PT7B_H_
