#ifndef _NOTOSANS_SEMIBOLD11PT7B_H_
#define _NOTOSANS_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0x80, 0x14, 0x49, 0xF9, 0x42, 0x9F, 0x92, 0x2C, 0x27,
  0xE9, 0xC3, 0x1F, 0xEC, 0x20, 0x63, 0x29, 0x35, 0x0A, 0xE6, 0xA8, 0xD4,
  0x4A, 0x47, 0x38, 0x68, 0x68, 0x30, 0x7B, 0xCE, 0x46, 0x7B, 0xE0, 0x29,
  0x2D, 0x92, 0x44, 0xC8, 0x92, 0x4B, 0x58, 0x33, 0xB3, 0x1E, 0x30, 0x10,
  0x41, 0x3F, 0x10, 0x40, 0x70, 0xFC, 0xC0, 0x11, 0x22, 0x64, 0x4C, 0x39,
  0x24, 0xF3, 0xCD, 0x34, 0x9E, 0x3E, 0x92, 0x49, 0x7B, 0x30, 0xC2, 0x10,
  0xC4, 0x3F, 0xF9, 0x30, 0x8E, 0x38, 0x38, 0xFE, 0x18, 0x62, 0x9A, 0x4B,
  0xF0, 0x82, 0xF4, 0x21, 0xE1, 0x8E, 0x7E, 0x39, 0x84, 0x1E, 0xCD, 0x14,
  0xCE, 0xFC, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x79, 0x34, 0xDE, 0x7B, 0x3C,
  0xDE, 0x79, 0x2C, 0xF3, 0x7C, 0x30, 0x9C, 0xCC, 0x50, 0x1C, 0x04, 0x66,
  0x38, 0x18, 0x10, 0xF8, 0x3E, 0x81, 0x81, 0x87, 0x72, 0x00, 0xF4, 0xC6,
  0x62, 0x10, 0x8C, 0x3C, 0x43, 0x9D, 0xA5, 0xA5, 0xA5, 0x9A, 0xC0, 0x3C,
  0x18, 0x70, 0xA1, 0x66, 0x4F, 0x91, 0xE1, 0xFA, 0x28, 0xBE, 0x9A, 0x38,
  0xFE, 0x7F, 0x28, 0x20, 0x82, 0x0C, 0x1E, 0xF2, 0x38, 0x61, 0x86, 0x18,
  0xFE, 0xF8, 0x8F, 0xF8, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x3F, 0x18, 0x20,
  0x9E, 0x1C, 0x5F, 0x86, 0x18, 0x7F, 0xFE, 0x18, 0x61, 0xF6, 0x66, 0x66,
  0x6F, 0x24, 0x92, 0x49, 0x3C, 0x8E, 0x69, 0x28, 0xF2, 0x49, 0xA3, 0x84,
  0x21, 0x08, 0x42, 0x1F, 0xC3, 0xC3, 0xA7, 0xA5, 0xA5, 0x9D, 0x99, 0x99,
  0xC7, 0xCE, 0x9D, 0xB9, 0x73, 0xE3, 0xC3, 0x79, 0x8A, 0x1C, 0x38, 0x30,
  0xF1, 0x3E, 0xF4, 0xE3, 0x1F, 0x42, 0x10, 0x79, 0x8A, 0x1C, 0x38, 0x30,
  0xF1, 0x3E, 0x0C, 0x0C, 0xF2, 0x68, 0xA6, 0xF2, 0x48, 0xA3, 0xF4, 0xA1,
  0xC7, 0x0E, 0x7E, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x86, 0x18, 0x61,
  0x86, 0x1C, 0xDE, 0xC7, 0x89, 0x13, 0x62, 0x85, 0x0A, 0x08, 0xCC, 0x73,
  0x14, 0xED, 0x2B, 0x7A, 0x9C, 0xA3, 0x38, 0xC6, 0xC6, 0xD8, 0xA1, 0xC3,
  0x85, 0x1B, 0x63, 0xC6, 0x99, 0xA1, 0xC3, 0x02, 0x04, 0x08, 0xFC, 0x31,
  0x84, 0x31, 0x84, 0x3F, 0xEA, 0xAA, 0xB0, 0xC4, 0x46, 0x22, 0x31, 0xE4,
  0x92, 0x49, 0x3C, 0x30, 0xC2, 0x92, 0xC4, 0xF8, 0xE0, 0x78, 0x33, 0xD3,
  0xCD, 0xF0, 0x84, 0x2D, 0x98, 0xC7, 0x3F, 0x78, 0x88, 0x8F, 0x08, 0x7B,
  0x38, 0xC6, 0x7D, 0x74, 0xFF, 0x08, 0x3C, 0x7B, 0x3C, 0xC6, 0x31, 0x8C,
  0xEC, 0xE3, 0x19, 0xF4, 0x3F, 0x60, 0x84, 0x2F, 0x98, 0xC6, 0x31, 0xBF,
  0x20, 0x92, 0x49, 0x3F, 0x00, 0x84, 0x27, 0x6E, 0x7A, 0x53, 0xFF, 0xFF,
  0x6C, 0xE2, 0x71, 0x38, 0x9C, 0x4C, 0xFE, 0x63, 0x18, 0xC4, 0x74, 0xE3,
  0x19, 0xB8, 0xBE, 0x63, 0x1C, 0xFE, 0x10, 0x80, 0xEC, 0xE3, 0x19, 0xF4,
  0x21, 0x08, 0xBC, 0x88, 0x88, 0xF8, 0xC3, 0x1E, 0x4F, 0x44, 0x44, 0x70,
  0x8C, 0x63, 0x19, 0xFC, 0xCD, 0x24, 0x9E, 0x30, 0xC0, 0xC8, 0xAA, 0xD5,
  0x4A, 0xA7, 0x51, 0x10, 0xCD, 0xE3, 0x0C, 0x6B, 0x30, 0xCD, 0x24, 0x9E,
  0x30, 0xC3, 0x38, 0xC0, 0x78, 0x8C, 0x44, 0x7C, 0x32, 0x22, 0xEE, 0x22,
  0x23, 0xFF, 0xE0, 0xC6, 0x66, 0x33, 0x66, 0x6C, 0x66, 0x70,
};

const GFXglyph NotoSans_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 5, 9, 6, 1, -8 },
  { 17, 9, 8, 10, 0, -8 },
  { 26, 8, 8, 8, 0, -8 },
  { 34, 1, 3, 3, 1, -8 },
  { 35, 3, 10, 4, 0, -8 },
  { 39, 3, 10, 4, 0, -8 },
  { 43, 6, 5, 6, 0, -8 },
  { 47, 6, 6, 6, 0, -7 },
  { 52, 2, 2, 3, 0, -1 },
  { 53, 3, 2, 4, 0, -4 },
  { 54, 1, 2, 3, 1, -2 },
  { 55, 4, 8, 4, 0, -8 },
  { 59, 6, 8, 6, 0, -8 },
  { 65, 3, 8, 6, 1, -8 },
  { 68, 6, 8, 6, 0, -8 },
  { 74, 6, 8, 6, 0, -8 },
  { 80, 6, 8, 6, 0, -8 },
  { 86, 5, 8, 6, 1, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 6, 8, 6, 0, -8 },
  { 103, 6, 8, 6, 0, -8 },
  { 109, 6, 8, 6, 0, -8 },
  { 115, 1, 6, 3, 1, -6 },
  { 116, 2, 7, 3, 0, -6 },
  { 118, 6, 6, 6, 0, -7 },
  { 123, 5, 3, 6, 1, -5 },
  { 125, 6, 6, 6, 0, -7 },
  { 130, 5, 8, 5, 0, -8 },
  { 135, 8, 9, 10, 1, -8 },
  { 144, 7, 8, 7, 0, -8 },
  { 151, 6, 8, 7, 1, -8 },
  { 157, 6, 8, 7, 1, -8 },
  { 163, 6, 8, 8, 1, -8 },
  { 169, 4, 8, 6, 1, -8 },
  { 173, 4, 8, 6, 1, -8 },
  { 177, 6, 8, 8, 1, -8 },
  { 183, 6, 8, 8, 1, -8 },
  { 189, 4, 8, 4, 0, -8 },
  { 193, 3, 10, 3, -1, -8 },
  { 197, 6, 8, 7, 1, -8 },
  { 203, 5, 8, 6, 1, -8 },
  { 208, 8, 8, 10, 1, -8 },
  { 216, 7, 8, 9, 1, -8 },
  { 223, 7, 8, 9, 1, -8 },
  { 230, 5, 8, 7, 1, -8 },
  { 235, 7, 10, 9, 1, -8 },
  { 244, 6, 8, 7, 1, -8 },
  { 250, 5, 8, 6, 1, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 8, 1, -8 },
  { 267, 7, 8, 7, 0, -8 },
  { 274, 10, 8, 10, 0, -8 },
  { 284, 7, 8, 7, 0, -8 },
  { 291, 7, 8, 7, 0, -8 },
  { 298, 6, 8, 6, 0, -8 },
  { 304, 2, 10, 4, 1, -8 },
  { 307, 4, 8, 4, 0, -8 },
  { 311, 3, 10, 4, 0, -8 },
  { 315, 6, 5, 6, 0, -8 },
  { 319, 5, 1, 5, 0, 1 },
  { 320, 3, 1, 4, 0, -8 },
  { 321, 6, 6, 6, 0, -6 },
  { 326, 5, 8, 7, 1, -8 },
  { 331, 4, 6, 6, 1, -6 },
  { 334, 5, 8, 7, 1, -8 },
  { 339, 5, 6, 6, 1, -6 },
  { 343, 5, 8, 4, 0, -8 },
  { 348, 5, 9, 7, 1, -6 },
  { 354, 5, 8, 7, 1, -8 },
  { 359, 1, 8, 3, 1, -8 },
  { 360, 3, 11, 3, -1, -8 },
  { 365, 5, 8, 6, 1, -8 },
  { 370, 1, 8, 3, 1, -8 },
  { 371, 9, 6, 11, 1, -6 },
  { 378, 5, 6, 7, 1, -6 },
  { 382, 5, 6, 7, 1, -6 },
  { 386, 5, 9, 7, 1, -6 },
  { 392, 5, 9, 7, 1, -6 },
  { 398, 4, 6, 5, 1, -6 },
  { 401, 4, 6, 5, 1, -6 },
  { 404, 4, 7, 4, 0, -7 },
  { 408, 5, 6, 7, 1, -6 },
  { 412, 6, 6, 6, 0, -6 },
  { 417, 9, 6, 9, 0, -6 },
  { 424, 6, 6, 6, 0, -6 },
  { 429, 6, 9, 6, 0, -6 },
  { 436, 5, 6, 5, 0, -6 },
  { 440, 4, 10, 4, 0, -8 },
  { 445, 1, 11, 6, 3, -8 },
  { 447, 4, 10, 4, 0, -8 },
  { 452, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMIBOLD11PT7B_H_
