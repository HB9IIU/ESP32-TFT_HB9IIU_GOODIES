#ifndef _NOTOSANS_SEMIBOLD67PT7B_H_
#define _NOTOSANS_SEMIBOLD67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFE, 0x1E, 0x00, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0,
  0xFF, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E,
  0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xC0, 0x78, 0x7F, 0x83,
  0xC0, 0x08, 0xFF, 0x83, 0xC0, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0xFF, 0x83,
  0xC0, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x7F, 0xE3,
  0xC0, 0x00, 0x7F, 0xFB, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xC7, 0xFF, 0x00, 0x03, 0xC3, 0xFF, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x03,
  0xC0, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x03,
  0xC0, 0xFF, 0xF0, 0x03, 0xC1, 0xFF, 0xFF, 0x03, 0xC7, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xFE, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0xFF,
  0x3F, 0xC1, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xF8, 0xFE,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xFC,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x01, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xFD, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x07,
  0xE0, 0x06, 0x7E, 0x07, 0xE0, 0x3E, 0x7F, 0xE3, 0xE3, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xE1, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE,
  0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFD,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xBF, 0x83, 0xFC, 0xF8, 0x1F, 0xE3,
  0x80, 0xFF, 0x10, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFC, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0x81,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xFC, 0x3F, 0x80, 0x0F,
  0xFC, 0x1E, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x18, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x60, 0x00, 0x07, 0xFE, 0xF8, 0x00, 0x3F, 0xF9,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE3, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0x07, 0xFB, 0xFF,
  0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC,
  0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFD,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0x9F,
  0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x0C, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0x7F, 0x87, 0x80, 0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0xF8, 0xE0, 0x00,
  0x7F, 0xC4, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x7E, 0x7F, 0x01, 0xFE, 0x00, 0x7E, 0x01,
  0xFD, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0x07,
  0xE0, 0x0F, 0xDF, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x7E, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xC0, 0x03, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0xFE, 0x7E, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC0, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x00, 0xFF,
  0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x7F, 0xF8, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x7F, 0xFE, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x03,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x01, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x70, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xFF, 0xDF, 0xE0, 0x00, 0x1F, 0xEF,
  0xFF, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xFF, 0xC7, 0xF0, 0x00, 0x3F,
  0x8F, 0xFF, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE,
  0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xE7,
  0xFC, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x3F,
  0xE7, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x03, 0xF0, 0xFF, 0xC0, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x9F, 0xFF, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xEF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC,
  0x7F, 0xFF, 0xE3, 0xF8, 0x7F, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0x9F, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xF8,
  0x0F, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0x7C, 0x3F, 0xF8, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0x1F, 0xFC, 0x00, 0x38, 0x7F, 0xFE,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0x01,
  0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x01, 0xFF,
  0xF3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE,
  0x0F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFB, 0xFC, 0x1F,
  0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0x07, 0xF0,
  0x07, 0xFF, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x10, 0xFF, 0xC0, 0x00, 0x30,
  0x7F, 0xF8, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xC0, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x03,
  0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0xDF,
  0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x03,
  0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xC7, 0xFF, 0xFF, 0x8F, 0xF7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0xF0, 0x0F, 0xF1,
  0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xF8,
  0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xDF,
  0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x80, 0xFF,
  0x87, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xE3,
  0xFC, 0x0F, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xDF,
  0xF0, 0x3F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xC0, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE3, 0xFC, 0x00, 0x3C,
  0xFF, 0x80, 0x01, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x03,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0x8F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF3, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x3F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF,
  0xE0, 0x1F, 0x8F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x01,
  0xFC, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x58, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x01, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x80, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_SemiBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 49, 19, 4, -48 },
  { 63, 22, 17, 30, 4, -48 },
  { 110, 40, 48, 43, 2, -48 },
  { 350, 32, 55, 38, 3, -51 },
  { 570, 54, 50, 59, 2, -49 },
  { 908, 47, 50, 50, 3, -49 },
  { 1202, 9, 17, 17, 4, -48 },
  { 1222, 17, 59, 22, 3, -48 },
  { 1348, 17, 59, 22, 2, -48 },
  { 1474, 32, 31, 37, 2, -51 },
  { 1598, 32, 33, 38, 3, -40 },
  { 1730, 12, 17, 19, 2, -8 },
  { 1756, 17, 8, 21, 2, -22 },
  { 1773, 10, 11, 18, 4, -10 },
  { 1787, 25, 48, 27, 1, -48 },
  { 1937, 33, 50, 38, 3, -49 },
  { 2144, 21, 48, 38, 5, -48 },
  { 2270, 33, 49, 38, 3, -49 },
  { 2473, 32, 50, 38, 3, -49 },
  { 2673, 36, 48, 38, 1, -48 },
  { 2889, 31, 49, 38, 4, -48 },
  { 3079, 33, 49, 38, 3, -48 },
  { 3282, 34, 48, 38, 2, -48 },
  { 3486, 33, 49, 38, 3, -48 },
  { 3689, 33, 49, 38, 3, -48 },
  { 3892, 10, 38, 18, 4, -37 },
  { 3940, 12, 46, 19, 2, -37 },
  { 4009, 32, 34, 38, 3, -41 },
  { 4145, 32, 19, 38, 3, -33 },
  { 4221, 32, 34, 38, 3, -41 },
  { 4357, 29, 50, 31, 0, -49 },
  { 4539, 54, 54, 60, 3, -48 },
  { 4904, 45, 48, 45, 0, -48 },
  { 5174, 35, 48, 44, 6, -48 },
  { 5384, 37, 50, 43, 4, -49 },
  { 5616, 39, 48, 49, 6, -48 },
  { 5850, 27, 48, 37, 6, -48 },
  { 6012, 27, 48, 36, 6, -48 },
  { 6174, 39, 50, 49, 4, -49 },
  { 6418, 38, 48, 51, 6, -48 },
  { 6646, 20, 48, 25, 2, -48 },
  { 6766, 20, 62, 21, -5, -48 },
  { 6921, 37, 48, 43, 6, -48 },
  { 7143, 29, 48, 37, 6, -48 },
  { 7317, 50, 48, 62, 6, -48 },
  { 7617, 41, 48, 53, 6, -48 },
  { 7863, 45, 50, 53, 4, -49 },
  { 8145, 32, 48, 41, 6, -48 },
  { 8337, 45, 60, 53, 4, -49 },
  { 8675, 37, 48, 43, 6, -48 },
  { 8897, 31, 50, 37, 3, -49 },
  { 9091, 36, 48, 38, 1, -48 },
  { 9307, 38, 49, 50, 6, -48 },
  { 9540, 42, 48, 42, 0, -48 },
  { 9792, 64, 48, 64, 0, -48 },
  { 10176, 42, 48, 43, 0, -48 },
  { 10428, 40, 48, 40, 0, -48 },
  { 10668, 35, 48, 39, 2, -48 },
  { 10878, 15, 59, 22, 5, -48 },
  { 10989, 26, 48, 27, 0, -48 },
  { 11145, 15, 59, 22, 2, -48 },
  { 11256, 34, 31, 38, 2, -48 },
  { 11388, 28, 4, 28, 0, 6 },
  { 11402, 17, 10, 22, 3, -51 },
  { 11424, 31, 38, 39, 3, -37 },
  { 11572, 34, 52, 42, 5, -51 },
  { 11793, 29, 38, 34, 3, -37 },
  { 11931, 34, 52, 42, 3, -51 },
  { 12152, 33, 38, 39, 3, -37 },
  { 12309, 27, 51, 25, 1, -51 },
  { 12482, 34, 53, 42, 3, -37 },
  { 12708, 33, 51, 43, 5, -51 },
  { 12919, 9, 50, 19, 5, -50 },
  { 12976, 18, 66, 19, -4, -50 },
  { 13125, 34, 51, 39, 5, -51 },
  { 13342, 9, 51, 19, 5, -51 },
  { 13400, 54, 37, 64, 5, -37 },
  { 13650, 33, 37, 43, 5, -37 },
  { 13803, 35, 38, 41, 3, -37 },
  { 13970, 34, 53, 42, 5, -37 },
  { 14196, 34, 53, 42, 3, -37 },
  { 14422, 23, 37, 29, 5, -37 },
  { 14529, 27, 38, 33, 3, -37 },
  { 14658, 24, 45, 27, 1, -44 },
  { 14793, 33, 37, 43, 5, -36 },
  { 14946, 37, 36, 37, 0, -36 },
  { 15113, 54, 36, 56, 1, -36 },
  { 15356, 36, 36, 38, 1, -36 },
  { 15518, 37, 52, 37, 0, -36 },
  { 15759, 28, 36, 32, 2, -36 },
  { 15885, 23, 59, 26, 1, -48 },
  { 16055, 7, 67, 37, 15, -51 },
  { 16114, 23, 59, 26, 2, -48 },
  { 16284, 32, 11, 38, 3, -29 },
};

const GFXfont NotoSans_SemiBold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMIBOLD67PT7B_H_
