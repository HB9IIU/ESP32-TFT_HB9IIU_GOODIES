#ifndef _NOTOSANS_SEMIBOLD13PT7B_H_
#define _NOTOSANS_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0xC0, 0xB9, 0x90, 0x12, 0x12, 0x7F, 0x7F, 0x24, 0xFF,
  0x24, 0x2C, 0x68, 0x21, 0xFF, 0xA8, 0xE1, 0xE2, 0xEB, 0xF8, 0x82, 0x00,
  0x71, 0x8B, 0x23, 0x68, 0x2F, 0x67, 0x56, 0x1A, 0x42, 0x48, 0xCB, 0x31,
  0xC0, 0x78, 0x64, 0x12, 0x0E, 0x0F, 0x36, 0xDA, 0x39, 0x9C, 0x7B, 0x80,
  0xE0, 0x7A, 0x49, 0x24, 0xD9, 0x80, 0xC6, 0x23, 0x33, 0x32, 0x26, 0xC0,
  0x10, 0x21, 0xFC, 0x82, 0x8D, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0x6D, 0x60, 0xF0, 0xF0, 0x18, 0x84, 0x62, 0x31, 0x88, 0xC0, 0xFB, 0x28,
  0xE3, 0x8E, 0x38, 0xF2, 0x78, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0xFA, 0x30,
  0xC2, 0x18, 0xC6, 0x30, 0xFC, 0xFA, 0x30, 0x86, 0x78, 0x30, 0xE7, 0xF8,
  0x0C, 0x38, 0xF1, 0x66, 0xD9, 0xBF, 0x86, 0x0C, 0xFB, 0x0C, 0x3C, 0xF8,
  0x30, 0xE6, 0xF8, 0x7B, 0x08, 0x2E, 0xCE, 0x38, 0xF3, 0x78, 0xFE, 0x0C,
  0x10, 0x60, 0x83, 0x04, 0x18, 0x30, 0xFA, 0x3C, 0xDE, 0x7B, 0x38, 0xE3,
  0xF8, 0x7C, 0x8B, 0x1A, 0x37, 0xE6, 0xC1, 0x06, 0x78, 0xF0, 0x3C, 0x6C,
  0x00, 0xD2, 0xC0, 0x04, 0x66, 0x30, 0x70, 0x70, 0x40, 0xFC, 0x0F, 0xC0,
  0x83, 0x83, 0x83, 0x33, 0x08, 0x00, 0xFA, 0x30, 0xC6, 0x30, 0x80, 0x08,
  0x30, 0x3F, 0x18, 0x2C, 0xEE, 0x49, 0xB2, 0x6C, 0x99, 0x7A, 0x24, 0x41,
  0x0F, 0xC0, 0x1C, 0x0E, 0x0D, 0x06, 0xC2, 0x63, 0xF1, 0xFC, 0x86, 0xC1,
  0x80, 0xFD, 0x8F, 0x1E, 0x6F, 0xD8, 0xF1, 0xE7, 0xFC, 0x7F, 0xC7, 0x06,
  0x08, 0x18, 0x30, 0x31, 0x3E, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6,
  0xCE, 0xF8, 0xFE, 0x31, 0xFF, 0xE3, 0x18, 0xF8, 0xFE, 0x31, 0x8F, 0xE3,
  0x18, 0xC0, 0x7E, 0xC7, 0x06, 0x0C, 0xF8, 0x70, 0xB1, 0x3E, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xF2, 0x22, 0x22, 0x22, 0xF0,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xC7, 0x9B, 0x67, 0x8F, 0x1B, 0x33,
  0x66, 0xC6, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xE1, 0xF8, 0x7E,
  0x1F, 0xCF, 0xD2, 0xF4, 0xBD, 0xEF, 0x33, 0xCC, 0xC0, 0xE1, 0xE1, 0xF1,
  0xD9, 0xD9, 0xCD, 0xC5, 0xC7, 0xC3, 0x7E, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1,
  0xC3, 0x67, 0x3E, 0xFF, 0x3C, 0x73, 0xFF, 0xCC, 0x30, 0xC0, 0x7E, 0xC3,
  0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0x67, 0x3E, 0x06, 0x07, 0xFD, 0x9B, 0x16,
  0x6F, 0x9B, 0x33, 0x66, 0xC6, 0xFB, 0x28, 0x38, 0x78, 0x60, 0xE6, 0xF8,
  0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC2, 0x66, 0x7C, 0xC3, 0x43, 0x62, 0x66, 0x26, 0x34, 0x3C,
  0x1C, 0x18, 0xC6, 0x34, 0x63, 0x47, 0x36, 0xD2, 0x6D, 0x22, 0x9E, 0x29,
  0xE3, 0x8C, 0x30, 0xC0, 0xE3, 0x66, 0x3C, 0x1C, 0x18, 0x3C, 0x26, 0x66,
  0xC3, 0xC3, 0x66, 0x64, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x0C,
  0x30, 0xC1, 0x06, 0x18, 0x20, 0xFE, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2,
  0x18, 0x42, 0x18, 0x43, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x70,
  0xA3, 0x24, 0x58, 0x40, 0xFC, 0xCC, 0xFA, 0x30, 0xFF, 0x8E, 0x7F, 0xC0,
  0xC3, 0x0C, 0x3E, 0xCF, 0x1C, 0x71, 0xCE, 0xE0, 0x7E, 0x61, 0x08, 0x65,
  0xE0, 0x0C, 0x30, 0xDD, 0xCE, 0x38, 0x63, 0xCD, 0xD0, 0x7B, 0x38, 0xFF,
  0x83, 0x17, 0xC0, 0x3B, 0x59, 0xF6, 0x31, 0x8C, 0x63, 0x00, 0x77, 0x38,
  0xE1, 0x87, 0x37, 0xC3, 0x8F, 0xE0, 0xC3, 0x0C, 0x3F, 0xCF, 0x1C, 0x71,
  0xC7, 0x10, 0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0xE0,
  0xC1, 0x83, 0x06, 0x6D, 0x9E, 0x3C, 0x6C, 0xC9, 0x9C, 0xFF, 0xFF, 0xF0,
  0xBF, 0xD9, 0xCB, 0x31, 0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x18, 0xBF, 0x3C,
  0x71, 0xC7, 0x1C, 0x40, 0x7B, 0x38, 0x61, 0x87, 0x37, 0x80, 0xBF, 0x3C,
  0x71, 0xC7, 0x3F, 0xB0, 0xC3, 0x00, 0x77, 0x38, 0xE1, 0x8F, 0x37, 0xC3,
  0x0C, 0x30, 0xBE, 0xCC, 0xCC, 0xC0, 0xFC, 0x70, 0xE1, 0xCF, 0xC0, 0x23,
  0x3E, 0xC6, 0x31, 0x8C, 0x38, 0xC7, 0x1C, 0x71, 0xC7, 0x37, 0x40, 0xC6,
  0x8D, 0x93, 0x62, 0x87, 0x0E, 0x00, 0xCC, 0x69, 0xC9, 0x2B, 0x35, 0x67,
  0xA8, 0x67, 0x0C, 0x60, 0xC6, 0xD8, 0xE0, 0xC3, 0x8D, 0xB1, 0x80, 0xC6,
  0x8D, 0x93, 0x62, 0x87, 0x06, 0x08, 0x31, 0xC0, 0x7C, 0x21, 0x8C, 0x21,
  0x8F, 0xC0, 0x39, 0x08, 0x46, 0x60, 0x84, 0x21, 0x8E, 0xFF, 0xF8, 0xE1,
  0x08, 0x43, 0x0C, 0x84, 0x23, 0x38, 0x47, 0xF0,
};

const GFXglyph NotoSans_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 11, 9, 11, 0, -9 },
  { 37, 9, 9, 10, 1, -9 },
  { 48, 1, 3, 3, 1, -9 },
  { 49, 3, 11, 4, 1, -9 },
  { 54, 4, 11, 4, 0, -9 },
  { 60, 7, 6, 7, 0, -10 },
  { 66, 6, 7, 7, 1, -8 },
  { 72, 3, 4, 4, 0, -2 },
  { 74, 4, 1, 4, 0, -4 },
  { 75, 2, 2, 4, 1, -2 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 6, 9, 7, 1, -9 },
  { 89, 4, 9, 7, 1, -9 },
  { 94, 6, 9, 7, 1, -9 },
  { 101, 6, 9, 7, 1, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 6, 9, 7, 1, -9 },
  { 130, 7, 9, 7, 0, -9 },
  { 138, 6, 9, 7, 1, -9 },
  { 145, 7, 9, 7, 0, -9 },
  { 153, 2, 7, 4, 1, -7 },
  { 155, 3, 9, 4, 0, -7 },
  { 159, 6, 7, 7, 1, -8 },
  { 165, 6, 3, 7, 1, -6 },
  { 168, 6, 7, 7, 1, -8 },
  { 174, 6, 9, 6, 0, -9 },
  { 181, 10, 10, 12, 1, -9 },
  { 194, 9, 9, 9, 0, -9 },
  { 205, 7, 9, 9, 1, -9 },
  { 213, 7, 9, 8, 1, -9 },
  { 221, 8, 9, 10, 1, -9 },
  { 230, 5, 9, 7, 1, -9 },
  { 236, 5, 9, 7, 1, -9 },
  { 242, 7, 9, 9, 1, -9 },
  { 250, 8, 9, 10, 1, -9 },
  { 259, 4, 9, 5, 0, -9 },
  { 264, 4, 12, 4, -1, -9 },
  { 270, 7, 9, 8, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 10, 9, 12, 1, -9 },
  { 297, 8, 9, 10, 1, -9 },
  { 306, 8, 9, 10, 1, -9 },
  { 315, 6, 9, 8, 1, -9 },
  { 322, 8, 11, 10, 1, -9 },
  { 333, 7, 9, 8, 1, -9 },
  { 341, 6, 9, 7, 1, -9 },
  { 348, 7, 9, 7, 0, -9 },
  { 356, 8, 9, 10, 1, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 12, 9, 12, 0, -9 },
  { 388, 8, 9, 8, 0, -9 },
  { 397, 8, 9, 8, 0, -9 },
  { 406, 7, 9, 7, 0, -9 },
  { 414, 3, 11, 4, 1, -9 },
  { 419, 5, 9, 5, 0, -9 },
  { 425, 3, 11, 4, 0, -9 },
  { 430, 7, 6, 7, 0, -9 },
  { 436, 6, 1, 6, 0, 1 },
  { 437, 3, 2, 4, 1, -10 },
  { 438, 6, 7, 8, 1, -7 },
  { 444, 6, 10, 8, 1, -10 },
  { 452, 5, 7, 7, 1, -7 },
  { 457, 6, 10, 8, 1, -10 },
  { 465, 6, 7, 8, 1, -7 },
  { 471, 5, 10, 5, 0, -10 },
  { 478, 6, 10, 8, 1, -7 },
  { 486, 6, 10, 8, 1, -10 },
  { 494, 2, 10, 4, 1, -10 },
  { 497, 4, 13, 4, -1, -10 },
  { 504, 7, 10, 8, 1, -10 },
  { 513, 2, 10, 4, 1, -10 },
  { 516, 11, 7, 12, 1, -7 },
  { 526, 6, 7, 8, 1, -7 },
  { 532, 6, 7, 8, 1, -7 },
  { 538, 6, 10, 8, 1, -7 },
  { 546, 6, 10, 8, 1, -7 },
  { 554, 4, 7, 6, 1, -7 },
  { 558, 5, 7, 6, 1, -7 },
  { 563, 5, 9, 5, 0, -9 },
  { 569, 6, 7, 8, 1, -7 },
  { 575, 7, 7, 7, 0, -7 },
  { 582, 11, 7, 11, 0, -7 },
  { 592, 7, 7, 7, 0, -7 },
  { 599, 7, 10, 7, 0, -7 },
  { 608, 6, 7, 6, 0, -7 },
  { 614, 5, 11, 5, 0, -9 },
  { 621, 1, 13, 7, 3, -10 },
  { 623, 5, 11, 5, 0, -9 },
  { 630, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMIBOLD13PT7B_H_
