#ifndef _ROBOTOCONDENSED_EXTRABOLD52PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E,
  0xF8, 0x7B, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0xE3, 0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x07, 0x8F, 0x80, 0x07, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x8F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x87,
  0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x80, 0x3E, 0x3E, 0x07, 0x03, 0xF1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xC3, 0xE1, 0xE0, 0x3E, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0xF0, 0x07, 0xC7, 0xCF, 0x80, 0x3F, 0xFE, 0x78,
  0x00, 0xFF, 0xE7, 0xC0, 0x07, 0xFF, 0x3C, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x08, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x07, 0xCF,
  0xFC, 0x00, 0x3E, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0x80, 0x1E, 0x7E, 0x7E,
  0x01, 0xF3, 0xE1, 0xF0, 0x0F, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x7C, 0x07,
  0x87, 0xC3, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x1E, 0x0F,
  0xCF, 0xC0, 0x20, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF1,
  0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xF7, 0xF9, 0xF8, 0xFF, 0x7F, 0xFF, 0x8F,
  0xF3, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F,
  0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xC0, 0x7F, 0xE3, 0xFE, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0,
  0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x20, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1E, 0x02, 0x3C, 0x3C, 0x1E, 0xFF, 0x79,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0x80,
  0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00,
  0xC0, 0x38, 0x00, 0x80, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE7, 0xE1, 0xF0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x3F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF1,
  0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFE,
  0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF,
  0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3E, 0xFF, 0x00,
  0xFD, 0xFE, 0x01, 0xF3, 0xFC, 0x07, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F,
  0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1,
  0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x8F, 0xC1, 0xFE, 0x02, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF9, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F,
  0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x8F, 0xF1, 0xFF, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xF1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F,
  0x83, 0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xFD, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xF7, 0xF8, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF1, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFB, 0xF8, 0x0F,
  0xCF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF3, 0xF0, 0x40, 0x0E, 0x0F, 0xE7,
  0xF9, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC, 0x1E, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xF1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x3C, 0x3F, 0x01, 0xFF, 0x83, 0xE3, 0xE0,
  0x3F, 0xFC, 0x3E, 0x3E, 0x07, 0xFF, 0xC1, 0xE7, 0xC0, 0xFF, 0xFC, 0x1E,
  0x7C, 0x0F, 0xC7, 0xC1, 0xF7, 0xC1, 0xF8, 0x7C, 0x1F, 0x7C, 0x1F, 0x07,
  0xC1, 0xFF, 0x83, 0xF0, 0x7C, 0x1F, 0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFC, 0x1F,
  0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F,
  0x81, 0xEF, 0x87, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F, 0x83, 0xEF, 0x87,
  0xE1, 0xF8, 0x3E, 0xF8, 0x7F, 0x1F, 0x87, 0xCF, 0x83, 0xFB, 0xFC, 0x7C,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xC1, 0xFF, 0xFF, 0xF0, 0x7C, 0x1F, 0xF3,
  0xFE, 0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x01, 0x00, 0x60, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xE7, 0xF8, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFB, 0xFC, 0x0F, 0xFC,
  0xFF, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC,
  0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xDF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0x7F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFB, 0xF0, 0x7E, 0xFF, 0xFE, 0xFC,
  0x1F, 0xBF, 0xFF, 0xBF, 0x87, 0xEF, 0xFF, 0xE7, 0xE1, 0xFB, 0xFF, 0xF9,
  0xF8, 0xFC, 0xFF, 0xFE, 0x7E, 0x3F, 0x3F, 0xFF, 0x9F, 0xCF, 0xCF, 0xFF,
  0xE3, 0xF7, 0xF3, 0xFF, 0xFC, 0xFD, 0xF8, 0xFF, 0xFF, 0x3F, 0x7E, 0x3F,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7E, 0x3F, 0xFF,
  0xDF, 0xCF, 0xFF, 0xF3, 0xF3, 0xFF, 0xFC, 0xFC, 0xFF, 0xFF, 0x1F, 0xBF,
  0xFF, 0xC7, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x87,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0xFF,
  0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8,
  0x3F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF8, 0x3F,
  0xCF, 0xF0, 0x7F, 0xC1, 0xFE, 0x7F, 0x87, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0xFC,
  0x7F, 0x03, 0xF9, 0xFF, 0xF3, 0xF8, 0x1F, 0xCF, 0xFF, 0xBF, 0xC0, 0xFF,
  0x7F, 0xFD, 0xFE, 0x07, 0xFB, 0xF7, 0xEF, 0xF0, 0x3F, 0xFF, 0xBF, 0x7F,
  0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80,
  0x7F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03,
  0xF7, 0xE0, 0x7C, 0xFC, 0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x83, 0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0x80, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8,
  0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x87, 0xFB,
  0xFE, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFD,
  0xFE, 0x3F, 0xCF, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0x00, 0xFF, 0x3F, 0xC3, 0xFD, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFD, 0xFF, 0x8F, 0xF3, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFD, 0xFE,
  0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0x07, 0xF0, 0xFF, 0x3F,
  0x8F, 0xFD, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFC, 0x3F, 0xCF, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF, 0x03, 0xFB,
  0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x41, 0xFE, 0x03, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF1, 0xFF, 0xDF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x00, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC2, 0x01, 0xFE, 0x1E, 0x0F, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x7F, 0xBF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE0, 0x1E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0xA7, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xDF, 0xE0, 0xFF, 0xBF, 0xC3, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF,
  0x1F, 0xF1, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0x3F, 0xC1, 0xFC, 0x3F, 0xBF, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x1F, 0xF1, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF,
  0x83, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x3F, 0xDF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x0F, 0xF7, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xF7, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x04, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFE, 0xFE, 0x1F, 0xE7, 0xF0, 0x08, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFF,
  0x7F, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x83,
  0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x06, 0x00, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xDF, 0xC3, 0xFC, 0xFE, 0x03, 0x00, 0x00,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0x7F,
  0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0,
  0x7F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xC1, 0xFF, 0xFC, 0x1F, 0x83, 0xFF, 0xFC,
  0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x1F, 0xCF, 0xE3,
  0xFC, 0x3F, 0x9F, 0xC7, 0xFC, 0xFF, 0x3F, 0x8F, 0xF9, 0xFC, 0x3F, 0x1F,
  0xF3, 0xF8, 0x7F, 0x7F, 0xE7, 0xF0, 0xFE, 0xFF, 0xCF, 0xE1, 0xFD, 0xFF,
  0xDF, 0xC3, 0xFB, 0xFF, 0xBF, 0x03, 0xF7, 0xDF, 0xFE, 0x07, 0xFF, 0xBF,
  0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF3, 0xFC, 0x3F,
  0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x3F,
  0xC3, 0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xFB, 0xFC, 0x1F, 0xEF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB,
  0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F,
  0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F,
  0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x20, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x78, 0x01, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x3F, 0x3F, 0xFC,
  0x3F, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7F, 0xFE, 0x7E, 0x3F,
  0xFE, 0x7C, 0x1F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x07, 0xF8, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_ExtraBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 14, 14, 17, 1, -39 },
  { 64, 24, 37, 27, 1, -37 },
  { 175, 22, 49, 26, 2, -43 },
  { 310, 29, 39, 33, 2, -38 },
  { 452, 28, 39, 31, 2, -38 },
  { 589, 6, 14, 8, 1, -39 },
  { 600, 12, 53, 17, 3, -41 },
  { 680, 13, 53, 17, 1, -41 },
  { 767, 23, 23, 24, 1, -37 },
  { 834, 21, 27, 24, 2, -31 },
  { 905, 9, 16, 13, 1, -6 },
  { 923, 12, 6, 20, 4, -19 },
  { 932, 9, 9, 15, 3, -8 },
  { 943, 16, 40, 17, 0, -37 },
  { 1023, 22, 39, 26, 2, -38 },
  { 1131, 15, 37, 26, 4, -37 },
  { 1201, 22, 38, 26, 2, -38 },
  { 1306, 22, 39, 26, 2, -38 },
  { 1414, 23, 37, 26, 2, -37 },
  { 1521, 22, 38, 26, 2, -37 },
  { 1626, 23, 38, 26, 2, -37 },
  { 1736, 22, 37, 26, 2, -37 },
  { 1838, 22, 39, 26, 2, -38 },
  { 1946, 22, 38, 26, 2, -38 },
  { 2051, 9, 30, 15, 3, -29 },
  { 2085, 10, 39, 14, 2, -29 },
  { 2134, 19, 25, 23, 1, -28 },
  { 2194, 20, 17, 26, 3, -25 },
  { 2237, 19, 25, 24, 3, -28 },
  { 2297, 21, 39, 24, 1, -38 },
  { 2400, 36, 48, 40, 2, -36 },
  { 2616, 31, 37, 31, 0, -37 },
  { 2760, 24, 37, 29, 3, -37 },
  { 2871, 26, 39, 30, 2, -38 },
  { 2998, 24, 37, 29, 3, -37 },
  { 3109, 21, 37, 25, 3, -37 },
  { 3207, 21, 37, 25, 3, -37 },
  { 3305, 26, 39, 31, 2, -38 },
  { 3432, 26, 37, 32, 3, -37 },
  { 3553, 8, 37, 14, 3, -37 },
  { 3590, 22, 38, 26, 1, -37 },
  { 3695, 26, 37, 29, 3, -37 },
  { 3816, 21, 37, 25, 3, -37 },
  { 3914, 34, 37, 39, 3, -37 },
  { 4072, 26, 37, 32, 3, -37 },
  { 4193, 27, 39, 31, 2, -38 },
  { 4325, 25, 37, 30, 3, -37 },
  { 4441, 27, 45, 31, 2, -38 },
  { 4593, 25, 37, 29, 3, -37 },
  { 4709, 24, 39, 28, 2, -38 },
  { 4826, 26, 37, 29, 1, -37 },
  { 4947, 24, 38, 30, 3, -37 },
  { 5061, 30, 37, 30, 0, -37 },
  { 5200, 37, 37, 39, 1, -37 },
  { 5372, 28, 37, 29, 1, -37 },
  { 5502, 28, 37, 28, 0, -37 },
  { 5632, 24, 37, 28, 2, -37 },
  { 5743, 10, 52, 14, 3, -43 },
  { 5808, 21, 40, 20, 0, -37 },
  { 5913, 10, 52, 14, 1, -43 },
  { 5978, 19, 18, 21, 1, -37 },
  { 6021, 19, 6, 21, 1, 0 },
  { 6036, 14, 8, 17, 1, -39 },
  { 6050, 21, 29, 24, 2, -28 },
  { 6127, 22, 40, 26, 2, -39 },
  { 6237, 21, 29, 24, 2, -28 },
  { 6314, 21, 40, 26, 2, -39 },
  { 6419, 22, 29, 25, 2, -28 },
  { 6499, 16, 40, 17, 1, -40 },
  { 6579, 22, 39, 26, 2, -28 },
  { 6687, 21, 39, 26, 2, -39 },
  { 6790, 9, 38, 13, 2, -38 },
  { 6833, 13, 49, 13, -2, -38 },
  { 6913, 23, 39, 25, 2, -39 },
  { 7026, 8, 39, 13, 3, -39 },
  { 7065, 33, 28, 38, 3, -28 },
  { 7181, 21, 28, 26, 2, -28 },
  { 7255, 22, 29, 26, 2, -28 },
  { 7335, 22, 39, 26, 2, -28 },
  { 7443, 21, 39, 26, 2, -28 },
  { 7546, 15, 28, 18, 2, -28 },
  { 7599, 21, 29, 24, 1, -28 },
  { 7676, 14, 35, 16, 1, -34 },
  { 7738, 21, 28, 26, 2, -27 },
  { 7812, 22, 27, 24, 1, -27 },
  { 7887, 31, 27, 33, 1, -27 },
  { 7992, 22, 27, 24, 1, -27 },
  { 8067, 23, 38, 24, 0, -27 },
  { 8177, 20, 27, 24, 2, -27 },
  { 8245, 13, 50, 15, 1, -41 },
  { 8327, 5, 44, 13, 4, -37 },
  { 8355, 13, 50, 15, 1, -41 },
  { 8437, 24, 12, 29, 2, -21 },
};

const GFXfont RobotoCondensed_ExtraBold52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_EXTRABOLD52PT7B_H_
