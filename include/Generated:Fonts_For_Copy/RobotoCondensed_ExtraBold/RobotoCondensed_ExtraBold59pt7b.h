#ifndef _ROBOTOCONDENSED_EXTRABOLD59PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0xC0, 0x80, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE3, 0xF0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0x00, 0xFC, 0x7E, 0x03, 0x80, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0x3F, 0x1F,
  0x00, 0xF8, 0x3F, 0x3F, 0x00, 0xFC, 0x3F, 0x3E, 0x00, 0xFC, 0x7E, 0x7E,
  0x00, 0xFF, 0xFE, 0x7C, 0x00, 0x7F, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0xF8,
  0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x01, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x80, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0x1F, 0x3F,
  0xFE, 0x00, 0x3F, 0x7F, 0xFE, 0x00, 0x3E, 0x7F, 0xFF, 0x00, 0x7E, 0x7E,
  0x3F, 0x00, 0x7C, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xF8, 0xFC,
  0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC,
  0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xC0, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF,
  0xC7, 0xF1, 0xFF, 0xFF, 0xDF, 0xE3, 0xFC, 0xFF, 0xBF, 0xCF, 0xF9, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF,
  0xF8, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE,
  0x00, 0x08, 0x00, 0x30, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x30, 0x00, 0x20, 0x40, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0xF8,
  0x0C, 0x7C, 0x1E, 0x0F, 0x9F, 0xE7, 0x8F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0x3C, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x02,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE,
  0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7E, 0xFF, 0x80, 0x3F, 0xBF, 0xE0,
  0x0F, 0xEF, 0xF8, 0x07, 0xF3, 0xFE, 0x01, 0xFC, 0xFF, 0x80, 0xFE, 0x3F,
  0xE0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC3, 0xFE, 0x07, 0xF0, 0xFF, 0x83, 0xFC,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xC0, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xF8, 0x04, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0x7F, 0xDF, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x01, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFE, 0x1F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xCF, 0xF8, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x0F, 0x8F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x7F, 0x3F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC, 0x08, 0x00,
  0x0F, 0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x1F,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFB,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xFF, 0x81, 0xF0,
  0x7E, 0x03, 0xFF, 0xE0, 0xFC, 0x7E, 0x03, 0xFF, 0xF8, 0x3E, 0x3F, 0x01,
  0xFF, 0xFC, 0x1F, 0x1F, 0x01, 0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xFC, 0x3F,
  0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0x83, 0xF7, 0xE0, 0xFE, 0x0F, 0xC0, 0xFB,
  0xF0, 0x7E, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0xF8, 0x0F, 0xFE, 0x0F, 0xC0, 0xFC,
  0x07, 0xFF, 0x07, 0xE0, 0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x3F, 0x01, 0xFF,
  0xC1, 0xF8, 0x1F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xFB, 0xF0, 0x7E,
  0x07, 0xE0, 0x7D, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0x8F,
  0x83, 0xF8, 0xFF, 0x0F, 0xC7, 0xE0, 0xFF, 0xFF, 0xCF, 0xC3, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0xFB, 0xFF, 0xE0, 0xFC, 0x0F, 0xFC, 0xFF,
  0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0x80, 0x20, 0x06, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xFE, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xF8, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xF0, 0x3F,
  0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x8F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x81, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x03,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFF,
  0xFE, 0x0F, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xDF, 0xFF, 0xFB, 0xF8, 0x3F,
  0xBF, 0xFF, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xF1, 0xFC, 0xFF, 0xFF,
  0xCF, 0xE3, 0xF9, 0xFF, 0xFF, 0x9F, 0xC7, 0xE3, 0xFF, 0xFF, 0x3F, 0x9F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xBF, 0x8F, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF,
  0x9F, 0xC7, 0xFF, 0xFE, 0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xE1,
  0xFD, 0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF8, 0x1F, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F,
  0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x09, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF0, 0x3F, 0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F,
  0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF0, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFF, 0x07,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF7,
  0xFC, 0x07, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xC7,
  0xF8, 0x1F, 0xF3, 0xFF, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xFF, 0xCF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x3F,
  0xBF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF,
  0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F,
  0xDF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x87,
  0xF0, 0xFC, 0x3F, 0x07, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xE3, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFD, 0xFE, 0x1F,
  0xFD, 0xFF, 0x0F, 0xF1, 0xFF, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x82, 0x00, 0xFF,
  0x9F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F,
  0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0x7F,
  0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x07,
  0xF8, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x10, 0x7F, 0xE0, 0x3C, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF,
  0x3F, 0xC3, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC0,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF, 0x00,
  0x20, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x80, 0x3F, 0xF0,
  0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xFC, 0x7F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xEF, 0xF8, 0x3F,
  0xF3, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xE3, 0xFF, 0x0F, 0xF9,
  0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF7, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x04, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x0F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xDF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0x0F, 0xFB, 0xFE, 0x0F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0x01,
  0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xE7, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F,
  0xE0, 0xFF, 0x82, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xFC,
  0xFF, 0x00, 0x40, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x10, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0x0F, 0xF1,
  0xFF, 0x00, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xCF, 0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xBF, 0xC1, 0xFC, 0x1F, 0xE7, 0xF8,
  0x7F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x3F, 0x87, 0xFE, 0x3F, 0x87, 0xF9, 0xFF, 0xCF,
  0xF0, 0xFF, 0x3F, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0xE7, 0xF8, 0x3F, 0xBF, 0xFE, 0xFE, 0x07, 0xF7, 0xEF, 0xDF, 0xC0, 0xFE,
  0xFD, 0xFB, 0xF8, 0x1F, 0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xE0,
  0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xBF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE7, 0xFC, 0x1F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFE, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF,
  0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x01, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x7F, 0xF0, 0x3F, 0x9F, 0xFF, 0x07, 0xF7, 0xFF, 0xE0,
  0xFC, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0x9F, 0x81, 0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 43, 16, 3, -42 },
  { 55, 16, 16, 19, 1, -44 },
  { 87, 27, 42, 31, 2, -42 },
  { 229, 24, 56, 30, 3, -49 },
  { 397, 32, 44, 38, 3, -43 },
  { 573, 31, 44, 35, 2, -43 },
  { 744, 6, 16, 9, 2, -44 },
  { 756, 15, 59, 19, 3, -46 },
  { 867, 14, 59, 19, 2, -46 },
  { 971, 26, 26, 27, 1, -42 },
  { 1056, 24, 31, 28, 2, -35 },
  { 1149, 11, 18, 15, 1, -7 },
  { 1174, 15, 7, 23, 4, -21 },
  { 1188, 10, 10, 18, 4, -9 },
  { 1201, 18, 46, 19, 0, -42 },
  { 1305, 24, 44, 30, 3, -43 },
  { 1437, 16, 42, 30, 5, -42 },
  { 1521, 26, 43, 30, 2, -43 },
  { 1661, 25, 44, 30, 2, -43 },
  { 1799, 26, 42, 30, 2, -42 },
  { 1936, 25, 43, 30, 2, -42 },
  { 2071, 25, 43, 30, 3, -42 },
  { 2206, 26, 42, 30, 2, -42 },
  { 2343, 24, 44, 30, 3, -43 },
  { 2475, 25, 43, 30, 2, -43 },
  { 2610, 10, 33, 17, 4, -32 },
  { 2652, 11, 43, 16, 2, -32 },
  { 2712, 21, 28, 26, 2, -32 },
  { 2786, 22, 19, 30, 4, -28 },
  { 2839, 22, 28, 27, 3, -32 },
  { 2916, 24, 44, 27, 1, -43 },
  { 3048, 41, 54, 45, 2, -41 },
  { 3325, 35, 42, 36, 0, -42 },
  { 3509, 28, 42, 33, 3, -42 },
  { 3656, 30, 44, 34, 2, -43 },
  { 3821, 28, 42, 33, 3, -42 },
  { 3968, 25, 42, 29, 3, -42 },
  { 4100, 24, 42, 28, 3, -42 },
  { 4226, 29, 44, 35, 3, -43 },
  { 4386, 30, 42, 36, 3, -42 },
  { 4544, 9, 42, 16, 4, -42 },
  { 4592, 25, 43, 29, 1, -42 },
  { 4727, 30, 42, 33, 3, -42 },
  { 4885, 24, 42, 28, 3, -42 },
  { 5011, 39, 42, 45, 3, -42 },
  { 5216, 30, 42, 36, 3, -42 },
  { 5374, 31, 44, 36, 2, -43 },
  { 5545, 28, 42, 34, 3, -42 },
  { 5692, 31, 51, 36, 2, -43 },
  { 5890, 29, 42, 33, 3, -42 },
  { 6043, 28, 44, 32, 2, -43 },
  { 6197, 30, 42, 32, 1, -42 },
  { 6355, 28, 43, 34, 3, -42 },
  { 6506, 34, 42, 34, 0, -42 },
  { 6685, 42, 42, 44, 1, -42 },
  { 6906, 31, 42, 33, 1, -42 },
  { 7069, 32, 42, 32, 0, -42 },
  { 7237, 28, 42, 31, 2, -42 },
  { 7384, 12, 59, 16, 3, -49 },
  { 7473, 24, 46, 23, 0, -42 },
  { 7611, 12, 59, 16, 1, -49 },
  { 7700, 21, 21, 23, 1, -42 },
  { 7756, 22, 7, 23, 1, 0 },
  { 7776, 15, 9, 20, 2, -44 },
  { 7793, 24, 33, 28, 2, -32 },
  { 7892, 24, 45, 29, 3, -44 },
  { 8027, 24, 33, 27, 2, -32 },
  { 8126, 24, 45, 29, 2, -44 },
  { 8261, 25, 33, 28, 2, -32 },
  { 8365, 18, 45, 19, 1, -45 },
  { 8467, 25, 44, 30, 2, -32 },
  { 8605, 23, 44, 29, 3, -44 },
  { 8732, 9, 44, 15, 3, -44 },
  { 8782, 14, 56, 15, -2, -44 },
  { 8880, 26, 44, 29, 3, -44 },
  { 9023, 9, 44, 15, 3, -44 },
  { 9073, 38, 32, 44, 3, -32 },
  { 9225, 23, 32, 29, 3, -32 },
  { 9317, 25, 33, 29, 2, -32 },
  { 9421, 24, 44, 29, 3, -32 },
  { 9553, 24, 44, 29, 2, -32 },
  { 9685, 16, 32, 20, 3, -32 },
  { 9749, 24, 33, 27, 1, -32 },
  { 9848, 16, 40, 18, 1, -39 },
  { 9928, 24, 32, 29, 3, -31 },
  { 10024, 25, 31, 27, 1, -31 },
  { 10121, 35, 31, 37, 1, -31 },
  { 10257, 25, 31, 27, 1, -31 },
  { 10354, 26, 43, 27, 0, -31 },
  { 10494, 22, 31, 27, 2, -31 },
  { 10580, 14, 56, 17, 2, -46 },
  { 10678, 5, 50, 15, 5, -42 },
  { 10710, 14, 56, 17, 2, -46 },
  { 10808, 27, 13, 32, 3, -24 },
};

const GFXfont RobotoCondensed_ExtraBold59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_EXTRABOLD59PT7B_H_
