#ifndef _ROBOTOCONDENSED_EXTRABOLD45PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xEF, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x81, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC1, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xFF, 0xF9, 0xFE, 0xFF, 0x3F, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xFD, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x08, 0x0F, 0x9F, 0x07, 0x07, 0xC7, 0x87, 0x83,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xE0, 0x7C, 0x79, 0xE0,
  0x3E, 0x7C, 0xF0, 0x0F, 0xFE, 0xF0, 0x07, 0xFE, 0xF0, 0x01, 0xFE, 0x78,
  0x00, 0x7E, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7F, 0x80, 0x0F, 0x7F, 0xE0, 0x0F, 0x7F, 0xF0, 0x07,
  0xBE, 0x7C, 0x07, 0x9E, 0x3E, 0x07, 0xCF, 0x0F, 0x03, 0xC7, 0x87, 0x83,
  0xC3, 0xC7, 0xC1, 0xE1, 0xE3, 0xE1, 0xE0, 0xF9, 0xF0, 0x30, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7E, 0x0F, 0xFE, 0x3F, 0x0F, 0xFF, 0x9F, 0x8F, 0xFF, 0xEF, 0xC7,
  0xE7, 0xFF, 0xC3, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0xF8,
  0xFE, 0x0F, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xF8, 0x07, 0xF0,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x70,
  0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x00, 0x80, 0x40, 0x0E, 0x01, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x1F, 0x81, 0xE0, 0x38, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x81, 0xE0, 0x3E, 0x38,
  0x7F, 0xF7, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0x70, 0x3C, 0x02, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x7E, 0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F,
  0xC7, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xE3, 0xF9, 0xFE,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xDF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7D, 0xFC, 0x07, 0xDF, 0xC0, 0xF9, 0xFC, 0x0F, 0x9F, 0xC1, 0xF9,
  0xFC, 0x1F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3E, 0x1F, 0xC7, 0xE1, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x1F, 0xC0, 0x83, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFB, 0xFE, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x3E, 0x0F, 0xEF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xBF, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFE,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F,
  0xC7, 0xF3, 0xF0, 0xFE, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7F, 0x3F,
  0x8F, 0xE3, 0xFB, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7F, 0x3F, 0x07, 0xEF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFD, 0xFE,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0xFF, 0x7F, 0x1F, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0x9F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x1F, 0x1F, 0xCF, 0xEF, 0xF3, 0xF9, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE3,
  0xF1, 0xF0, 0xF0, 0x10, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x7F, 0xFC, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF,
  0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x07,
  0xE0, 0xF0, 0xF0, 0x3F, 0xE0, 0xF3, 0xE0, 0xFF, 0xE1, 0xE7, 0x81, 0xFF,
  0xC3, 0xCF, 0x07, 0xC7, 0x87, 0xBE, 0x1F, 0x0F, 0x07, 0xFC, 0x3E, 0x1E,
  0x0F, 0xF0, 0x78, 0x3C, 0x1F, 0xE1, 0xF0, 0x78, 0x3F, 0xC3, 0xE1, 0xF0,
  0x7F, 0x87, 0xC3, 0xE0, 0xFF, 0x0F, 0x87, 0xC1, 0xFE, 0x1F, 0x0F, 0x83,
  0xBC, 0x3E, 0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7C, 0x3D,
  0xE1, 0xF1, 0xF8, 0xF3, 0xC3, 0xF3, 0xF1, 0xE7, 0x87, 0xFF, 0xFF, 0x8F,
  0x87, 0xFF, 0xFF, 0x1F, 0x07, 0xF3, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xBF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC,
  0x0F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x3F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7,
  0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F,
  0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xEF,
  0x87, 0xDF, 0xFF, 0xBE, 0x1F, 0x7F, 0xFE, 0xFC, 0xFD, 0xFF, 0xFB, 0xF3,
  0xF7, 0xFF, 0xE7, 0xCF, 0x9F, 0xFF, 0x9F, 0x3E, 0x7F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0x8F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xF1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF,
  0x87, 0xF8, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0,
  0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x1F, 0xFF, 0xBF,
  0x3F, 0xFF, 0x3E, 0x7F, 0xFE, 0x7E, 0xFF, 0xFC, 0x7D, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80,
  0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x7F,
  0x01, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80,
  0xFE, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x7F,
  0x01, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF,
  0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFE, 0xFE, 0x07, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB,
  0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFF, 0x03,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7E,
  0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0x7E, 0x0F, 0xF0, 0xFE,
  0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0, 0xFC,
  0x7F, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF9, 0xFC,
  0x3F, 0x1F, 0xF9, 0xFC, 0x3F, 0x9F, 0xF9, 0xFC, 0x3F, 0xBF, 0xF9, 0xF8,
  0x3F, 0xBF, 0xF9, 0xF8, 0x1F, 0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFF, 0xF8,
  0x1F, 0xBE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0,
  0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE,
  0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xFC, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x87, 0xFB, 0xF8, 0x7E, 0x7F, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xF0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFD, 0xFE, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xFB, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xEF, 0xFC,
  0xFD, 0xFF, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xDF, 0xEF, 0xF7, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC3, 0xF7, 0xFB, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0x3F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFD, 0xF8, 0x3F, 0xBF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xE0, 0xF8, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xEF, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xCF, 0xFD, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xE7,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFD,
  0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7,
  0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xDF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0x3E, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x08, 0x0F, 0xE0, 0xE1, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE7, 0xC3, 0xFB, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF,
  0xCF, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xE7,
  0xF8, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7E, 0x0F,
  0x87, 0xF7, 0xF9, 0xFF, 0x3F, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0,
  0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF,
  0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC,
  0x3F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x7F,
  0xFC, 0x7C, 0x3F, 0x3F, 0xCF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0xFE, 0x7F, 0xDF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFC, 0x7C, 0x1F, 0xBF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0x7F, 0xBF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFB, 0xFE, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xF3, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFE, 0x7F, 0xBF, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3E, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE1, 0xFD,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x87,
  0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFE, 0xFC, 0x3E, 0x3F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF9,
  0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F,
  0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x1F, 0x0F, 0xDF, 0x87, 0xE1, 0xFB,
  0xF0, 0xFC, 0x3F, 0x7F, 0x1F, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC, 0x7F,
  0x3F, 0x1F, 0x9F, 0xE7, 0xE3, 0xF3, 0xFC, 0xFC, 0x7E, 0x7F, 0x9F, 0x87,
  0xCF, 0xFB, 0xF0, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xEF, 0x83, 0xFF, 0xBF,
  0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F,
  0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xEF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xC3,
  0xFB, 0xF8, 0x7F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F,
  0x9F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0x7F, 0xFF,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8,
  0x1F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0xFC, 0x7F, 0x8F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x38, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x0F, 0x01, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x87, 0xF0, 0x7C, 0x0F, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE3, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xE1, 0xFF, 0x9F, 0x07, 0xFC, 0xF8, 0x1F, 0xC0, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -32 },
  { 33, 12, 12, 14, 1, -34 },
  { 51, 21, 32, 23, 1, -32 },
  { 135, 19, 41, 23, 2, -37 },
  { 233, 25, 32, 29, 2, -32 },
  { 333, 25, 32, 26, 1, -32 },
  { 433, 5, 12, 7, 1, -34 },
  { 441, 10, 45, 15, 3, -35 },
  { 498, 11, 45, 15, 1, -35 },
  { 560, 19, 20, 21, 1, -32 },
  { 608, 19, 23, 21, 1, -26 },
  { 663, 8, 14, 12, 1, -6 },
  { 677, 11, 5, 18, 3, -16 },
  { 684, 7, 7, 13, 3, -7 },
  { 691, 14, 35, 14, 0, -32 },
  { 753, 19, 32, 23, 2, -32 },
  { 829, 13, 32, 23, 3, -32 },
  { 881, 20, 32, 23, 1, -32 },
  { 961, 20, 32, 23, 1, -32 },
  { 1041, 20, 32, 23, 1, -32 },
  { 1121, 19, 32, 23, 2, -32 },
  { 1197, 19, 32, 23, 2, -32 },
  { 1273, 20, 32, 23, 1, -32 },
  { 1353, 19, 32, 23, 2, -32 },
  { 1429, 19, 32, 23, 2, -32 },
  { 1505, 7, 25, 13, 3, -25 },
  { 1527, 9, 33, 12, 1, -25 },
  { 1565, 16, 21, 20, 1, -24 },
  { 1607, 17, 14, 23, 3, -21 },
  { 1637, 16, 21, 20, 3, -24 },
  { 1679, 18, 32, 20, 1, -32 },
  { 1751, 31, 41, 34, 2, -31 },
  { 1910, 27, 32, 27, 0, -32 },
  { 2018, 21, 32, 25, 2, -32 },
  { 2102, 22, 32, 26, 2, -32 },
  { 2190, 21, 32, 25, 2, -32 },
  { 2274, 19, 32, 22, 2, -32 },
  { 2350, 18, 32, 21, 2, -32 },
  { 2422, 23, 32, 26, 2, -32 },
  { 2514, 23, 32, 28, 2, -32 },
  { 2606, 7, 32, 12, 3, -32 },
  { 2634, 19, 32, 22, 1, -32 },
  { 2710, 23, 32, 25, 2, -32 },
  { 2802, 18, 32, 22, 2, -32 },
  { 2874, 30, 32, 34, 2, -32 },
  { 2994, 23, 32, 27, 2, -32 },
  { 3086, 23, 32, 27, 2, -32 },
  { 3178, 22, 32, 26, 2, -32 },
  { 3266, 23, 38, 27, 2, -32 },
  { 3376, 22, 32, 25, 2, -32 },
  { 3464, 21, 32, 25, 2, -32 },
  { 3548, 23, 32, 25, 1, -32 },
  { 3640, 22, 32, 26, 2, -32 },
  { 3728, 26, 32, 26, 0, -32 },
  { 3832, 32, 32, 34, 1, -32 },
  { 3960, 24, 32, 25, 1, -32 },
  { 4056, 24, 32, 25, 0, -32 },
  { 4152, 22, 32, 24, 1, -32 },
  { 4240, 9, 45, 12, 2, -37 },
  { 4291, 18, 35, 17, 0, -32 },
  { 4370, 9, 45, 12, 1, -37 },
  { 4421, 16, 16, 18, 1, -32 },
  { 4453, 17, 5, 18, 0, 0 },
  { 4464, 12, 7, 15, 1, -34 },
  { 4475, 19, 24, 21, 1, -24 },
  { 4532, 19, 34, 22, 2, -34 },
  { 4613, 18, 24, 21, 1, -24 },
  { 4667, 19, 34, 22, 1, -34 },
  { 4748, 18, 24, 22, 2, -24 },
  { 4802, 13, 34, 15, 1, -34 },
  { 4858, 20, 33, 23, 1, -24 },
  { 4941, 18, 34, 22, 2, -34 },
  { 5018, 7, 34, 12, 2, -34 },
  { 5048, 10, 43, 11, -1, -34 },
  { 5102, 20, 34, 22, 2, -34 },
  { 5187, 7, 34, 12, 2, -34 },
  { 5217, 29, 24, 33, 2, -24 },
  { 5304, 18, 24, 22, 2, -24 },
  { 5358, 20, 24, 22, 1, -24 },
  { 5418, 19, 33, 22, 2, -24 },
  { 5497, 19, 33, 22, 1, -24 },
  { 5576, 12, 24, 15, 2, -24 },
  { 5612, 18, 24, 20, 1, -24 },
  { 5666, 12, 30, 14, 1, -30 },
  { 5711, 18, 24, 22, 2, -24 },
  { 5765, 20, 24, 20, 0, -24 },
  { 5825, 27, 24, 28, 1, -24 },
  { 5906, 19, 24, 20, 1, -24 },
  { 5963, 20, 33, 20, 0, -24 },
  { 6046, 17, 24, 20, 2, -24 },
  { 6097, 11, 43, 13, 1, -35 },
  { 6157, 4, 38, 11, 4, -32 },
  { 6176, 11, 43, 13, 1, -35 },
  { 6236, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_ExtraBold45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_EXTRABOLD45PT7B_H_
