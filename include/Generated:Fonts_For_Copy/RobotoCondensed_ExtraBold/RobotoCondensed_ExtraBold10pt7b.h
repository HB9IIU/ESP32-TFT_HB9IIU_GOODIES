#ifndef _ROBOTOCONDENSED_EXTRABOLD10PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF6, 0xB6, 0x80, 0x31, 0x9E, 0xAF, 0xA9, 0x80, 0x23, 0x96, 0x87,
  0x0F, 0x6E, 0x20, 0x62, 0xA7, 0x04, 0x2C, 0xD0, 0xC0, 0x71, 0x45, 0x1A,
  0xFB, 0x67, 0x80, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x36, 0xDA, 0x50, 0x27,
  0x98, 0xA0, 0x22, 0xF2, 0x20, 0x58, 0xC0, 0xC0, 0x25, 0x24, 0xA4, 0x72,
  0xB7, 0xBD, 0xA9, 0xC0, 0x7D, 0xB6, 0xD8, 0x76, 0x84, 0x62, 0x33, 0xE0,
  0x76, 0xC4, 0x61, 0xED, 0xC0, 0x31, 0x94, 0xAF, 0x88, 0x40, 0x72, 0x1C,
  0x31, 0xE9, 0xC0, 0x33, 0x1D, 0xBD, 0xAD, 0xC0, 0xF8, 0x84, 0x62, 0x31,
  0x80, 0x72, 0x94, 0xE5, 0xED, 0xC0, 0x72, 0xB6, 0xB7, 0x19, 0x80, 0xCC,
  0x50, 0x17, 0x1E, 0xE1, 0xE3, 0x80, 0x9F, 0xC0, 0x7D, 0x12, 0x22, 0x60,
  0x3C, 0x85, 0x6D, 0x5A, 0xB5, 0x5F, 0xA0, 0x38, 0x30, 0xC3, 0x9E, 0x49,
  0xEC, 0xC0, 0xFB, 0xBE, 0x99, 0xF0, 0x72, 0x73, 0x8C, 0x25, 0xE0, 0xEB,
  0x99, 0x9B, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x7A,
  0x71, 0xBC, 0xA5, 0xE0, 0x9C, 0xE7, 0xF9, 0xCE, 0x60, 0xFE, 0x11, 0x11,
  0x1D, 0x70, 0xB5, 0xB9, 0xCE, 0x5A, 0x40, 0x88, 0x88, 0x88, 0xF0, 0xCF,
  0x3D, 0xF5, 0xB6, 0xDA, 0x40, 0x9E, 0xF7, 0xFB, 0xDE, 0x60, 0x79, 0x2C,
  0xF3, 0xCD, 0x27, 0x80, 0xEB, 0x99, 0xF8, 0x80, 0x79, 0x2C, 0xF3, 0xCD,
  0x27, 0x82, 0xFB, 0xBE, 0xAB, 0x90, 0x72, 0xD0, 0xE1, 0xED, 0xC0, 0xF9,
  0x8C, 0x63, 0x18, 0xC0, 0xCE, 0x73, 0x9C, 0xA5, 0xE0, 0xCD, 0x25, 0x9E,
  0x70, 0xC3, 0x00, 0xD3, 0xB5, 0x7B, 0xF6, 0xCD, 0x9B, 0x00, 0xCB, 0xDC,
  0x67, 0x2F, 0x20, 0xCA, 0xDC, 0x63, 0x18, 0xC0, 0xF8, 0xCC, 0x46, 0x23,
  0xE0, 0xFF, 0xC0, 0xCC, 0x46, 0x62, 0x33, 0xD5, 0x55, 0x70, 0x66, 0x6B,
  0xF0, 0x4C, 0x7D, 0x7D, 0x70, 0xC6, 0x31, 0xED, 0xEF, 0x7E, 0x7D, 0xCD,
  0x70, 0x11, 0x17, 0xDD, 0xD7, 0x76, 0xBF, 0x87, 0x00, 0x69, 0x74, 0x92,
  0x7E, 0xF7, 0xB7, 0x8D, 0xC0, 0xCC, 0xCF, 0xDD, 0xDD, 0x11, 0x55, 0x31,
  0x55, 0xF0, 0xC6, 0x31, 0xAF, 0x7B, 0xDB, 0xFF, 0xFF, 0xAF, 0x5E, 0xBD,
  0x60, 0xFD, 0xDD, 0xD0, 0x76, 0xF7, 0xB7, 0x00, 0xF6, 0xF7, 0xBF, 0x63,
  0x00, 0x7D, 0xDD, 0x71, 0x10, 0xFB, 0x6C, 0x7D, 0x7D, 0x70, 0x4B, 0xA4,
  0x98, 0xDE, 0xF7, 0xB7, 0x80, 0xD5, 0x76, 0x60, 0xD7, 0xF7, 0xDE, 0x68,
  0xD7, 0x67, 0xD0, 0xD5, 0x76, 0x66, 0x40, 0xF3, 0x64, 0xF0, 0x29, 0x25,
  0x92, 0x4C, 0xFF, 0x89, 0x24, 0xD2, 0x50, 0x6F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 3, 3, 0, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 0, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 5, 4, 5, 0, -7 },
  { 38, 4, 5, 5, 0, -6 },
  { 41, 2, 3, 3, 0, -1 },
  { 42, 2, 1, 4, 1, -3 },
  { 43, 1, 2, 3, 1, -2 },
  { 44, 3, 8, 3, 0, -7 },
  { 47, 5, 7, 5, 0, -7 },
  { 52, 3, 7, 5, 1, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 1, 6, 3, 1, -6 },
  { 96, 2, 8, 3, 0, -6 },
  { 98, 4, 4, 4, 0, -5 },
  { 100, 3, 3, 5, 1, -5 },
  { 102, 3, 4, 5, 1, -5 },
  { 104, 4, 7, 5, 0, -7 },
  { 108, 7, 9, 8, 0, -7 },
  { 116, 6, 7, 6, 0, -7 },
  { 122, 4, 7, 6, 1, -7 },
  { 126, 5, 7, 6, 0, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 5, 1, -7 },
  { 139, 4, 7, 5, 1, -7 },
  { 143, 5, 7, 6, 0, -7 },
  { 148, 5, 7, 6, 1, -7 },
  { 153, 1, 7, 3, 1, -7 },
  { 154, 4, 7, 5, 0, -7 },
  { 158, 5, 7, 6, 1, -7 },
  { 163, 4, 7, 5, 1, -7 },
  { 167, 6, 7, 8, 1, -7 },
  { 173, 5, 7, 6, 1, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 4, 7, 6, 1, -7 },
  { 188, 6, 8, 6, 0, -7 },
  { 194, 4, 7, 6, 1, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 5, 7, 5, 0, -7 },
  { 208, 5, 7, 6, 0, -7 },
  { 213, 6, 7, 6, 0, -7 },
  { 219, 7, 7, 7, 0, -7 },
  { 226, 5, 7, 6, 0, -7 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 5, 7, 5, 0, -7 },
  { 241, 1, 10, 3, 1, -8 },
  { 243, 4, 8, 4, 0, -7 },
  { 247, 2, 10, 3, 0, -8 },
  { 250, 4, 4, 4, 0, -7 },
  { 252, 4, 1, 4, 0, 0 },
  { 253, 3, 2, 3, 0, -8 },
  { 254, 4, 5, 5, 0, -5 },
  { 257, 5, 8, 5, 0, -8 },
  { 262, 4, 5, 5, 0, -5 },
  { 265, 4, 8, 5, 0, -8 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 3, 8, 3, 0, -8 },
  { 276, 5, 7, 5, 0, -5 },
  { 281, 4, 8, 5, 0, -8 },
  { 285, 2, 8, 3, 0, -8 },
  { 287, 2, 10, 3, 0, -8 },
  { 290, 5, 8, 5, 0, -8 },
  { 295, 1, 8, 3, 1, -8 },
  { 296, 7, 5, 7, 0, -5 },
  { 301, 4, 5, 5, 0, -5 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 5, 7, 5, 0, -5 },
  { 313, 4, 7, 5, 0, -5 },
  { 317, 3, 5, 3, 0, -5 },
  { 319, 4, 5, 5, 0, -5 },
  { 322, 3, 7, 3, 0, -7 },
  { 325, 5, 5, 5, 0, -5 },
  { 329, 4, 5, 5, 0, -5 },
  { 332, 6, 5, 6, 0, -5 },
  { 336, 4, 5, 5, 0, -5 },
  { 339, 4, 7, 5, 0, -5 },
  { 343, 4, 5, 5, 0, -5 },
  { 346, 3, 10, 3, 0, -8 },
  { 350, 1, 8, 3, 1, -7 },
  { 351, 3, 10, 3, 0, -8 },
  { 355, 5, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_EXTRABOLD10PT7B_H_
