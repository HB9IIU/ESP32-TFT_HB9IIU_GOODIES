#ifndef _ROBOTOCONDENSED_EXTRABOLD36PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xE0, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xCF, 0x00,
  0xE7, 0x80, 0x73, 0x80, 0x39, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x07, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7E, 0xFD, 0xF8,
  0xFB, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xDF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFD, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0x01, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x7B, 0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE7,
  0x87, 0x1C, 0xE0, 0xF7, 0xBC, 0x1F, 0xF7, 0x01, 0xFD, 0xE0, 0x1F, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x73, 0xE0, 0x0E, 0xFE, 0x03, 0xBF,
  0xE0, 0x77, 0xBC, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0xE3, 0x8E, 0x3C, 0x71,
  0xC7, 0x0F, 0x38, 0x21, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0x7C, 0x78,
  0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC7, 0x8F, 0xF9, 0xF3, 0xFF, 0xBE,
  0xFD, 0xFF, 0xDF, 0xBF, 0xFB, 0xF3, 0xFE, 0x7E, 0x3F, 0xCF, 0xC3, 0xF0,
  0xFC, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xF8, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x01, 0x01, 0x81, 0xE1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x20, 0x40, 0x70,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x38, 0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61,
  0xC0, 0x79, 0xCF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xF8, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x3E, 0x3C, 0x1C, 0x1C, 0x00, 0x10, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0xF3, 0xCF, 0x3D, 0xF7, 0xDE, 0xFB, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0xC7,
  0xCF, 0x9F, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0xC0,
  0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7E, 0xFE, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFE, 0xFC, 0x3E, 0xFC,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7D, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3C, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3E, 0x7F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x00,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF3, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF,
  0x9F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0xC7, 0xEF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xEF, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0xFC, 0x7D, 0xF8, 0xF9, 0xFB,
  0xE1, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xFE, 0x7E, 0x7E, 0xF8, 0x7D,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0xDF, 0xBF, 0xFF, 0x3F,
  0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0x9F, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x9F, 0xDF, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1E, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x83, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0xDE, 0x18, 0xFD, 0xFB,
  0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x3E, 0x79, 0xE0, 0xC0, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0x1F, 0xE0, 0xF8, 0x07,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xF8,
  0x1F, 0xC7, 0xFE, 0xFF, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF,
  0x87, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0x0E,
  0x3C, 0x3F, 0xC7, 0x1C, 0x3F, 0xF3, 0xDE, 0x1E, 0x70, 0xEF, 0x1E, 0x38,
  0x77, 0x0E, 0x1C, 0x3B, 0x8F, 0x0E, 0x1F, 0xC7, 0x87, 0x0F, 0xE3, 0xC3,
  0x87, 0xF1, 0xE3, 0xC3, 0xF8, 0xF1, 0xE1, 0xFC, 0x78, 0xF0, 0xFE, 0x3C,
  0x78, 0xFF, 0x1E, 0x3C, 0x73, 0x8F, 0xBE, 0x79, 0xC3, 0xFF, 0xF8, 0xF1,
  0xFB, 0xF8, 0x78, 0x78, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD,
  0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x03, 0xE7,
  0xE0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x07, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC,
  0x3F, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xFE, 0x07, 0xEF, 0x83, 0xFB, 0xE0,
  0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF8,
  0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7E, 0xF8, 0x1F,
  0xBE, 0x07, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xDE, 0x3F, 0xFF,
  0xBC, 0x7B, 0xFF, 0x78, 0xF7, 0xFE, 0xFB, 0xEF, 0xFC, 0xF7, 0x9F, 0xF9,
  0xEF, 0x3F, 0xF3, 0xFE, 0x7F, 0xE3, 0xFC, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F,
  0xE3, 0xFF, 0x1F, 0xC7, 0xFE, 0x1F, 0x8F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF0, 0x78, 0x7C, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF,
  0x9F, 0x7F, 0xE3, 0xDF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xDF, 0x87, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD,
  0xF0, 0x7E, 0xF8, 0x1F, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xE1, 0xFB, 0xFD, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07,
  0xE3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x3E, 0x0F, 0xFC, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x8F, 0xC3, 0xFF,
  0xC7, 0xF1, 0xF3, 0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0xFE, 0x3E,
  0x7C, 0x7F, 0x3F, 0x3F, 0x7F, 0x9F, 0x9F, 0xBF, 0xEF, 0x87, 0xDF, 0xF7,
  0xC3, 0xEF, 0xFB, 0xE1, 0xF7, 0xBD, 0xF0, 0xFF, 0xDE, 0xF8, 0x7F, 0xEF,
  0xFC, 0x1F, 0xF7, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8,
  0x0F, 0x9F, 0x80, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x01, 0xF9, 0xF8, 0x1F,
  0x9F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7,
  0xE0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x1F, 0x07, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01,
  0xF7, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0x3C, 0x79, 0xE3,
  0xCF, 0x1E, 0x3D, 0xE1, 0xEF, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xCF, 0xDF, 0x8F, 0x80, 0x1F, 0x07, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF9, 0xF9, 0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7D, 0xF8, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB,
  0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x0F, 0xBE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xBF, 0xBF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xEF, 0x80, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xDF, 0x8F, 0xBF, 0x1F,
  0x7E, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC3, 0xFF,
  0x8F, 0x9F, 0xBF, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB, 0xFF, 0xF7, 0xEF, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C,
  0x3C, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xEF,
  0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x0F, 0x81, 0x1F, 0xCF, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8,
  0x1F, 0xC0, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F, 0x83, 0xE0, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x0F, 0x9E, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xE7, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xDF, 0x9F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x3E, 0xF8,
  0x01, 0xF1, 0x03, 0xE3, 0x8F, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF9, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xC0, 0x23, 0xEF, 0xBF, 0xF9, 0xC0, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x04, 0x1F,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xFE, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFD, 0xF0, 0xF9, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E,
  0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xE1, 0xF1, 0xFF, 0xF7,
  0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xDF, 0xEF, 0xFF, 0x1F, 0x8F,
  0xFE, 0x1F, 0x1F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE,
  0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1,
  0xF0, 0xF8, 0xF9, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x3E,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFB, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF,
  0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xBF, 0xBF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3,
  0xEF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0x3E, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xEF,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFC, 0x3C, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0xF9, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0x8F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x87, 0xDF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xC7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xD1, 0xFE, 0x3F, 0x83, 0xF0, 0x3E, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF3, 0xE7, 0xC0, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0xF0, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF3, 0xEF, 0x9F, 0x9F,
  0x3C, 0xFC, 0xF9, 0xF7, 0xF7, 0xCF, 0xBF, 0xBE, 0x7F, 0xFD, 0xE3, 0xFE,
  0xEF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xF9, 0xFE, 0x1F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC1,
  0xE0, 0x7E, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E,
  0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E,
  0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x83, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x78, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x3F, 0x0F, 0x87, 0xC7, 0xE7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0x70, 0x20, 0x00, 0x1E,
  0x00, 0x7F, 0x0F, 0x7F, 0x8F, 0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0xF0,
  0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 9, 2, -26 },
  { 21, 10, 10, 12, 1, -27 },
  { 34, 17, 26, 19, 1, -26 },
  { 90, 15, 33, 18, 2, -30 },
  { 152, 19, 26, 23, 2, -26 },
  { 214, 19, 26, 21, 1, -26 },
  { 276, 4, 10, 6, 1, -27 },
  { 281, 9, 36, 12, 2, -28 },
  { 322, 9, 36, 12, 1, -28 },
  { 363, 16, 16, 17, 0, -26 },
  { 395, 15, 19, 17, 1, -22 },
  { 431, 6, 11, 9, 1, -4 },
  { 440, 9, 4, 14, 2, -13 },
  { 445, 6, 6, 11, 2, -6 },
  { 450, 11, 28, 12, 0, -26 },
  { 489, 15, 26, 18, 2, -26 },
  { 538, 10, 26, 18, 3, -26 },
  { 571, 16, 26, 18, 1, -26 },
  { 623, 16, 26, 18, 1, -26 },
  { 675, 16, 26, 18, 1, -26 },
  { 727, 16, 26, 18, 1, -26 },
  { 779, 15, 26, 18, 2, -26 },
  { 828, 16, 26, 18, 1, -26 },
  { 880, 15, 26, 18, 2, -26 },
  { 929, 15, 26, 18, 2, -26 },
  { 978, 6, 20, 10, 2, -20 },
  { 993, 7, 27, 10, 1, -20 },
  { 1017, 13, 17, 16, 1, -19 },
  { 1045, 14, 11, 18, 2, -17 },
  { 1065, 13, 17, 16, 2, -19 },
  { 1093, 14, 26, 16, 1, -26 },
  { 1139, 25, 33, 28, 1, -25 },
  { 1243, 21, 26, 22, 0, -26 },
  { 1312, 17, 26, 20, 2, -26 },
  { 1368, 19, 26, 21, 1, -26 },
  { 1430, 17, 26, 20, 2, -26 },
  { 1486, 15, 26, 18, 2, -26 },
  { 1535, 14, 26, 17, 2, -26 },
  { 1581, 18, 26, 21, 2, -26 },
  { 1640, 18, 26, 22, 2, -26 },
  { 1699, 6, 26, 10, 2, -26 },
  { 1719, 15, 26, 18, 1, -26 },
  { 1768, 18, 26, 20, 2, -26 },
  { 1827, 14, 26, 17, 2, -26 },
  { 1873, 23, 26, 27, 2, -26 },
  { 1948, 18, 26, 22, 2, -26 },
  { 2007, 19, 26, 22, 1, -26 },
  { 2069, 17, 26, 21, 2, -26 },
  { 2125, 19, 31, 22, 1, -26 },
  { 2199, 17, 26, 20, 2, -26 },
  { 2255, 17, 26, 20, 1, -26 },
  { 2311, 18, 26, 20, 1, -26 },
  { 2370, 17, 26, 21, 2, -26 },
  { 2426, 21, 26, 21, 0, -26 },
  { 2495, 25, 26, 27, 1, -26 },
  { 2577, 20, 26, 20, 0, -26 },
  { 2642, 19, 26, 20, 0, -26 },
  { 2704, 17, 26, 19, 1, -26 },
  { 2760, 7, 36, 10, 2, -30 },
  { 2792, 15, 28, 14, 0, -26 },
  { 2845, 7, 36, 10, 1, -30 },
  { 2877, 13, 13, 14, 1, -26 },
  { 2899, 14, 4, 14, 0, 0 },
  { 2906, 9, 5, 12, 1, -27 },
  { 2912, 15, 19, 17, 1, -19 },
  { 2948, 15, 27, 18, 2, -27 },
  { 2999, 15, 19, 17, 1, -19 },
  { 3035, 15, 27, 18, 1, -27 },
  { 3086, 15, 19, 17, 1, -19 },
  { 3122, 10, 27, 12, 1, -27 },
  { 3156, 15, 26, 18, 1, -19 },
  { 3205, 14, 27, 18, 2, -27 },
  { 3253, 6, 27, 9, 2, -27 },
  { 3274, 8, 34, 9, -1, -27 },
  { 3308, 16, 27, 17, 2, -27 },
  { 3362, 5, 27, 9, 2, -27 },
  { 3379, 23, 19, 27, 2, -19 },
  { 3434, 14, 19, 18, 2, -19 },
  { 3468, 16, 19, 18, 1, -19 },
  { 3506, 15, 26, 18, 2, -19 },
  { 3555, 15, 26, 18, 1, -19 },
  { 3604, 10, 19, 12, 2, -19 },
  { 3628, 14, 19, 16, 1, -19 },
  { 3662, 11, 24, 11, 0, -24 },
  { 3695, 14, 19, 18, 2, -19 },
  { 3729, 16, 19, 16, 0, -19 },
  { 3767, 21, 19, 23, 1, -19 },
  { 3817, 16, 19, 16, 0, -19 },
  { 3855, 16, 26, 16, 0, -19 },
  { 3907, 14, 19, 16, 1, -19 },
  { 3941, 9, 34, 11, 1, -28 },
  { 3980, 3, 31, 9, 3, -26 },
  { 3992, 9, 34, 11, 1, -28 },
  { 4031, 16, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_ExtraBold36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_EXTRABOLD36PT7B_H_
