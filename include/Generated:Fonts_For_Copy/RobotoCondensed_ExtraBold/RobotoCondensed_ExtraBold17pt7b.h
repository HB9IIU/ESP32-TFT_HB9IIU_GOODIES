#ifndef _ROBOTOCONDENSED_EXTRABOLD17PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x1B, 0xE0, 0xDE, 0xF7, 0xBD, 0x80, 0x1A, 0x1A,
  0x16, 0x16, 0x7F, 0x34, 0x34, 0xFF, 0x34, 0x2C, 0x2C, 0x2C, 0x10, 0x20,
  0xE3, 0xEE, 0xFD, 0xF8, 0x3C, 0x3C, 0x1F, 0x3F, 0x7F, 0xCF, 0x04, 0x08,
  0x70, 0x79, 0x24, 0x92, 0xCF, 0x43, 0xE0, 0x7C, 0x2F, 0x34, 0x92, 0x49,
  0xE0, 0xE0, 0x38, 0x3E, 0x3B, 0x1D, 0x87, 0xC3, 0xC3, 0xED, 0xB6, 0xDF,
  0x67, 0x3F, 0xCF, 0xE0, 0xFF, 0xC0, 0x13, 0x66, 0xCC, 0xCC, 0xCC, 0xCC,
  0x46, 0x63, 0x10, 0x43, 0x18, 0x63, 0x18, 0xE7, 0x39, 0xCE, 0x63, 0x19,
  0x8C, 0x40, 0x18, 0x18, 0xFE, 0x7E, 0x38, 0x2C, 0x24, 0x18, 0x30, 0x67,
  0xFF, 0xE3, 0x06, 0x0C, 0x6D, 0xB4, 0xFF, 0x5F, 0x80, 0x18, 0xC6, 0x63,
  0x18, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x78, 0xFB, 0xBE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0xDD, 0xF1, 0xC0, 0x0B, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x30, 0x79, 0xFB, 0x3E, 0x70, 0xE1, 0x87, 0x1C, 0x71, 0xC3, 0xFF, 0xF0,
  0x3C, 0x7E, 0x67, 0x07, 0x07, 0x1E, 0x1E, 0x07, 0x67, 0x67, 0x7E, 0x3C,
  0x1C, 0x38, 0xF1, 0xE6, 0xCD, 0xB3, 0x7F, 0xFE, 0x18, 0x30, 0x60, 0xFF,
  0xFF, 0x86, 0x0F, 0x9F, 0x83, 0x87, 0xCF, 0xDF, 0xF1, 0xC0, 0x18, 0xF1,
  0xC7, 0x0D, 0xDF, 0xFB, 0xE3, 0xC7, 0xDD, 0xF1, 0xC0, 0xFF, 0xFC, 0x38,
  0x61, 0xC3, 0x06, 0x1C, 0x30, 0xE1, 0xC3, 0x00, 0x79, 0xFB, 0xBF, 0x7E,
  0xCF, 0x9F, 0x77, 0xCF, 0xDF, 0xF3, 0xC0, 0x39, 0xFB, 0xB6, 0x7C, 0xFD,
  0xFF, 0xBF, 0x0C, 0x39, 0xE3, 0x80, 0x5F, 0x80, 0x02, 0xFC, 0x5F, 0x80,
  0x00, 0xFF, 0x68, 0x02, 0x1D, 0xF7, 0x8F, 0x0F, 0x83, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x83, 0x8F, 0x87, 0x3F, 0xEE, 0x20, 0x3C, 0xFF, 0xB8,
  0x30, 0xE3, 0x86, 0x0C, 0x00, 0x20, 0xE0, 0xC0, 0x0F, 0x07, 0x39, 0x81,
  0x20, 0x3C, 0xF3, 0x9E, 0x66, 0xCC, 0xD9, 0x9B, 0x33, 0x6E, 0x7D, 0xEE,
  0xEC, 0x00, 0xC0, 0x1F, 0xC0, 0xF8, 0x0C, 0x07, 0x81, 0xE0, 0x78, 0x3F,
  0x0E, 0xC3, 0x30, 0xCE, 0x7F, 0x9F, 0xE6, 0x1F, 0x87, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0x3C, 0x7E, 0xE7,
  0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xE7, 0x7E, 0x3C, 0xF8, 0xFE, 0xEE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0xF8, 0xFF, 0xFF, 0x87,
  0x0E, 0x1F, 0xBF, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E,
  0x1F, 0xBF, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x3C, 0x7F, 0xE7, 0xE3, 0xC0,
  0xCF, 0xCF, 0xC3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xE6, 0xCD, 0xF9,
  0xE0, 0xE7, 0x73, 0xBB, 0x9F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF8, 0xEE, 0x77,
  0x39, 0xDC, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xFF, 0xF0, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x37, 0xB6, 0xF6, 0xFE,
  0xDF, 0xDE, 0xF9, 0xDF, 0x3B, 0xE6, 0x70, 0xE3, 0xE3, 0xF3, 0xF3, 0xFB,
  0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x3F, 0x39, 0xDC, 0x6C,
  0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x73, 0x9F, 0xC7, 0x80, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x3F, 0xB9,
  0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x73, 0x9F, 0xC7, 0xC0, 0x78,
  0x10, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xEE, 0xEE, 0xE7,
  0xE7, 0x3C, 0xFE, 0xE6, 0xC7, 0xE0, 0x7C, 0x3E, 0x0E, 0xC7, 0xE7, 0xFE,
  0x3C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7,
  0xE7, 0xFE, 0x3C, 0xE1, 0xD8, 0x67, 0x39, 0xCE, 0x73, 0x0C, 0xC3, 0x70,
  0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0xE7, 0x36, 0x73, 0x67, 0x76, 0x77,
  0x7F, 0x77, 0xF6, 0x7D, 0xE3, 0xDE, 0x3D, 0xE3, 0xDE, 0x39, 0xE3, 0x9C,
  0x63, 0xB9, 0xDD, 0xC7, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0x3B, 0x9C,
  0xFC, 0x70, 0xE3, 0xB1, 0xDC, 0xC6, 0xE3, 0x61, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFE, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70,
  0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7, 0xE0, 0xE0,
  0xC1, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x60, 0xE0, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x30, 0xE3, 0x9B, 0x6D,
  0x30, 0xFF, 0xFC, 0x71, 0x8E, 0x79, 0xFB, 0x30, 0x67, 0xDD, 0xB3, 0x7E,
  0xEC, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB3, 0xE7, 0xCF, 0x9F, 0x3F, 0xED,
  0xC0, 0x7B, 0xFC, 0xF3, 0xC3, 0x0C, 0xFF, 0x78, 0x07, 0x07, 0x07, 0x07,
  0x3F, 0x7F, 0x67, 0x67, 0xE7, 0x67, 0x67, 0x7F, 0x3F, 0x79, 0xFB, 0x3F,
  0xFF, 0xF8, 0x39, 0x7E, 0x7C, 0x19, 0xDC, 0xEF, 0xFD, 0xCE, 0x73, 0x9C,
  0xE7, 0x00, 0x7F, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1F, 0xF3,
  0xC0, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xE0, 0x5F, 0x0D, 0xB6, 0xDB, 0x6C, 0x11, 0xCC, 0x03, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x1B, 0xDC, 0xC1, 0x83, 0x06, 0x0C, 0xFB, 0xB6, 0x7C, 0xF9,
  0xF3, 0x76, 0x7C, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xDD, 0xDF, 0xFB, 0x3B,
  0xE7, 0x7C, 0xEF, 0x9D, 0xF3, 0xBE, 0x77, 0xCE, 0xE0, 0xDD, 0xFB, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCE, 0x79, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3, 0xFE,
  0x78, 0xDD, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3, 0xFE, 0xDD, 0x83, 0x06, 0x00,
  0x3F, 0x7F, 0x67, 0x67, 0xE7, 0x67, 0x67, 0x7F, 0x3F, 0x07, 0x07, 0x07,
  0xDF, 0xEC, 0xCC, 0xCC, 0xC0, 0x3C, 0xFD, 0x9B, 0x83, 0xC3, 0xF9, 0xBF,
  0x3C, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73, 0xCE, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xFF, 0x7E, 0xE6, 0x66, 0x6E, 0x6E, 0x7C, 0x3C, 0x3C, 0x38,
  0x38, 0xEC, 0xDB, 0xB6, 0xED, 0xBF, 0x7F, 0xDE, 0xE3, 0xB8, 0xEE, 0x33,
  0x80, 0x66, 0x7E, 0x7C, 0x3C, 0x38, 0x3C, 0x7C, 0x6E, 0xE6, 0xE6, 0x66,
  0x6E, 0x7E, 0x7C, 0x3C, 0x3C, 0x38, 0x18, 0x38, 0x70, 0x70, 0xFF, 0xF1,
  0x8E, 0x71, 0xCE, 0x3F, 0xFC, 0x11, 0x8C, 0x63, 0x19, 0xDC, 0xE3, 0x8C,
  0x63, 0x18, 0xC2, 0xFF, 0xFF, 0xFF, 0xF0, 0x43, 0x18, 0xE7, 0x39, 0xC7,
  0x3B, 0x9C, 0xE7, 0x31, 0x88, 0x63, 0xF6, 0xDE, 0xCC,
};

const GFXglyph RobotoCondensed_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 5, 5, 5, 0, -13 },
  { 10, 8, 12, 9, 0, -12 },
  { 22, 7, 16, 9, 1, -14 },
  { 36, 9, 12, 11, 1, -12 },
  { 50, 9, 12, 10, 1, -12 },
  { 64, 2, 5, 3, 0, -13 },
  { 66, 4, 17, 6, 1, -13 },
  { 75, 5, 17, 6, 0, -13 },
  { 86, 8, 7, 8, 0, -12 },
  { 93, 7, 8, 8, 0, -10 },
  { 100, 3, 5, 4, 0, -2 },
  { 102, 4, 2, 7, 1, -6 },
  { 103, 3, 3, 5, 1, -3 },
  { 105, 5, 13, 5, 0, -12 },
  { 114, 7, 12, 9, 1, -12 },
  { 125, 5, 12, 9, 1, -12 },
  { 133, 7, 12, 9, 1, -12 },
  { 144, 8, 12, 9, 0, -12 },
  { 156, 7, 12, 9, 1, -12 },
  { 167, 7, 12, 9, 1, -12 },
  { 178, 7, 12, 9, 1, -12 },
  { 189, 7, 12, 9, 1, -12 },
  { 200, 7, 12, 9, 1, -12 },
  { 211, 7, 12, 9, 1, -12 },
  { 222, 3, 10, 5, 1, -10 },
  { 226, 3, 13, 5, 1, -10 },
  { 231, 7, 8, 8, 0, -9 },
  { 238, 7, 5, 9, 1, -8 },
  { 243, 6, 8, 8, 1, -9 },
  { 249, 7, 12, 8, 0, -12 },
  { 260, 11, 16, 13, 1, -12 },
  { 282, 10, 12, 10, 0, -12 },
  { 297, 8, 12, 10, 1, -12 },
  { 309, 8, 12, 10, 1, -12 },
  { 321, 8, 12, 10, 1, -12 },
  { 333, 7, 12, 8, 1, -12 },
  { 344, 7, 12, 8, 1, -12 },
  { 355, 8, 12, 10, 1, -12 },
  { 367, 9, 12, 10, 1, -12 },
  { 381, 3, 12, 5, 1, -12 },
  { 386, 7, 12, 8, 0, -12 },
  { 397, 9, 12, 9, 1, -12 },
  { 411, 7, 12, 8, 1, -12 },
  { 422, 11, 12, 13, 1, -12 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 9, 12, 10, 1, -12 },
  { 465, 8, 12, 10, 1, -12 },
  { 477, 9, 14, 10, 1, -12 },
  { 493, 8, 12, 10, 1, -12 },
  { 505, 8, 12, 9, 1, -12 },
  { 517, 9, 12, 9, 0, -12 },
  { 531, 8, 12, 10, 1, -12 },
  { 543, 10, 12, 10, 0, -12 },
  { 558, 12, 12, 13, 0, -12 },
  { 576, 9, 12, 10, 0, -12 },
  { 590, 9, 12, 9, 0, -12 },
  { 604, 8, 12, 9, 1, -12 },
  { 616, 3, 17, 5, 1, -14 },
  { 623, 7, 13, 7, 0, -12 },
  { 635, 4, 17, 5, 0, -14 },
  { 644, 6, 6, 7, 0, -12 },
  { 649, 7, 2, 7, 0, 0 },
  { 651, 5, 3, 6, 0, -13 },
  { 653, 7, 9, 8, 1, -9 },
  { 661, 7, 13, 8, 1, -13 },
  { 673, 6, 9, 8, 1, -9 },
  { 680, 8, 13, 8, 0, -13 },
  { 693, 7, 9, 8, 1, -9 },
  { 701, 5, 13, 6, 0, -13 },
  { 710, 7, 12, 9, 1, -9 },
  { 721, 7, 13, 8, 1, -13 },
  { 733, 3, 13, 4, 1, -13 },
  { 738, 5, 16, 4, -1, -13 },
  { 748, 7, 13, 8, 1, -13 },
  { 760, 2, 13, 4, 1, -13 },
  { 764, 11, 9, 13, 1, -9 },
  { 777, 7, 9, 8, 1, -9 },
  { 785, 7, 9, 8, 1, -9 },
  { 793, 7, 12, 8, 1, -9 },
  { 804, 8, 12, 8, 0, -9 },
  { 816, 4, 9, 6, 1, -9 },
  { 821, 7, 9, 8, 0, -9 },
  { 829, 5, 11, 5, 0, -11 },
  { 836, 7, 9, 8, 1, -9 },
  { 844, 8, 9, 8, 0, -9 },
  { 853, 10, 9, 11, 0, -9 },
  { 865, 8, 9, 8, 0, -9 },
  { 874, 8, 12, 8, 0, -9 },
  { 886, 6, 9, 8, 1, -9 },
  { 893, 5, 16, 5, 0, -13 },
  { 903, 2, 14, 4, 1, -12 },
  { 907, 5, 16, 5, 0, -13 },
  { 917, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_EXTRABOLD17PT7B_H_
