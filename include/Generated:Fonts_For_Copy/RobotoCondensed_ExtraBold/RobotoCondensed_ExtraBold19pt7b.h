#ifndef _ROBOTOCONDENSED_EXTRABOLD19PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xCF, 0x3C, 0xB2, 0xC8, 0x16,
  0x36, 0x36, 0x36, 0xFF, 0xFF, 0x24, 0x2C, 0xFF, 0xFF, 0x6C, 0x6C, 0x68,
  0x48, 0x18, 0x18, 0x3C, 0x7E, 0xE7, 0xE7, 0xE0, 0x70, 0x7C, 0x3E, 0x0F,
  0x07, 0xE7, 0xE7, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x3E, 0x0D, 0x93, 0x6C,
  0xFA, 0x1D, 0x80, 0x40, 0x30, 0x1B, 0x87, 0xF3, 0x64, 0xD9, 0x27, 0xC0,
  0xE0, 0x3C, 0x1F, 0x86, 0xE1, 0x98, 0x6E, 0x1F, 0x03, 0x81, 0xE6, 0xFD,
  0xB3, 0xEC, 0xF3, 0xBC, 0xFF, 0x9F, 0xE0, 0xFF, 0xEC, 0x11, 0xCC, 0xC6,
  0x33, 0x98, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x31, 0xC4, 0x8C, 0xC6, 0x67,
  0x33, 0x33, 0x33, 0x37, 0x66, 0xCC, 0x80, 0x08, 0x04, 0x12, 0x5F, 0xF1,
  0xC1, 0xE0, 0xD8, 0x44, 0x38, 0x70, 0xE1, 0xCF, 0xFF, 0xFF, 0x9C, 0x38,
  0x70, 0xE0, 0x77, 0x76, 0x64, 0xFF, 0xC0, 0xFD, 0x80, 0x0C, 0x61, 0x86,
  0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x00, 0x3C, 0x7E, 0xEE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x3C, 0x0C,
  0xFF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x3C, 0xFE,
  0xEE, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xF0, 0xFF, 0xFF,
  0x3C, 0xFE, 0xEE, 0xE7, 0x07, 0x0E, 0x3C, 0x3E, 0x07, 0x07, 0xC7, 0xEF,
  0xFE, 0x7C, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x7E, 0x6E, 0xEE, 0xCE, 0xFF,
  0xFF, 0x0E, 0x0E, 0x0E, 0x7E, 0x7E, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0x67,
  0x07, 0x07, 0xE7, 0xEE, 0x7E, 0x3C, 0x1C, 0x3C, 0x78, 0x70, 0xE0, 0xFC,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0x07, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x3C, 0x7E,
  0xEE, 0xE7, 0xE6, 0xEE, 0x7C, 0x7E, 0xE6, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C,
  0x3C, 0x7E, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x06, 0x0E, 0x1E,
  0x3C, 0x30, 0x7D, 0x80, 0x00, 0x7D, 0x80, 0xFF, 0x80, 0x00, 0x0D, 0xBF,
  0xB0, 0x04, 0x77, 0xFE, 0xC3, 0xE7, 0xC7, 0x04, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x3C, 0x7E,
  0x77, 0xE7, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x18,
  0x0F, 0x80, 0xFF, 0x0C, 0x1C, 0xC0, 0x64, 0x79, 0x67, 0xCF, 0x36, 0x7B,
  0x33, 0xD9, 0x9E, 0xCC, 0xF6, 0x65, 0xBF, 0xEC, 0xEE, 0x70, 0x01, 0x80,
  0x07, 0xF0, 0x1F, 0x00, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x37,
  0x0E, 0xE1, 0xCC, 0x39, 0xC7, 0xF9, 0xFF, 0x38, 0x77, 0x0F, 0xC1, 0xC0,
  0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x3B, 0xFD, 0xFE, 0xE3, 0xF1, 0xF8,
  0xFC, 0xFF, 0xF7, 0xF0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x03, 0x81,
  0xC0, 0xE0, 0x71, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFC, 0x7F, 0x3B, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xEF, 0xE7, 0xE0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x03, 0x81,
  0xCF, 0xE7, 0xF1, 0xF8, 0xFE, 0x77, 0xF9, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xE7, 0x77, 0x7E, 0x3C, 0xE3, 0xB9,
  0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3B, 0xCE, 0x73,
  0x9C, 0xE3, 0xB8, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x8F,
  0xF8, 0xFF, 0x9F, 0xF9, 0xBF, 0xDB, 0xEF, 0xBE, 0xF3, 0xEF, 0x7E, 0xF7,
  0xE7, 0x7E, 0x67, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF9, 0xFE, 0x7F, 0xDF,
  0xB7, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xF0, 0x3E, 0x1F, 0xCF,
  0x7B, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xDE,
  0x7F, 0x0F, 0x80, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xFE,
  0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3E, 0x1F, 0xCF, 0x7B, 0x8E,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x39, 0xDE, 0x7F, 0x0F,
  0xE0, 0x3C, 0x04, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x9D, 0xFE,
  0xFE, 0x77, 0x39, 0xDC, 0xEE, 0x7F, 0x1C, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0x71, 0xF8, 0xFE, 0xE7, 0xF1, 0xF0, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xE0, 0xEE, 0x39,
  0xC7, 0x38, 0xE7, 0x1C, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x83, 0x60, 0x7C,
  0x0F, 0x80, 0xE0, 0x1C, 0x00, 0xE3, 0x1D, 0x8E, 0x77, 0x79, 0x9D, 0xEE,
  0x77, 0xB9, 0xDE, 0xE7, 0x7B, 0x8D, 0xFE, 0x3F, 0xF0, 0xFB, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0x73, 0xC0, 0x71, 0xDC, 0x77, 0xB8, 0xEE, 0x3F,
  0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0xC3, 0xB9, 0xCE, 0x73, 0xFC, 0x70,
  0xE1, 0xDC, 0x77, 0x38, 0xCE, 0x3B, 0x0F, 0xC1, 0xF0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x18, 0x70, 0xF1,
  0xE6, 0xCC, 0xD9, 0x80, 0xFF, 0xFC, 0x71, 0xC6, 0x7D, 0xFF, 0xB8, 0x77,
  0xFF, 0xF3, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0x7D, 0xFF, 0xBE, 0x3C, 0x18,
  0x31, 0xF7, 0xFE, 0xF8, 0x07, 0x07, 0x07, 0x07, 0x77, 0xFF, 0xEF, 0xC7,
  0xC7, 0xC7, 0xC7, 0xEF, 0xFF, 0x77, 0x3C, 0xFE, 0xEE, 0xE7, 0xFF, 0xFF,
  0xE0, 0xE6, 0x7E, 0x3C, 0x1C, 0xF3, 0x9C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC0, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7, 0xE7, 0xE7, 0xFF,
  0x77, 0x07, 0x4E, 0x7E, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xEE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7,
  0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0xEF, 0xEE, 0xFC, 0xFC, 0xF8, 0xFC, 0xFC,
  0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0xEF, 0xFF,
  0xEF, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67,
  0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0xFE,
  0xEE, 0xE7, 0xC7, 0xC7, 0xE7, 0xEE, 0xFE, 0x3C, 0xFC, 0xFE, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x77, 0xFF,
  0xEF, 0xC7, 0xC7, 0xC7, 0xC7, 0xEF, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x3C, 0x7F, 0x67, 0x70, 0x7C,
  0x1E, 0x07, 0x67, 0x7F, 0x3E, 0x71, 0xC7, 0x3E, 0xF9, 0xC7, 0x1C, 0x71,
  0xC7, 0x0F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF,
  0x77, 0xE7, 0x67, 0x77, 0x76, 0x76, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0xE6,
  0x76, 0x66, 0x6F, 0x66, 0xFE, 0x7F, 0xE7, 0xFE, 0x3B, 0xC3, 0x9C, 0x39,
  0xC3, 0x9C, 0x77, 0x77, 0x3E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7E, 0x77, 0xE7,
  0xE7, 0x33, 0x9D, 0xCE, 0xC7, 0xE1, 0xF0, 0xF8, 0x78, 0x1C, 0x0E, 0x06,
  0x07, 0x07, 0x83, 0x80, 0xFF, 0xFC, 0x70, 0xE3, 0x8E, 0x1C, 0x70, 0xFF,
  0xFC, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0xE7, 0x1C, 0x63, 0x18, 0xC6, 0x38,
  0xC0, 0xFF, 0xFF, 0x80, 0x8C, 0xEE, 0xEE, 0xE6, 0x77, 0x6E, 0xEE, 0xEE,
  0xC8, 0x73, 0xFD, 0xB7, 0xD9, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 6, 0, -14 },
  { 11, 8, 14, 10, 1, -14 },
  { 25, 8, 18, 10, 1, -16 },
  { 43, 10, 14, 12, 1, -14 },
  { 61, 10, 14, 11, 1, -14 },
  { 79, 3, 5, 3, 0, -14 },
  { 81, 5, 19, 6, 1, -15 },
  { 93, 4, 19, 6, 1, -15 },
  { 103, 9, 8, 9, 0, -14 },
  { 112, 7, 11, 9, 1, -12 },
  { 122, 4, 6, 5, 0, -2 },
  { 125, 5, 2, 7, 1, -7 },
  { 127, 3, 3, 6, 1, -3 },
  { 129, 6, 15, 6, 0, -14 },
  { 141, 8, 14, 10, 1, -14 },
  { 155, 6, 14, 10, 1, -14 },
  { 166, 8, 14, 10, 1, -14 },
  { 180, 8, 14, 10, 1, -14 },
  { 194, 8, 14, 10, 1, -14 },
  { 208, 8, 14, 10, 1, -14 },
  { 222, 8, 14, 10, 1, -14 },
  { 236, 8, 14, 10, 1, -14 },
  { 250, 8, 14, 10, 1, -14 },
  { 264, 8, 14, 10, 1, -14 },
  { 278, 3, 11, 5, 1, -11 },
  { 283, 3, 15, 5, 1, -11 },
  { 289, 6, 9, 9, 1, -10 },
  { 296, 7, 6, 10, 1, -9 },
  { 302, 7, 9, 9, 1, -10 },
  { 310, 8, 14, 9, 0, -14 },
  { 324, 13, 17, 15, 1, -13 },
  { 352, 11, 14, 11, 0, -14 },
  { 372, 9, 14, 11, 1, -14 },
  { 388, 9, 14, 11, 1, -14 },
  { 404, 9, 14, 11, 1, -14 },
  { 420, 8, 14, 9, 1, -14 },
  { 434, 8, 14, 9, 1, -14 },
  { 448, 9, 14, 11, 1, -14 },
  { 464, 10, 14, 12, 1, -14 },
  { 482, 3, 14, 5, 1, -14 },
  { 488, 8, 14, 9, 0, -14 },
  { 502, 10, 14, 11, 1, -14 },
  { 520, 8, 14, 9, 1, -14 },
  { 534, 12, 14, 14, 1, -14 },
  { 555, 10, 14, 12, 1, -14 },
  { 573, 10, 14, 11, 1, -14 },
  { 591, 9, 14, 11, 1, -14 },
  { 607, 10, 16, 11, 1, -14 },
  { 627, 9, 14, 11, 1, -14 },
  { 643, 9, 14, 10, 1, -14 },
  { 659, 10, 14, 10, 0, -14 },
  { 677, 9, 14, 11, 1, -14 },
  { 693, 11, 14, 11, 0, -14 },
  { 713, 14, 14, 14, 0, -14 },
  { 738, 10, 14, 11, 0, -14 },
  { 756, 10, 14, 10, 0, -14 },
  { 774, 9, 14, 10, 1, -14 },
  { 790, 4, 19, 5, 1, -16 },
  { 800, 8, 15, 7, 0, -14 },
  { 815, 4, 19, 5, 0, -16 },
  { 825, 7, 7, 8, 0, -14 },
  { 832, 7, 2, 8, 0, 0 },
  { 834, 5, 3, 6, 0, -14 },
  { 836, 7, 10, 9, 1, -10 },
  { 845, 8, 14, 9, 1, -14 },
  { 859, 7, 10, 9, 1, -10 },
  { 868, 8, 14, 9, 1, -14 },
  { 882, 8, 10, 9, 1, -10 },
  { 892, 6, 14, 6, 0, -14 },
  { 903, 8, 14, 10, 1, -10 },
  { 917, 8, 14, 9, 1, -14 },
  { 931, 3, 14, 5, 1, -14 },
  { 937, 5, 18, 5, -1, -14 },
  { 949, 8, 14, 9, 1, -14 },
  { 963, 3, 14, 5, 1, -14 },
  { 969, 12, 10, 14, 1, -10 },
  { 984, 8, 10, 9, 1, -10 },
  { 994, 8, 10, 9, 1, -10 },
  { 1004, 8, 14, 9, 1, -10 },
  { 1018, 8, 14, 9, 1, -10 },
  { 1032, 5, 10, 6, 1, -10 },
  { 1039, 8, 10, 9, 0, -10 },
  { 1049, 6, 13, 6, 0, -13 },
  { 1059, 8, 10, 9, 1, -10 },
  { 1069, 8, 10, 9, 0, -10 },
  { 1079, 12, 10, 12, 0, -10 },
  { 1094, 8, 10, 9, 0, -10 },
  { 1104, 9, 14, 9, 0, -10 },
  { 1120, 7, 10, 9, 1, -10 },
  { 1129, 5, 18, 6, 0, -15 },
  { 1141, 1, 17, 5, 2, -14 },
  { 1144, 4, 18, 6, 1, -15 },
  { 1153, 9, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_EXTRABOLD19PT7B_H_
