#ifndef _ROBOTOCONDENSED_EXTRABOLD11PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x29, 0x9E, 0x65, 0x7D, 0x4A, 0x23, 0x9E, 0xB6,
  0x1F, 0x6B, 0x71, 0x00, 0xC3, 0x4D, 0x38, 0x39, 0x75, 0xC6, 0x31, 0x65,
  0x9C, 0x7F, 0x7D, 0x9F, 0xE8, 0x5A, 0xAA, 0x94, 0x89, 0xB2, 0x4B, 0x6A,
  0x00, 0x25, 0x5E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x5C, 0xC0, 0xA0,
  0x24, 0xB4, 0x96, 0x80, 0x72, 0xD7, 0xBD, 0xAD, 0x6E, 0x3D, 0xB6, 0xDB,
  0x72, 0xF6, 0x33, 0x11, 0x9F, 0x76, 0xC6, 0x33, 0x0F, 0x6E, 0x19, 0xCE,
  0xB5, 0xFC, 0x63, 0x7A, 0x10, 0xE5, 0x8D, 0x6E, 0x33, 0x10, 0xFD, 0xA5,
  0x6E, 0xF8, 0xC6, 0x23, 0x18, 0x8C, 0x72, 0xD6, 0xB7, 0x2D, 0x6E, 0x72,
  0xF6, 0xB7, 0x8C, 0xCC, 0xA0, 0xA0, 0x50, 0x17, 0x17, 0xC7, 0x10, 0xF0,
  0xF0, 0x8E, 0x3E, 0x80, 0x76, 0xC4, 0x62, 0x00, 0x84, 0x1C, 0x22, 0x5D,
  0x55, 0xF5, 0xB5, 0xF5, 0x5E, 0x60, 0x3C, 0x30, 0x70, 0xE3, 0x46, 0x8F,
  0x93, 0x62, 0xF4, 0xA7, 0x2F, 0x4E, 0x7E, 0x39, 0xB4, 0xF0, 0xC1, 0x36,
  0xCE, 0xE5, 0xA7, 0x39, 0xCE, 0xDC, 0xF8, 0x88, 0xF8, 0x8F, 0xF8, 0x88,
  0xF8, 0x88, 0x39, 0xB4, 0xF0, 0xDD, 0x36, 0xCE, 0x9C, 0xE7, 0x3F, 0xCE,
  0x73, 0xFF, 0x18, 0xC6, 0x31, 0x8F, 0x6E, 0x9D, 0xAD, 0xCE, 0x7A, 0x53,
  0x88, 0x88, 0x88, 0x8F, 0xCF, 0x9F, 0x3F, 0x7B, 0xF6, 0xED, 0xDB, 0x9E,
  0xF7, 0xFB, 0xDE, 0x73, 0x39, 0xB4, 0xF3, 0xCD, 0x36, 0xCE, 0xF4, 0xE7,
  0x3F, 0x42, 0x10, 0x39, 0xB4, 0xF3, 0xCD, 0x36, 0xCE, 0x0C, 0xF4, 0xE7,
  0x3F, 0x5A, 0x53, 0x79, 0xA4, 0x1C, 0x1B, 0x36, 0x9E, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39, 0xCF, 0x7E, 0xCD, 0x34, 0xDA, 0x78,
  0xE3, 0x8C, 0xDB, 0xDB, 0x5B, 0x5A, 0x7E, 0x7E, 0x76, 0x66, 0xCD, 0xA7,
  0x8C, 0x31, 0xE6, 0xB3, 0xCD, 0x27, 0x8E, 0x30, 0xC3, 0x0C, 0xFC, 0x21,
  0x8C, 0x31, 0x84, 0x3F, 0xEA, 0xAA, 0xAC, 0xCC, 0x46, 0x62, 0x33, 0x10,
  0xD5, 0x55, 0x5C, 0x66, 0x7D, 0xF0, 0x4C, 0x76, 0xDF, 0xBD, 0xBC, 0x88,
  0x8F, 0xBB, 0xBB, 0xF0, 0x72, 0xF1, 0x85, 0xB8, 0x18, 0xC6, 0xFD, 0xEF,
  0x7B, 0x78, 0x72, 0xF7, 0xF4, 0x3C, 0x76, 0x6E, 0x66, 0x66, 0x60, 0x6E,
  0xF7, 0xBD, 0xBD, 0x6E, 0xC6, 0x31, 0xED, 0xEF, 0x7B, 0xD8, 0xDF, 0x80,
  0x51, 0x55, 0x7C, 0x88, 0x8B, 0xEE, 0xEB, 0xB0, 0xFF, 0x80, 0xED, 0x6E,
  0xDD, 0xBB, 0x76, 0xC0, 0xFE, 0xF7, 0xBD, 0xEC, 0x72, 0xF7, 0xB5, 0xB8,
  0xFB, 0xBB, 0xBE, 0x88, 0x7E, 0xF7, 0xBD, 0xBC, 0x63, 0xFE, 0x49, 0x00,
  0x76, 0xD8, 0x6D, 0xB8, 0x5D, 0x24, 0x98, 0xDE, 0xF7, 0xB5, 0xBC, 0xDA,
  0x94, 0xA7, 0x10, 0xD7, 0xA9, 0xF3, 0x66, 0xCD, 0x80, 0xDB, 0x9C, 0xE5,
  0x6C, 0xDE, 0x94, 0xE7, 0x11, 0x8C, 0xF8, 0x8C, 0xC4, 0x7C, 0x2D, 0x25,
  0x92, 0x4C, 0x80, 0xFF, 0x80, 0xC9, 0x24, 0x52, 0x4A, 0x00, 0xD5, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 0, -8 },
  { 4, 5, 8, 6, 0, -8 },
  { 9, 5, 10, 6, 0, -9 },
  { 16, 6, 8, 7, 1, -8 },
  { 22, 6, 8, 6, 0, -8 },
  { 28, 2, 3, 2, 0, -8 },
  { 29, 2, 11, 4, 1, -9 },
  { 32, 3, 11, 4, 0, -9 },
  { 37, 5, 5, 5, 0, -8 },
  { 41, 5, 5, 5, 0, -6 },
  { 45, 2, 3, 3, 0, -1 },
  { 46, 2, 1, 4, 1, -4 },
  { 47, 2, 2, 3, 1, -2 },
  { 48, 3, 9, 4, 0, -8 },
  { 52, 5, 8, 6, 0, -8 },
  { 57, 3, 8, 6, 1, -8 },
  { 60, 5, 8, 6, 0, -8 },
  { 65, 5, 8, 6, 0, -8 },
  { 70, 5, 8, 6, 0, -8 },
  { 75, 5, 8, 6, 0, -8 },
  { 80, 5, 8, 6, 0, -8 },
  { 85, 5, 8, 6, 0, -8 },
  { 90, 5, 8, 6, 0, -8 },
  { 95, 5, 8, 6, 0, -8 },
  { 100, 2, 6, 3, 1, -6 },
  { 102, 2, 8, 3, 0, -6 },
  { 104, 4, 5, 5, 0, -6 },
  { 107, 4, 3, 6, 1, -5 },
  { 109, 4, 5, 5, 1, -6 },
  { 112, 5, 8, 5, 0, -8 },
  { 117, 8, 10, 8, 0, -8 },
  { 127, 7, 8, 7, 0, -8 },
  { 134, 5, 8, 6, 1, -8 },
  { 139, 6, 8, 6, 0, -8 },
  { 145, 5, 8, 6, 1, -8 },
  { 150, 4, 8, 5, 1, -8 },
  { 154, 4, 8, 5, 1, -8 },
  { 158, 6, 8, 6, 0, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 1, 8, 3, 1, -8 },
  { 170, 5, 8, 5, 0, -8 },
  { 175, 5, 8, 6, 1, -8 },
  { 180, 4, 8, 5, 1, -8 },
  { 184, 7, 8, 8, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 0, -8 },
  { 202, 5, 8, 6, 1, -8 },
  { 207, 6, 9, 7, 0, -8 },
  { 214, 5, 8, 6, 1, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 6, 8, 6, 0, -8 },
  { 231, 5, 8, 6, 1, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 8, 8, 8, 0, -8 },
  { 250, 6, 8, 6, 0, -8 },
  { 256, 6, 8, 6, 0, -8 },
  { 262, 6, 8, 6, 0, -8 },
  { 268, 2, 11, 3, 1, -9 },
  { 271, 4, 9, 4, 0, -8 },
  { 276, 2, 11, 3, 0, -9 },
  { 279, 4, 4, 4, 0, -8 },
  { 281, 4, 1, 4, 0, 0 },
  { 282, 3, 2, 4, 0, -9 },
  { 283, 5, 6, 5, 0, -6 },
  { 287, 4, 9, 5, 1, -9 },
  { 292, 5, 6, 5, 0, -6 },
  { 296, 5, 9, 5, 0, -9 },
  { 302, 5, 6, 5, 0, -6 },
  { 306, 4, 9, 4, 0, -9 },
  { 311, 5, 8, 6, 0, -6 },
  { 316, 5, 9, 5, 0, -9 },
  { 322, 1, 9, 3, 1, -9 },
  { 324, 2, 11, 3, 0, -9 },
  { 327, 4, 9, 5, 1, -9 },
  { 332, 1, 9, 3, 1, -9 },
  { 334, 7, 6, 8, 1, -6 },
  { 340, 5, 6, 5, 0, -6 },
  { 344, 5, 6, 5, 0, -6 },
  { 348, 4, 8, 5, 1, -6 },
  { 352, 5, 8, 5, 0, -6 },
  { 357, 3, 6, 4, 1, -6 },
  { 360, 5, 6, 5, 0, -6 },
  { 364, 3, 7, 3, 0, -7 },
  { 367, 5, 6, 5, 0, -6 },
  { 371, 5, 6, 5, 0, -6 },
  { 375, 7, 6, 7, 0, -6 },
  { 381, 5, 6, 5, 0, -6 },
  { 385, 5, 8, 5, 0, -6 },
  { 390, 5, 6, 5, 0, -6 },
  { 394, 3, 11, 3, 0, -9 },
  { 399, 1, 9, 3, 1, -8 },
  { 401, 3, 11, 3, 0, -9 },
  { 406, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_EXTRABOLD11PT7B_H_
