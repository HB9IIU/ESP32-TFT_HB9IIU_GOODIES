#ifndef _ROBOTOCONDENSED_EXTRABOLD9PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x4C, 0xB4, 0x35, 0x76, 0xF6, 0x60, 0x27, 0x54, 0x61, 0xD7,
  0x20, 0x65, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x9C, 0xCE, 0xE9, 0xE0, 0xC0,
  0x6A, 0xAA, 0x40, 0x95, 0x55, 0x80, 0x2D, 0x65, 0x66, 0xF6, 0x60, 0x58,
  0xC0, 0x80, 0x29, 0x24, 0xA4, 0x65, 0xDD, 0xD5, 0x60, 0x75, 0x54, 0x7D,
  0x13, 0x24, 0xF0, 0x7D, 0x12, 0x1D, 0x70, 0x33, 0x77, 0xF3, 0x30, 0x74,
  0x71, 0x1D, 0x60, 0x24, 0x7D, 0xD5, 0x70, 0xF1, 0x32, 0x26, 0x40, 0x75,
  0x56, 0xDD, 0x70, 0x65, 0xDD, 0x73, 0x60, 0x88, 0x40, 0x58, 0x3E, 0xE3,
  0xE3, 0x80, 0x9F, 0xC0, 0x6F, 0x32, 0x60, 0x60, 0x38, 0x89, 0x6D, 0x5A,
  0xB7, 0x90, 0x1C, 0x21, 0x9C, 0xA5, 0xBF, 0x20, 0xF6, 0xF7, 0xED, 0xEF,
  0xC0, 0x72, 0xF1, 0x8C, 0x2D, 0xC0, 0xF6, 0xB7, 0xBD, 0xEB, 0xC0, 0xFC,
  0xCF, 0xCC, 0xF0, 0xFC, 0xCF, 0xCC, 0xC0, 0x72, 0xF1, 0xBC, 0xA5, 0xC0,
  0xCE, 0x73, 0xFC, 0xE7, 0x20, 0xFE, 0x11, 0x11, 0x1F, 0x60, 0xDE, 0xBD,
  0xCF, 0x6B, 0x60, 0xCC, 0xCC, 0xCC, 0xF0, 0xCF, 0xBE, 0xFB, 0xFF, 0x5D,
  0x40, 0xCE, 0x7B, 0xDD, 0xEF, 0x60, 0x72, 0xF3, 0x9C, 0xAD, 0xC0, 0xF6,
  0xF7, 0xBF, 0x63, 0x00, 0x72, 0xF3, 0x9C, 0xAD, 0xC1, 0xF6, 0xF7, 0xED,
  0x6B, 0x60, 0x76, 0x90, 0xE1, 0x6D, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0xDE, 0xF7, 0xBD, 0xAD, 0xC0, 0xCE, 0xD6, 0xA7, 0x38, 0x80, 0xD5, 0xA9,
  0xD3, 0xE6, 0xCD, 0x9B, 0x00, 0xDA, 0x9C, 0x47, 0x2B, 0x60, 0xDA, 0x94,
  0xE2, 0x10, 0x80, 0xF8, 0x8C, 0x46, 0x23, 0xE0, 0xFF, 0xFF, 0xC0, 0xCC,
  0x44, 0x62, 0x22, 0xD5, 0x55, 0xC0, 0x4E, 0x80, 0xE0, 0x48, 0x6F, 0x7F,
  0x70, 0xCC, 0xFD, 0xDD, 0xF0, 0x6D, 0xCD, 0x60, 0x11, 0x7D, 0xDD, 0x70,
  0x7D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0x70, 0xCC, 0xFD,
  0xDD, 0xD0, 0xCF, 0xFC, 0xCF, 0xFF, 0x80, 0xCC, 0xFE, 0xEF, 0xD0, 0xFF,
  0xFC, 0xFF, 0x5D, 0x75, 0xD4, 0xFD, 0xDD, 0xD0, 0x7D, 0xDD, 0x70, 0xFD,
  0xDD, 0xFC, 0xC0, 0x7D, 0xDD, 0x71, 0x10, 0xFB, 0x6C, 0x6F, 0x6B, 0x60,
  0x5D, 0x24, 0xC0, 0xDD, 0xDD, 0x70, 0xFF, 0x66, 0x60, 0xAB, 0xE7, 0x9E,
  0x58, 0xF6, 0x66, 0xF0, 0xFF, 0x66, 0x66, 0x40, 0xF2, 0x64, 0xF0, 0x55,
  0x95, 0x40, 0xFF, 0x95, 0x55, 0x80, 0x75, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 3, 2, 3, 0, -7 },
  { 4, 4, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 5, 7, 6, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 1, 0, -7 },
  { 24, 2, 9, 3, 1, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 3, 2, 0, -1 },
  { 36, 2, 1, 4, 1, -3 },
  { 37, 1, 1, 3, 1, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 5, 0, -7 },
  { 45, 2, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 4, 7, 5, 0, -7 },
  { 59, 4, 7, 5, 0, -7 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 0, -7 },
  { 79, 1, 5, 3, 1, -5 },
  { 80, 2, 7, 2, 0, -5 },
  { 82, 4, 4, 4, 0, -5 },
  { 84, 3, 3, 5, 1, -4 },
  { 86, 3, 4, 4, 1, -5 },
  { 88, 4, 7, 4, 0, -7 },
  { 92, 7, 8, 7, 0, -6 },
  { 99, 5, 7, 5, 0, -7 },
  { 104, 5, 7, 5, 0, -7 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 5, 7, 5, 0, -7 },
  { 119, 4, 7, 4, 0, -7 },
  { 123, 4, 7, 4, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 5, 7, 6, 0, -7 },
  { 137, 1, 7, 2, 1, -7 },
  { 138, 4, 7, 4, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 4, 7, 4, 0, -7 },
  { 151, 6, 7, 7, 0, -7 },
  { 157, 5, 7, 6, 0, -7 },
  { 162, 5, 7, 5, 0, -7 },
  { 167, 5, 7, 5, 0, -7 },
  { 172, 5, 8, 5, 0, -7 },
  { 177, 5, 7, 5, 0, -7 },
  { 182, 5, 7, 5, 0, -7 },
  { 187, 5, 7, 5, 0, -7 },
  { 192, 5, 7, 5, 0, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 7, 7, 7, 0, -7 },
  { 209, 5, 7, 5, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 5, 7, 5, 0, -7 },
  { 224, 2, 9, 2, 0, -7 },
  { 227, 4, 8, 3, 0, -7 },
  { 231, 2, 9, 2, 0, -7 },
  { 234, 3, 3, 4, 0, -7 },
  { 236, 3, 1, 4, 0, 0 },
  { 237, 3, 2, 3, 0, -7 },
  { 238, 4, 5, 4, 0, -5 },
  { 241, 4, 7, 4, 0, -7 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 4, 7, 4, 0, -7 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 3, 7, 3, 0, -7 },
  { 258, 4, 7, 5, 0, -5 },
  { 262, 4, 7, 4, 0, -7 },
  { 266, 2, 7, 2, 0, -7 },
  { 268, 2, 9, 2, 0, -7 },
  { 271, 4, 7, 4, 0, -7 },
  { 275, 2, 7, 2, 0, -7 },
  { 277, 6, 5, 7, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 4, 5, 4, 0, -5 },
  { 287, 4, 7, 4, 0, -5 },
  { 291, 4, 7, 4, 0, -5 },
  { 295, 3, 5, 3, 0, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 3, 6, 3, 0, -6 },
  { 303, 4, 5, 4, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 6, 5, 6, 0, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 4, 7, 4, 0, -5 },
  { 320, 4, 5, 4, 0, -5 },
  { 323, 2, 9, 3, 0, -7 },
  { 326, 1, 8, 2, 1, -7 },
  { 327, 2, 9, 3, 0, -7 },
  { 330, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_EXTRABOLD9PT7B_H_
