#ifndef _ROBOTOCONDENSED_EXTRABOLD48PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x01,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xBC,
  0x3D, 0xE1, 0xEF, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07,
  0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0x7F, 0x87, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xCF, 0x83, 0x81, 0xF1, 0xF0,
  0x78, 0x3E, 0x1E, 0x1E, 0x07, 0xC3, 0xC3, 0xC0, 0xF8, 0x78, 0xF0, 0x1F,
  0x0F, 0x3E, 0x03, 0xE3, 0xE7, 0x80, 0x3E, 0x7D, 0xF0, 0x07, 0xFF, 0x3C,
  0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xF9, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x1E, 0x7F,
  0x80, 0x07, 0xDF, 0xF8, 0x00, 0xF7, 0xFF, 0x80, 0x3E, 0xF9, 0xF0, 0x07,
  0x9F, 0x1E, 0x01, 0xF3, 0xC3, 0xE0, 0x3C, 0x78, 0x7C, 0x0F, 0x0F, 0x0F,
  0x81, 0xE1, 0xE1, 0xF0, 0x78, 0x3E, 0x3C, 0x0F, 0x07, 0xCF, 0x80, 0x40,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0x0F, 0xFF, 0x1F, 0x8F,
  0xFF, 0xCF, 0xC7, 0xEF, 0xF7, 0xE7, 0xF7, 0xFB, 0xF3, 0xF9, 0xFF, 0xF9,
  0xFC, 0x7F, 0xFC, 0xFE, 0x1F, 0xFC, 0x7F, 0x07, 0xFE, 0x3F, 0x83, 0xFE,
  0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x40, 0x18,
  0x07, 0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x78, 0x06, 0x00, 0x40, 0x60, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0x78, 0x07, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x20, 0x78, 0x01, 0xC3,
  0xC1, 0xDF, 0xDE, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3,
  0xE0, 0x1F, 0x8F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x1C, 0x0F, 0x00,
  0x40, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x7E, 0x7C, 0xFC, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x18,
  0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0x7D, 0xFC, 0x07,
  0xEF, 0xE0, 0x3E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x1F, 0xC1, 0xF8, 0xFE,
  0x0F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF7,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0x3F, 0xE0, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x7C, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFC, 0xFF, 0x1F, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0x8F, 0xE7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x8F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8, 0xFE, 0x7F, 0x0F,
  0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0x7F, 0x03, 0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x18, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x08, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xFD, 0xFC, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8,
  0xFC, 0xFC, 0x7C, 0x3E, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x0F, 0x80, 0x7E, 0x07, 0xC7, 0xC0, 0xFF, 0xC1, 0xE3, 0xC0, 0xFF,
  0xF0, 0xF3, 0xE0, 0xFF, 0xF8, 0x79, 0xF0, 0x7E, 0x7C, 0x3E, 0xF0, 0x7E,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0x07, 0xFC, 0x3F, 0x0F, 0x83, 0xFE, 0x1F,
  0x07, 0xC1, 0xFF, 0x0F, 0x83, 0xE0, 0xFF, 0x87, 0xC1, 0xF0, 0x7F, 0x87,
  0xE0, 0xF0, 0x3F, 0xC3, 0xF0, 0x78, 0x3F, 0xE1, 0xF8, 0x7C, 0x1F, 0xF0,
  0xFC, 0x3E, 0x0F, 0x78, 0x7E, 0x1F, 0x07, 0xBC, 0x3F, 0x0F, 0x87, 0xDF,
  0x0F, 0x8F, 0xC3, 0xCF, 0x87, 0xEF, 0xF3, 0xE7, 0xC3, 0xFF, 0xFF, 0xE3,
  0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0x9F, 0xE0, 0x7C, 0x0F, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x08,
  0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xBF, 0x80, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x07, 0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC3, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xE1,
  0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x87, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xE0, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7,
  0xF9, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFE,
  0x07, 0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x0F, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0xFF,
  0xBF, 0xC0, 0xFF, 0x3F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xBF,
  0x07, 0xFF, 0xFF, 0x7E, 0x0F, 0xBF, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xF8,
  0x7E, 0xFF, 0xFD, 0xF8, 0xF9, 0xFF, 0xFB, 0xF3, 0xF3, 0xFF, 0xF7, 0xE7,
  0xE7, 0xFF, 0xE7, 0xCF, 0xCF, 0xFF, 0xCF, 0xDF, 0x1F, 0xFF, 0x9F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x7F, 0xE1,
  0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFE, 0xF8, 0xFF, 0xFE, 0xFC, 0xFF, 0xFE, 0xFC, 0xFF, 0xFE,
  0x7E, 0xFF, 0xFE, 0x7E, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8,
  0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x01, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x03, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F,
  0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xC7, 0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07,
  0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFE, 0x7F, 0x07, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0x8F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81,
  0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x07, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xF9, 0xFC, 0x3F, 0xE1,
  0xFE, 0x7F, 0x8F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF,
  0xC7, 0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x9F, 0xFC, 0x7F, 0x0F, 0xE7,
  0xFF, 0x9F, 0xC3, 0xF9, 0xFF, 0xEF, 0xE0, 0x7F, 0x7F, 0xFB, 0xF8, 0x1F,
  0xDF, 0xFE, 0xFE, 0x07, 0xF7, 0xFF, 0xBF, 0x81, 0xFF, 0xF7, 0xEF, 0xE0,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x9F, 0xE0,
  0x3F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xF8, 0x07, 0xFB, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF1,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFD, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0xBF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0x7C, 0x7F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFE, 0xFF, 0x8F, 0xE3, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xE7, 0xF0, 0xFF, 0x7F, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8,
  0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xBF, 0x0F,
  0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x8F, 0xF8, 0x18, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF3, 0xF8, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x86, 0x03, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF,
  0x8F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xEF, 0xE1, 0xFE,
  0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF7,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x9F,
  0xC3, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x03,
  0xE1, 0xFC, 0xFF, 0x1F, 0xF3, 0xFB, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F,
  0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83,
  0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xC1, 0xFC, 0xFE, 0x3F, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x0F, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE3, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE3,
  0xF8, 0x7F, 0xDF, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE,
  0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x3F, 0xF7,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0x1F, 0xE7,
  0xF0, 0xFC, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1,
  0xF8, 0x7F, 0x7E, 0x1F, 0xC7, 0xF7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7,
  0xE7, 0xF3, 0xFC, 0x7E, 0x7F, 0x3F, 0xCF, 0xE3, 0xF7, 0xFE, 0xFE, 0x3F,
  0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xDF,
  0xFC, 0x1F, 0xF9, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81,
  0xFF, 0x9F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF9, 0xFE, 0x3F, 0x9F, 0xC3, 0xFD, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x9F, 0xC3,
  0xF9, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFF, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x1E, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x20, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x20, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xCF, 0xFE, 0x1F, 0x7F, 0xF8, 0xFD,
  0xFF, 0xFF, 0xF7, 0xC7, 0xFF, 0xBF, 0x0F, 0xFE, 0xF8, 0x1F, 0xF3, 0xE0,
  0x3F, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 34, 13, 3, -34 },
  { 31, 13, 13, 15, 1, -36 },
  { 53, 22, 34, 25, 1, -34 },
  { 147, 20, 44, 24, 2, -39 },
  { 257, 27, 34, 31, 2, -34 },
  { 372, 25, 34, 28, 2, -34 },
  { 479, 6, 13, 8, 1, -36 },
  { 489, 11, 49, 16, 3, -38 },
  { 557, 12, 49, 16, 1, -38 },
  { 631, 21, 21, 22, 1, -34 },
  { 687, 20, 24, 23, 1, -28 },
  { 747, 8, 15, 12, 1, -6 },
  { 762, 12, 6, 19, 3, -18 },
  { 771, 8, 8, 14, 3, -8 },
  { 779, 15, 37, 15, 0, -34 },
  { 849, 20, 34, 24, 2, -34 },
  { 934, 13, 34, 24, 4, -34 },
  { 990, 20, 34, 24, 2, -34 },
  { 1075, 21, 34, 24, 1, -34 },
  { 1165, 21, 34, 24, 2, -34 },
  { 1255, 20, 34, 24, 2, -34 },
  { 1340, 21, 34, 24, 2, -34 },
  { 1430, 21, 34, 24, 1, -34 },
  { 1520, 20, 34, 24, 2, -34 },
  { 1605, 20, 34, 24, 2, -34 },
  { 1690, 8, 27, 14, 3, -27 },
  { 1717, 9, 36, 13, 2, -27 },
  { 1758, 18, 23, 21, 1, -26 },
  { 1810, 18, 16, 24, 3, -23 },
  { 1846, 17, 23, 22, 3, -26 },
  { 1895, 19, 34, 22, 1, -34 },
  { 1976, 33, 44, 37, 2, -33 },
  { 2158, 29, 34, 29, 0, -34 },
  { 2282, 22, 34, 27, 3, -34 },
  { 2376, 24, 34, 27, 2, -34 },
  { 2478, 22, 34, 27, 3, -34 },
  { 2572, 19, 34, 23, 3, -34 },
  { 2653, 19, 34, 23, 3, -34 },
  { 2734, 24, 34, 28, 2, -34 },
  { 2836, 24, 34, 29, 3, -34 },
  { 2938, 7, 34, 13, 3, -34 },
  { 2968, 20, 34, 24, 1, -34 },
  { 3053, 24, 34, 27, 3, -34 },
  { 3155, 19, 34, 23, 3, -34 },
  { 3236, 31, 34, 36, 3, -34 },
  { 3368, 24, 34, 29, 3, -34 },
  { 3470, 25, 34, 29, 2, -34 },
  { 3577, 23, 34, 27, 3, -34 },
  { 3675, 25, 40, 29, 2, -34 },
  { 3800, 23, 34, 27, 3, -34 },
  { 3898, 22, 34, 26, 2, -34 },
  { 3992, 24, 34, 26, 1, -34 },
  { 4094, 23, 34, 28, 2, -34 },
  { 4192, 28, 34, 28, 0, -34 },
  { 4311, 34, 34, 36, 1, -34 },
  { 4456, 25, 34, 27, 1, -34 },
  { 4563, 26, 34, 26, 0, -34 },
  { 4674, 22, 34, 26, 2, -34 },
  { 4768, 10, 48, 13, 2, -40 },
  { 4828, 19, 37, 18, 0, -34 },
  { 4916, 9, 48, 13, 1, -40 },
  { 4970, 17, 17, 19, 1, -34 },
  { 5007, 19, 6, 19, 0, 0 },
  { 5022, 13, 7, 16, 1, -36 },
  { 5034, 20, 26, 23, 1, -26 },
  { 5099, 20, 36, 24, 2, -36 },
  { 5189, 20, 26, 22, 1, -26 },
  { 5254, 20, 36, 24, 1, -36 },
  { 5344, 20, 26, 23, 2, -26 },
  { 5409, 14, 36, 16, 1, -36 },
  { 5472, 21, 36, 24, 1, -26 },
  { 5567, 20, 36, 24, 2, -36 },
  { 5657, 8, 36, 12, 2, -36 },
  { 5693, 12, 46, 12, -2, -36 },
  { 5762, 21, 36, 23, 2, -36 },
  { 5857, 7, 36, 12, 3, -36 },
  { 5889, 31, 26, 36, 2, -26 },
  { 5990, 20, 26, 24, 2, -26 },
  { 6055, 21, 26, 24, 1, -26 },
  { 6124, 20, 36, 24, 2, -26 },
  { 6214, 21, 36, 24, 1, -26 },
  { 6309, 13, 26, 16, 2, -26 },
  { 6352, 19, 26, 22, 1, -26 },
  { 6414, 13, 32, 15, 1, -32 },
  { 6466, 20, 26, 24, 2, -26 },
  { 6531, 21, 26, 22, 0, -26 },
  { 6600, 28, 26, 30, 1, -26 },
  { 6691, 20, 26, 22, 1, -26 },
  { 6756, 21, 36, 22, 0, -26 },
  { 6851, 18, 26, 22, 2, -26 },
  { 6910, 12, 45, 14, 1, -37 },
  { 6978, 4, 40, 12, 4, -34 },
  { 6998, 12, 45, 14, 1, -37 },
  { 7066, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBold48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_EXTRABOLD48PT7B_H_
