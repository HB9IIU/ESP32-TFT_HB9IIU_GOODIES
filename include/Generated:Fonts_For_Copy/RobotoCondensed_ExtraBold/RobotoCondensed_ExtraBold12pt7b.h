#ifndef _ROBOTOCONDENSED_EXTRABOLD12PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA2, 0x80, 0xFA, 0xA0, 0x28, 0xA2, 0x9F, 0x3B, 0xE5, 0x14,
  0x50, 0x23, 0xBD, 0xBC, 0x38, 0xD3, 0xF3, 0x88, 0xC2, 0xAB, 0x34, 0x20,
  0xF5, 0x55, 0x1C, 0x30, 0xF1, 0xA3, 0xC7, 0x0E, 0xB7, 0x3E, 0x7C, 0xF8,
  0x4B, 0x49, 0x24, 0x99, 0x20, 0x89, 0x92, 0x49, 0x2D, 0x40, 0x25, 0x1E,
  0xE4, 0x80, 0x31, 0xBF, 0xF3, 0x18, 0x57, 0xE0, 0xF0, 0x32, 0x22, 0x64,
  0x44, 0xC8, 0x67, 0xA5, 0x39, 0xCE, 0x5E, 0x70, 0x3E, 0x92, 0x49, 0x20,
  0x79, 0xEC, 0x86, 0x18, 0xC6, 0x18, 0x7C, 0x79, 0xE0, 0x86, 0x38, 0x20,
  0xFE, 0x78, 0x18, 0xE3, 0x8E, 0x59, 0x6F, 0xC6, 0x18, 0x79, 0x84, 0x1E,
  0x58, 0x34, 0xDE, 0x38, 0x77, 0x31, 0xEF, 0x4E, 0x7E, 0x70, 0xFC, 0x21,
  0x86, 0x10, 0xC3, 0x08, 0x60, 0xF7, 0xA5, 0xEF, 0x4A, 0x7E, 0xF0, 0x67,
  0xA5, 0x3F, 0xF8, 0xCE, 0x60, 0xF0, 0x3C, 0x6C, 0x00, 0x12, 0x58, 0x0B,
  0xF0, 0xF0, 0x80, 0xF0, 0xF0, 0x8E, 0x3E, 0x80, 0x76, 0xC6, 0x33, 0x10,
  0x04, 0x20, 0x1E, 0x10, 0x93, 0x4A, 0x95, 0x4E, 0xA7, 0x54, 0xBE, 0x40,
  0x30, 0x0F, 0x00, 0x18, 0x70, 0xE1, 0x46, 0xCF, 0x9F, 0x23, 0xC6, 0xF7,
  0xF7, 0xBF, 0x6F, 0x7F, 0xF0, 0x38, 0xF9, 0x12, 0x0C, 0x08, 0x11, 0x3E,
  0x38, 0xF7, 0xF7, 0xBD, 0xEF, 0x7F, 0xF0, 0xFF, 0xF1, 0x8F, 0x63, 0x1F,
  0xF8, 0xFF, 0xCF, 0xFC, 0xCC, 0xC0, 0x73, 0xEC, 0xA0, 0x82, 0x7C, 0xFF,
  0x78, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x18,
  0xC6, 0x31, 0x8F, 0x6F, 0x70, 0xDB, 0x6F, 0x3C, 0xF3, 0xCF, 0xB6, 0xD8,
  0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC7, 0x8F, 0xBF, 0x7A, 0xB5, 0x6E, 0xDD,
  0x92, 0xCF, 0x3E, 0xFB, 0xAE, 0xF9, 0xE7, 0x8C, 0x38, 0xF9, 0x1A, 0x3C,
  0x68, 0xD9, 0xBE, 0x38, 0xF7, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x38, 0xF9,
  0x9A, 0x3C, 0x68, 0xD9, 0xBE, 0x3C, 0x1C, 0x10, 0xF7, 0xF7, 0xBF, 0xFB,
  0xDB, 0xD8, 0x39, 0xF4, 0xD8, 0x38, 0x3C, 0xDB, 0x38, 0xFF, 0xF3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x70, 0xC7, 0x89,
  0xB3, 0x66, 0xC5, 0x0E, 0x1C, 0x38, 0xC9, 0xEE, 0x97, 0x4F, 0xE7, 0x73,
  0xB9, 0xDC, 0xEC, 0x36, 0x00, 0xCC, 0xD9, 0xA1, 0xC3, 0x87, 0x1A, 0x36,
  0xCC, 0xCD, 0xB6, 0x9E, 0x38, 0xC3, 0x0C, 0x30, 0xFF, 0xF1, 0x86, 0x30,
  0xC6, 0x1F, 0xFC, 0xEA, 0xAA, 0xAB, 0xC6, 0x18, 0xC6, 0x10, 0xC6, 0x10,
  0xC0, 0xED, 0xB6, 0xDB, 0x6D, 0xF0, 0x23, 0x95, 0xA0, 0xF8, 0x64, 0x72,
  0xC6, 0xFD, 0xED, 0xE0, 0x84, 0x3D, 0xE9, 0xCE, 0x7E, 0xF0, 0x73, 0xF7,
  0x8C, 0x3D, 0xE0, 0x08, 0x5A, 0xFC, 0xE7, 0x2F, 0x68, 0x7B, 0xF3, 0xFC,
  0x35, 0xE0, 0x36, 0xF6, 0x66, 0x66, 0x60, 0x7D, 0xFC, 0xF3, 0xCD, 0xF7,
  0x96, 0x78, 0x88, 0xFF, 0x99, 0x99, 0x90, 0xA2, 0xAA, 0xA0, 0x51, 0x55,
  0x5F, 0x84, 0x2D, 0x6E, 0x73, 0xD6, 0x98, 0xFF, 0x80, 0xFF, 0xFE, 0x5C,
  0xB9, 0x72, 0xE5, 0x80, 0xFF, 0x99, 0x99, 0x90, 0x79, 0xEC, 0xF3, 0xCD,
  0xE7, 0x80, 0xF7, 0xA7, 0x39, 0xFB, 0xD0, 0x80, 0x6B, 0xF3, 0x9C, 0xBD,
  0xA1, 0x08, 0xFE, 0x49, 0x20, 0x72, 0xD8, 0xE1, 0xED, 0xC0, 0x6E, 0x66,
  0x66, 0x66, 0x99, 0x99, 0x9F, 0xD0, 0xDE, 0xD6, 0xE7, 0x38, 0xC0, 0xD3,
  0xBD, 0x7B, 0xF6, 0xED, 0x9B, 0x00, 0xDB, 0xDC, 0x67, 0x3F, 0x60, 0xDE,
  0xD6, 0xE7, 0x18, 0xCC, 0x60, 0x78, 0xCC, 0x66, 0x23, 0xE0, 0x2D, 0xB5,
  0x9B, 0x6C, 0x80, 0xFF, 0xE0, 0xC9, 0x26, 0x5A, 0x49, 0x00, 0xCD, 0xEC,
};

const GFXglyph RobotoCondensed_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 4, 0, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 5, 11, 6, 1, -10 },
  { 20, 6, 9, 8, 1, -9 },
  { 27, 7, 9, 7, 0, -9 },
  { 35, 2, 3, 2, 0, -9 },
  { 36, 3, 12, 4, 1, -9 },
  { 41, 3, 12, 4, 0, -9 },
  { 46, 5, 5, 6, 0, -9 },
  { 50, 5, 6, 6, 0, -7 },
  { 54, 2, 4, 3, 0, -1 },
  { 55, 3, 1, 5, 1, -4 },
  { 56, 2, 2, 4, 1, -2 },
  { 57, 4, 10, 4, 0, -9 },
  { 62, 5, 9, 6, 1, -9 },
  { 68, 3, 9, 6, 1, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 5, 9, 6, 1, -9 },
  { 106, 6, 9, 6, 0, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 5, 9, 6, 1, -9 },
  { 125, 2, 7, 3, 1, -7 },
  { 127, 3, 10, 3, 0, -7 },
  { 131, 5, 5, 5, 0, -6 },
  { 135, 4, 3, 6, 1, -5 },
  { 137, 4, 5, 5, 1, -6 },
  { 140, 5, 9, 5, 0, -9 },
  { 146, 9, 11, 9, 0, -8 },
  { 159, 7, 9, 7, 0, -9 },
  { 167, 5, 9, 7, 1, -9 },
  { 173, 7, 9, 7, 0, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 5, 9, 6, 1, -9 },
  { 193, 4, 9, 6, 1, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 2, 9, 3, 1, -9 },
  { 215, 5, 9, 6, 0, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 4, 9, 6, 1, -9 },
  { 233, 7, 9, 9, 1, -9 },
  { 241, 6, 9, 7, 1, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 5, 9, 7, 1, -9 },
  { 262, 7, 11, 7, 0, -9 },
  { 272, 5, 9, 7, 1, -9 },
  { 278, 6, 9, 7, 0, -9 },
  { 285, 6, 9, 7, 0, -9 },
  { 292, 5, 9, 7, 1, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 9, 9, 9, 0, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 6, 9, 7, 0, -9 },
  { 332, 6, 9, 6, 0, -9 },
  { 339, 2, 12, 3, 1, -10 },
  { 342, 5, 10, 5, 0, -9 },
  { 349, 3, 12, 3, 0, -10 },
  { 354, 5, 4, 5, 0, -9 },
  { 357, 5, 1, 5, 0, 0 },
  { 358, 3, 2, 4, 0, -9 },
  { 359, 5, 7, 6, 0, -7 },
  { 364, 5, 9, 6, 1, -9 },
  { 370, 5, 7, 6, 0, -7 },
  { 375, 5, 9, 6, 0, -9 },
  { 381, 5, 7, 6, 0, -7 },
  { 386, 4, 9, 4, 0, -9 },
  { 391, 6, 9, 6, 0, -7 },
  { 398, 4, 9, 6, 1, -9 },
  { 403, 2, 10, 3, 1, -10 },
  { 406, 2, 12, 3, 0, -10 },
  { 409, 5, 9, 6, 1, -9 },
  { 415, 1, 9, 3, 1, -9 },
  { 417, 7, 7, 9, 1, -7 },
  { 424, 4, 7, 6, 1, -7 },
  { 428, 6, 7, 6, 0, -7 },
  { 434, 5, 9, 6, 1, -7 },
  { 440, 5, 9, 6, 0, -7 },
  { 446, 3, 7, 4, 1, -7 },
  { 449, 5, 7, 5, 0, -7 },
  { 454, 4, 8, 4, 0, -8 },
  { 458, 4, 7, 6, 1, -7 },
  { 462, 5, 7, 5, 0, -7 },
  { 467, 7, 7, 8, 0, -7 },
  { 474, 5, 7, 5, 0, -7 },
  { 479, 5, 9, 5, 0, -7 },
  { 485, 5, 7, 5, 0, -7 },
  { 490, 3, 11, 4, 0, -9 },
  { 495, 1, 11, 3, 1, -9 },
  { 497, 3, 11, 4, 0, -9 },
  { 502, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_EXTRABOLD12PT7B_H_
