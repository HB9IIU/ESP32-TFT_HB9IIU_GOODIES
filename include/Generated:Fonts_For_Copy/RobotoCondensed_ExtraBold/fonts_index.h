#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_ExtraBold6pt7b, 6, "RobotoCondensed_ExtraBold6pt7b" },
  { &RobotoCondensed_ExtraBold7pt7b, 7, "RobotoCondensed_ExtraBold7pt7b" },
  { &RobotoCondensed_ExtraBold8pt7b, 8, "RobotoCondensed_ExtraBold8pt7b" },
  { &RobotoCondensed_ExtraBold9pt7b, 9, "RobotoCondensed_ExtraBold9pt7b" },
  { &RobotoCondensed_ExtraBold10pt7b, 10, "RobotoCondensed_ExtraBold10pt7b" },
  { &RobotoCondensed_ExtraBold11pt7b, 11, "RobotoCondensed_ExtraBold11pt7b" },
  { &RobotoCondensed_ExtraBold12pt7b, 12, "RobotoCondensed_ExtraBold12pt7b" },
  { &RobotoCondensed_ExtraBold13pt7b, 13, "RobotoCondensed_ExtraBold13pt7b" },
  { &RobotoCondensed_ExtraBold14pt7b, 14, "RobotoCondensed_ExtraBold14pt7b" },
  { &RobotoCondensed_ExtraBold15pt7b, 15, "RobotoCondensed_ExtraBold15pt7b" },
  { &RobotoCondensed_ExtraBold16pt7b, 16, "RobotoCondensed_ExtraBold16pt7b" },
  { &RobotoCondensed_ExtraBold17pt7b, 17, "RobotoCondensed_ExtraBold17pt7b" },
  { &RobotoCondensed_ExtraBold18pt7b, 18, "RobotoCondensed_ExtraBold18pt7b" },
  { &RobotoCondensed_ExtraBold19pt7b, 19, "RobotoCondensed_ExtraBold19pt7b" },
  { &RobotoCondensed_ExtraBold20pt7b, 20, "RobotoCondensed_ExtraBold20pt7b" },
  { &RobotoCondensed_ExtraBold21pt7b, 21, "RobotoCondensed_ExtraBold21pt7b" },
  { &RobotoCondensed_ExtraBold22pt7b, 22, "RobotoCondensed_ExtraBold22pt7b" },
  { &RobotoCondensed_ExtraBold23pt7b, 23, "RobotoCondensed_ExtraBold23pt7b" },
  { &RobotoCondensed_ExtraBold24pt7b, 24, "RobotoCondensed_ExtraBold24pt7b" },
  { &RobotoCondensed_ExtraBold25pt7b, 25, "RobotoCondensed_ExtraBold25pt7b" },
  { &RobotoCondensed_ExtraBold26pt7b, 26, "RobotoCondensed_ExtraBold26pt7b" },
  { &RobotoCondensed_ExtraBold27pt7b, 27, "RobotoCondensed_ExtraBold27pt7b" },
  { &RobotoCondensed_ExtraBold28pt7b, 28, "RobotoCondensed_ExtraBold28pt7b" },
  { &RobotoCondensed_ExtraBold29pt7b, 29, "RobotoCondensed_ExtraBold29pt7b" },
  { &RobotoCondensed_ExtraBold30pt7b, 30, "RobotoCondensed_ExtraBold30pt7b" },
  { &RobotoCondensed_ExtraBold31pt7b, 31, "RobotoCondensed_ExtraBold31pt7b" },
  { &RobotoCondensed_ExtraBold32pt7b, 32, "RobotoCondensed_ExtraBold32pt7b" },
  { &RobotoCondensed_ExtraBold33pt7b, 33, "RobotoCondensed_ExtraBold33pt7b" },
  { &RobotoCondensed_ExtraBold34pt7b, 34, "RobotoCondensed_ExtraBold34pt7b" },
  { &RobotoCondensed_ExtraBold35pt7b, 35, "RobotoCondensed_ExtraBold35pt7b" },
  { &RobotoCondensed_ExtraBold36pt7b, 36, "RobotoCondensed_ExtraBold36pt7b" },
  { &RobotoCondensed_ExtraBold37pt7b, 37, "RobotoCondensed_ExtraBold37pt7b" },
  { &RobotoCondensed_ExtraBold38pt7b, 38, "RobotoCondensed_ExtraBold38pt7b" },
  { &RobotoCondensed_ExtraBold39pt7b, 39, "RobotoCondensed_ExtraBold39pt7b" },
  { &RobotoCondensed_ExtraBold40pt7b, 40, "RobotoCondensed_ExtraBold40pt7b" },
  { &RobotoCondensed_ExtraBold41pt7b, 41, "RobotoCondensed_ExtraBold41pt7b" },
  { &RobotoCondensed_ExtraBold42pt7b, 42, "RobotoCondensed_ExtraBold42pt7b" },
  { &RobotoCondensed_ExtraBold43pt7b, 43, "RobotoCondensed_ExtraBold43pt7b" },
  { &RobotoCondensed_ExtraBold44pt7b, 44, "RobotoCondensed_ExtraBold44pt7b" },
  { &RobotoCondensed_ExtraBold45pt7b, 45, "RobotoCondensed_ExtraBold45pt7b" },
  { &RobotoCondensed_ExtraBold46pt7b, 46, "RobotoCondensed_ExtraBold46pt7b" },
  { &RobotoCondensed_ExtraBold47pt7b, 47, "RobotoCondensed_ExtraBold47pt7b" },
  { &RobotoCondensed_ExtraBold48pt7b, 48, "RobotoCondensed_ExtraBold48pt7b" },
  { &RobotoCondensed_ExtraBold49pt7b, 49, "RobotoCondensed_ExtraBold49pt7b" },
  { &RobotoCondensed_ExtraBold50pt7b, 50, "RobotoCondensed_ExtraBold50pt7b" },
  { &RobotoCondensed_ExtraBold51pt7b, 51, "RobotoCondensed_ExtraBold51pt7b" },
  { &RobotoCondensed_ExtraBold52pt7b, 52, "RobotoCondensed_ExtraBold52pt7b" },
  { &RobotoCondensed_ExtraBold53pt7b, 53, "RobotoCondensed_ExtraBold53pt7b" },
  { &RobotoCondensed_ExtraBold54pt7b, 54, "RobotoCondensed_ExtraBold54pt7b" },
  { &RobotoCondensed_ExtraBold55pt7b, 55, "RobotoCondensed_ExtraBold55pt7b" },
  { &RobotoCondensed_ExtraBold56pt7b, 56, "RobotoCondensed_ExtraBold56pt7b" },
  { &RobotoCondensed_ExtraBold57pt7b, 57, "RobotoCondensed_ExtraBold57pt7b" },
  { &RobotoCondensed_ExtraBold58pt7b, 58, "RobotoCondensed_ExtraBold58pt7b" },
  { &RobotoCondensed_ExtraBold59pt7b, 59, "RobotoCondensed_ExtraBold59pt7b" },
  { &RobotoCondensed_ExtraBold60pt7b, 60, "RobotoCondensed_ExtraBold60pt7b" },
  { &RobotoCondensed_ExtraBold61pt7b, 61, "RobotoCondensed_ExtraBold61pt7b" },
  { &RobotoCondensed_ExtraBold62pt7b, 62, "RobotoCondensed_ExtraBold62pt7b" },
  { &RobotoCondensed_ExtraBold63pt7b, 63, "RobotoCondensed_ExtraBold63pt7b" },
  { &RobotoCondensed_ExtraBold64pt7b, 64, "RobotoCondensed_ExtraBold64pt7b" },
  { &RobotoCondensed_ExtraBold65pt7b, 65, "RobotoCondensed_ExtraBold65pt7b" },
  { &RobotoCondensed_ExtraBold66pt7b, 66, "RobotoCondensed_ExtraBold66pt7b" },
  { &RobotoCondensed_ExtraBold67pt7b, 67, "RobotoCondensed_ExtraBold67pt7b" },
  { &RobotoCondensed_ExtraBold68pt7b, 68, "RobotoCondensed_ExtraBold68pt7b" },
  { &RobotoCondensed_ExtraBold69pt7b, 69, "RobotoCondensed_ExtraBold69pt7b" },
  { &RobotoCondensed_ExtraBold70pt7b, 70, "RobotoCondensed_ExtraBold70pt7b" },
  { &RobotoCondensed_ExtraBold71pt7b, 71, "RobotoCondensed_ExtraBold71pt7b" },
  { &RobotoCondensed_ExtraBold72pt7b, 72, "RobotoCondensed_ExtraBold72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
