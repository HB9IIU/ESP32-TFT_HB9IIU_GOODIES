#ifndef _ROBOTOCONDENSED_EXTRABOLD46PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x00, 0xF3, 0xE0, 0x0F, 0x9E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0,
  0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF8,
  0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x8F, 0x07, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE3, 0xC1, 0xF1,
  0xF1, 0xE0, 0xF8, 0xF9, 0xE0, 0x7C, 0x78, 0xF0, 0x3E, 0x3C, 0xF0, 0x0F,
  0xFE, 0xF8, 0x07, 0xFE, 0x78, 0x01, 0xFF, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x3F, 0xC0, 0x07, 0xBF, 0xF0, 0x07, 0x9F, 0xFC, 0x03, 0xDF,
  0x3E, 0x03, 0xCF, 0x8F, 0x03, 0xE7, 0x87, 0x81, 0xE3, 0xC3, 0xC1, 0xF1,
  0xE1, 0xE0, 0xF0, 0xF8, 0xF0, 0x70, 0x7C, 0x78, 0x18, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87,
  0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x3E, 0x0F, 0xFE, 0x1F, 0x0F, 0xFF, 0x9F, 0x87, 0xFF, 0xCF, 0xC7,
  0xF7, 0xF7, 0xE3, 0xFB, 0xFF, 0xF1, 0xF8, 0xFF, 0xF9, 0xFC, 0x3F, 0xF8,
  0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFD,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x40, 0x38, 0x0F, 0x03, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xE0, 0x1C, 0x00, 0x80, 0x40, 0x07, 0x00, 0x78, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x07, 0x80,
  0x70, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0xF8, 0xF1, 0xEF, 0xEF, 0x7E, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xF1, 0xF0, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x0C, 0x07, 0x00, 0x40, 0x40, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E,
  0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF,
  0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1,
  0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0xBF, 0x81,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7D, 0xFC, 0x03, 0xEF, 0xE0, 0x3E,
  0x7F, 0x01, 0xF3, 0xF8, 0x1F, 0x9F, 0xC0, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7C, 0x3F, 0x87, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xE0, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8,
  0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xF1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0xFF, 0x3F, 0x8F, 0xE7, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0x7F, 0x9F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x0F, 0x9F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x1F, 0x1F, 0xCF,
  0xEF, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x03, 0xF0, 0x3C, 0x3E,
  0x07, 0xFC, 0x3C, 0x3C, 0x0F, 0xFE, 0x3E, 0x7C, 0x1F, 0xFE, 0x1E, 0x78,
  0x3F, 0x3E, 0x1E, 0x78, 0x3E, 0x3E, 0x1E, 0xF8, 0x7C, 0x3E, 0x1E, 0xF8,
  0x7C, 0x3E, 0x1E, 0xF8, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x3E, 0x1E, 0xF0,
  0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0,
  0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x7C, 0x1E, 0xF0,
  0xF8, 0x7C, 0x3C, 0xF0, 0xF8, 0x7C, 0x3C, 0xF0, 0xFC, 0xFC, 0x7C, 0xF8,
  0x7F, 0xFF, 0xF8, 0xF8, 0x7F, 0xFF, 0xF0, 0x78, 0x3F, 0x9F, 0xE0, 0x7C,
  0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x00, 0x0F,
  0xF0, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0x9F, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB,
  0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC,
  0x1F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFE, 0x0F, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF,
  0x3F, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0xFF,
  0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80,
  0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x7F,
  0x00, 0xFE, 0xFF, 0x01, 0xFD, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0x9F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xEF, 0x83, 0xEF, 0xFF, 0xBF,
  0x1F, 0xBF, 0xFE, 0xFC, 0x7C, 0xFF, 0xFB, 0xF1, 0xF3, 0xFF, 0xE7, 0xC7,
  0xCF, 0xFF, 0x9F, 0xBF, 0x3F, 0xFE, 0x7E, 0xF8, 0xFF, 0xF8, 0xFB, 0xE7,
  0xFF, 0xE3, 0xFF, 0x9F, 0xFF, 0x8F, 0xFE, 0x7F, 0xFE, 0x3F, 0xF1, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0x87, 0xF8, 0x7F, 0xFE,
  0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83,
  0xF0, 0x7F, 0xFE, 0x07, 0xC1, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x7F,
  0xFE, 0xFC, 0x7F, 0xFE, 0x7C, 0x7F, 0xFE, 0x7E, 0x7F, 0xFE, 0x3E, 0x7F,
  0xFE, 0x3F, 0x7F, 0xFE, 0x1F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF,
  0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0x7F,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03,
  0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F,
  0x3F, 0xC1, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x1F, 0xC7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0, 0x7F,
  0x7F, 0x0F, 0xF0, 0x7E, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF8, 0xFE,
  0x7F, 0x0F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFE,
  0x3F, 0x9F, 0xF8, 0xFC, 0x3F, 0x9F, 0xF8, 0xFC, 0x3F, 0x9F, 0xFD, 0xFC,
  0x3F, 0x9F, 0xFD, 0xFC, 0x1F, 0xBF, 0xFD, 0xFC, 0x1F, 0xBF, 0xFD, 0xFC,
  0x1F, 0xFF, 0x7D, 0xF8, 0x1F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8,
  0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80,
  0x3F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0x7E, 0x00, 0x0F,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x1F,
  0x9F, 0xC3, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xF9, 0xFC, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFB, 0xF8, 0x3E, 0x7F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x3F, 0x0F, 0xEF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xDF, 0xE3, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x7E, 0x7F, 0x1F, 0xF7, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x07, 0xE7,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x71, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0xFF, 0xBF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3E, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x08, 0x0F, 0xF0, 0xF3, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x3F, 0x0F, 0xEF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x07, 0x81, 0xF8,
  0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xE3, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE1, 0xFF, 0xFE, 0x1F, 0xEF, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF8, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x3E, 0x07, 0xC3,
  0xFB, 0xFC, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xE1, 0xFE, 0x3F, 0xFF, 0x87,
  0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83,
  0xF0, 0x7F, 0xFC, 0x3E, 0x1F, 0xDF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x87, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFE,
  0x7E, 0x1F, 0xDF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xBF, 0xC7, 0xF3, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xFF, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xF7, 0xF0, 0x7E, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE1, 0xFD,
  0xF8, 0x7F, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFB, 0xF8, 0x7C, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xFC, 0x1F, 0xDF, 0x80,
  0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x1F, 0x07, 0xFF,
  0x83, 0xE1, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8,
  0xFC, 0xFC, 0x7F, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF3, 0xFE, 0x7E, 0x7E,
  0x7F, 0xDF, 0x87, 0xEF, 0xFB, 0xF0, 0xFD, 0xFF, 0x7E, 0x1F, 0xFD, 0xEF,
  0xC3, 0xFF, 0xBF, 0xF8, 0x7F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F,
  0xC3, 0xF9, 0xFC, 0x3F, 0xBF, 0x83, 0xFB, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFB, 0xF0, 0x3F, 0xBF, 0x83, 0xFB, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFC, 0xFE, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x83,
  0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x40, 0x3C, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x7F, 0x8F, 0xE1, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0F, 0x01, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x07, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFE, 0x0F, 0x81, 0xE0, 0x30, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFB, 0xF1, 0xFF, 0xDF, 0x07, 0xFC, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 33, 12, 2, -33 },
  { 34, 12, 13, 15, 1, -35 },
  { 54, 21, 33, 24, 1, -33 },
  { 141, 19, 42, 23, 2, -38 },
  { 241, 25, 33, 29, 2, -33 },
  { 345, 25, 33, 27, 1, -33 },
  { 449, 5, 13, 7, 1, -35 },
  { 458, 11, 46, 15, 3, -36 },
  { 522, 12, 46, 15, 1, -36 },
  { 591, 20, 20, 21, 1, -33 },
  { 641, 19, 24, 22, 1, -27 },
  { 698, 8, 14, 12, 1, -6 },
  { 712, 12, 6, 18, 3, -17 },
  { 721, 8, 7, 14, 3, -7 },
  { 728, 14, 36, 15, 0, -33 },
  { 791, 19, 33, 23, 2, -33 },
  { 870, 12, 33, 23, 4, -33 },
  { 920, 21, 33, 23, 1, -33 },
  { 1007, 20, 33, 23, 1, -33 },
  { 1090, 21, 33, 23, 1, -33 },
  { 1177, 19, 33, 23, 2, -33 },
  { 1256, 20, 33, 23, 2, -33 },
  { 1339, 20, 33, 23, 1, -33 },
  { 1422, 19, 33, 23, 2, -33 },
  { 1501, 19, 33, 23, 2, -33 },
  { 1580, 8, 25, 13, 3, -25 },
  { 1605, 9, 33, 12, 1, -25 },
  { 1643, 17, 22, 21, 1, -25 },
  { 1690, 17, 16, 23, 3, -22 },
  { 1724, 16, 22, 21, 3, -25 },
  { 1768, 18, 33, 21, 1, -33 },
  { 1843, 32, 42, 35, 2, -32 },
  { 2011, 27, 33, 28, 0, -33 },
  { 2123, 22, 33, 26, 2, -33 },
  { 2214, 23, 33, 26, 2, -33 },
  { 2309, 22, 33, 26, 2, -33 },
  { 2400, 19, 33, 23, 2, -33 },
  { 2479, 19, 33, 22, 2, -33 },
  { 2558, 23, 33, 27, 2, -33 },
  { 2653, 24, 33, 28, 2, -33 },
  { 2752, 7, 33, 13, 3, -33 },
  { 2781, 19, 33, 23, 1, -33 },
  { 2860, 24, 33, 26, 2, -33 },
  { 2959, 19, 33, 22, 2, -33 },
  { 3038, 30, 33, 35, 2, -33 },
  { 3162, 24, 33, 28, 2, -33 },
  { 3261, 24, 33, 28, 2, -33 },
  { 3360, 23, 33, 26, 2, -33 },
  { 3455, 24, 39, 28, 2, -33 },
  { 3572, 23, 33, 26, 2, -33 },
  { 3667, 21, 33, 25, 2, -33 },
  { 3754, 23, 33, 25, 1, -33 },
  { 3849, 22, 33, 26, 2, -33 },
  { 3940, 26, 33, 27, 0, -33 },
  { 4048, 32, 33, 34, 1, -33 },
  { 4180, 24, 33, 26, 1, -33 },
  { 4279, 25, 33, 25, 0, -33 },
  { 4383, 22, 33, 24, 1, -33 },
  { 4474, 9, 46, 12, 2, -38 },
  { 4526, 19, 36, 18, 0, -33 },
  { 4612, 9, 46, 12, 1, -38 },
  { 4664, 16, 16, 18, 1, -33 },
  { 4696, 18, 5, 18, 0, 0 },
  { 4708, 12, 7, 15, 1, -35 },
  { 4719, 19, 24, 22, 1, -24 },
  { 4776, 19, 35, 23, 2, -35 },
  { 4860, 19, 24, 21, 1, -24 },
  { 4917, 20, 35, 23, 1, -35 },
  { 5005, 19, 24, 22, 2, -24 },
  { 5062, 14, 35, 15, 1, -35 },
  { 5124, 20, 33, 23, 1, -24 },
  { 5207, 19, 35, 23, 2, -35 },
  { 5291, 8, 34, 12, 2, -34 },
  { 5325, 11, 43, 12, -1, -34 },
  { 5385, 20, 35, 22, 2, -35 },
  { 5473, 7, 35, 12, 2, -35 },
  { 5504, 30, 24, 34, 2, -24 },
  { 5594, 19, 24, 23, 2, -24 },
  { 5651, 20, 24, 23, 1, -24 },
  { 5711, 19, 33, 23, 2, -24 },
  { 5790, 20, 33, 23, 1, -24 },
  { 5873, 13, 24, 16, 2, -24 },
  { 5912, 18, 24, 21, 1, -24 },
  { 5966, 12, 30, 14, 1, -30 },
  { 6011, 19, 24, 23, 2, -24 },
  { 6068, 20, 24, 21, 0, -24 },
  { 6128, 27, 24, 29, 1, -24 },
  { 6209, 20, 24, 21, 1, -24 },
  { 6269, 21, 33, 21, 0, -24 },
  { 6356, 17, 24, 21, 2, -24 },
  { 6407, 11, 44, 14, 1, -36 },
  { 6468, 4, 39, 12, 4, -33 },
  { 6488, 11, 44, 14, 1, -36 },
  { 6549, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_EXTRABOLD46PT7B_H_
