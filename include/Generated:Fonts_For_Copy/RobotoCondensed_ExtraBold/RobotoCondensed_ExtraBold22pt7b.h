#ifndef _ROBOTOCONDENSED_EXTRABOLD22PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE6, 0x66, 0x60, 0x06, 0xF6, 0xEF, 0xBE, 0xFB,
  0xEF, 0x30, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x3F, 0xFF, 0xFC, 0xD8,
  0x36, 0x0D, 0x8F, 0xFB, 0xFE, 0x66, 0x19, 0x86, 0xC1, 0xB0, 0x0C, 0x06,
  0x07, 0x8F, 0xE7, 0xFB, 0x9F, 0xCE, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0,
  0x3F, 0x1F, 0x8F, 0xFF, 0x7F, 0x1F, 0x03, 0x01, 0x80, 0x78, 0x0F, 0xC0,
  0xCC, 0xCC, 0xD8, 0xCD, 0x8F, 0xF0, 0x7B, 0x00, 0x60, 0x06, 0x00, 0xDE,
  0x0D, 0xF1, 0xB3, 0x1B, 0x33, 0x33, 0x11, 0xF0, 0x1E, 0x1E, 0x07, 0xE1,
  0xFC, 0x39, 0x87, 0x30, 0xEE, 0x1F, 0x81, 0xE0, 0x7C, 0xFF, 0xDF, 0xBF,
  0x73, 0xEE, 0x7D, 0xFF, 0x9F, 0xF1, 0xEF, 0xFF, 0xF0, 0x08, 0x63, 0x8C,
  0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x71, 0xC3, 0x0E,
  0x18, 0x20, 0x86, 0x38, 0xC7, 0x18, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x33, 0x99, 0xCC, 0x40, 0x0C, 0x03, 0x00, 0xC1, 0xB7, 0xFF, 0xC7, 0x81,
  0xE0, 0xEC, 0x73, 0x80, 0x40, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF,
  0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x33, 0x37, 0x76, 0x60, 0xFF, 0xFE,
  0xFF, 0x70, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3,
  0x86, 0x0C, 0x18, 0x70, 0xC0, 0x1E, 0x3F, 0x9F, 0xDE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3B, 0xF9, 0xFC, 0x3C, 0x0C,
  0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E,
  0x3F, 0xBF, 0xFC, 0x7E, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x87, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFC, 0x70, 0x38, 0x1C,
  0x7C, 0x3C, 0x1F, 0x03, 0xC0, 0xFC, 0x7E, 0x3F, 0xFD, 0xFC, 0x7C, 0x07,
  0x07, 0x83, 0xC3, 0xE1, 0xF1, 0xF8, 0xDC, 0xEE, 0x77, 0x73, 0xBF, 0xFF,
  0xFF, 0xF8, 0x38, 0x1C, 0x0E, 0x7F, 0xBF, 0xDF, 0xEE, 0x06, 0x07, 0xF3,
  0xFD, 0xEF, 0x03, 0x81, 0xC0, 0xFC, 0x7E, 0x3F, 0xFD, 0xFC, 0x7C, 0x0E,
  0x0F, 0x0F, 0x8F, 0x07, 0x07, 0xF3, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7F, 0x3B, 0xFD, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x3E,
  0x3F, 0x9F, 0xFE, 0x7F, 0x3F, 0x9D, 0xFC, 0x7C, 0x7F, 0x7B, 0xF8, 0xFC,
  0x7F, 0x3F, 0xFD, 0xFC, 0x7C, 0x1C, 0x3F, 0x9F, 0xDE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xFF, 0xBF, 0xCE, 0xE0, 0xF0, 0x71, 0xF0, 0xF8, 0x70, 0xFF,
  0x70, 0x00, 0x00, 0x07, 0xF7, 0xFF, 0x60, 0x00, 0x00, 0x07, 0x77, 0x6E,
  0xEC, 0x01, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8,
  0x7E, 0x1F, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0x80, 0x3E, 0x3F, 0x9F, 0xFE,
  0x70, 0x38, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x38, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC,
  0x78, 0xF9, 0xF9, 0xE3, 0x33, 0xCE, 0x67, 0x98, 0xCF, 0x33, 0x9E, 0x67,
  0x3C, 0xCE, 0xD9, 0xFF, 0xB1, 0xDE, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x3C, 0xE1, 0xC7, 0x0F, 0xF8, 0x7F, 0xE7,
  0xFF, 0x38, 0x39, 0xC1, 0xFE, 0x0F, 0xFF, 0x3F, 0xEF, 0xFF, 0xC7, 0xF1,
  0xFC, 0x7F, 0x3F, 0xFE, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF,
  0xFB, 0xFC, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xC1, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0x1E, 0xFF, 0x8F, 0xF0, 0xF8,
  0xFE, 0x3F, 0xEF, 0xFB, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF3, 0xFF, 0xEF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFE, 0xFF,
  0x7F, 0xBC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x07, 0xF9, 0xFF,
  0x78, 0xFF, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF8,
  0x7F, 0x0E, 0xFF, 0xCF, 0xF0, 0xFC, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xCF, 0x73, 0x9F, 0xE3, 0xF0, 0x78, 0xF1, 0xFE, 0x7B, 0xCF,
  0x7B, 0xCF, 0x79, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xE3, 0xDE, 0x7B,
  0xCF, 0x3D, 0xE7, 0xBC, 0x7F, 0x8F, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x3F, 0xF6, 0x7F, 0xEE, 0xFF, 0xDD, 0xBF, 0x9F, 0x7F, 0xBE, 0xFF, 0x79,
  0xFE, 0xF3, 0xFC, 0xE7, 0xF9, 0xCF, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFF, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x1E, 0xFF, 0x8F,
  0xF0, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0xFE, 0xFF, 0x9F, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x1E, 0xFF, 0x8F, 0xF0, 0xFE, 0x01, 0xE0,
  0x1C, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xBC,
  0x77, 0xFE, 0xFF, 0x9F, 0xE3, 0xDE, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0x77,
  0x8F, 0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xE1, 0xFC, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3F, 0x87, 0xE1, 0xFF, 0xF7, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1C, 0xFF, 0x9F, 0xE0, 0xF8, 0xF0, 0x73, 0x83, 0x9C, 0x3C, 0xF1, 0xE7,
  0x8E, 0x1C, 0x70, 0xE7, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x71, 0xC7, 0x73, 0xCF, 0x73,
  0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x7B, 0xEE, 0x3B, 0xEE, 0x3F, 0xEE, 0x3F,
  0xFE, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E,
  0x3C, 0x1E, 0x38, 0x70, 0xF7, 0x8E, 0x39, 0xE3, 0xDC, 0x3D, 0xC1, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x39, 0xC7, 0x9E,
  0x78, 0xEF, 0x0F, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xDC,
  0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xFF, 0xF0, 0x78,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF, 0xFF, 0xFC, 0x1C, 0x1C, 0x3C, 0x36,
  0x36, 0x76, 0x67, 0x63, 0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0x8E, 0x3E, 0x3F,
  0xBF, 0xDC, 0xE0, 0x71, 0xFB, 0xFD, 0xCE, 0xE7, 0x7F, 0xBF, 0xCF, 0xF0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFE, 0xEE, 0x00, 0x3C, 0x3F, 0xBF, 0xDC,
  0xEE, 0x7F, 0x03, 0x81, 0xC0, 0xE7, 0x7F, 0x9F, 0xC7, 0xC0, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3B, 0xDD, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0xFE, 0xFF, 0x3B, 0x80, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE1, 0x7F, 0x9F, 0xE7, 0xC0, 0x0E, 0x7C, 0xF9, 0xC3,
  0x9F, 0xFF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x3B,
  0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xE7,
  0x70, 0x3B, 0xFD, 0xFC, 0x7C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73,
  0xFD, 0xFF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0x80, 0xEF, 0x60, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x38, 0xF3, 0x80,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3B, 0xEF, 0xBC,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x39, 0xEE, 0x73, 0xBC, 0xEE, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x3B, 0xCE, 0x73, 0x9E, 0xE3, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7,
  0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79,
  0xF9, 0xE7, 0xEE, 0x7F, 0xBF, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xFF, 0xDF, 0xC7, 0xC0, 0xEE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xDD, 0xCE, 0x07, 0x03, 0x81, 0xC0,
  0x7B, 0xFF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF,
  0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0x3C, 0xFF, 0xE7, 0xE7, 0xF0, 0x7C, 0x3F, 0x0F, 0xE7,
  0xE7, 0xFF, 0x3C, 0x38, 0xE3, 0xBF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3C, 0xF1, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xFF, 0xDF, 0xEF, 0x70, 0xF3, 0xDC, 0xE7, 0x39, 0xCE, 0x77, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0xF3, 0x3B, 0xB9, 0xDD,
  0xEE, 0xEF, 0x77, 0x7B, 0xBB, 0xD8, 0xFF, 0xC7, 0xBE, 0x3C, 0xF1, 0xE7,
  0x8F, 0x38, 0x39, 0xC0, 0x73, 0x9C, 0xE3, 0xF8, 0xFC, 0x3F, 0x07, 0x81,
  0xE0, 0xFC, 0x3F, 0x1F, 0xE7, 0x39, 0xCF, 0xF3, 0xDC, 0xE7, 0x39, 0xCE,
  0x7F, 0x8F, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x1F,
  0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70,
  0xFF, 0xFF, 0xFF, 0x11, 0xDC, 0xE7, 0x39, 0xCE, 0x77, 0x39, 0xC7, 0x39,
  0xCE, 0x73, 0x9C, 0x71, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x86, 0x38,
  0xC7, 0x39, 0xCE, 0x73, 0x8E, 0x77, 0x39, 0xCE, 0x73, 0x39, 0xC8, 0x00,
  0x38, 0xDF, 0x7F, 0xFF, 0xBE, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 6, 6, 7, 0, -17 },
  { 14, 10, 16, 11, 1, -16 },
  { 34, 9, 20, 11, 1, -18 },
  { 57, 12, 16, 14, 1, -16 },
  { 81, 11, 16, 13, 1, -16 },
  { 103, 2, 6, 3, 1, -17 },
  { 105, 6, 22, 7, 1, -17 },
  { 122, 5, 22, 7, 1, -17 },
  { 136, 10, 10, 10, 0, -16 },
  { 149, 9, 11, 10, 1, -13 },
  { 162, 4, 7, 6, 0, -3 },
  { 166, 5, 3, 9, 2, -8 },
  { 168, 4, 3, 7, 1, -3 },
  { 170, 7, 17, 7, 0, -16 },
  { 185, 9, 16, 11, 1, -16 },
  { 203, 6, 16, 11, 2, -16 },
  { 215, 9, 16, 11, 1, -16 },
  { 233, 9, 16, 11, 1, -16 },
  { 251, 9, 16, 11, 1, -16 },
  { 269, 9, 16, 11, 1, -16 },
  { 287, 9, 16, 11, 1, -16 },
  { 305, 9, 16, 11, 1, -16 },
  { 323, 9, 16, 11, 1, -16 },
  { 341, 9, 16, 11, 1, -16 },
  { 359, 4, 12, 6, 1, -12 },
  { 365, 4, 16, 6, 1, -12 },
  { 373, 8, 11, 10, 1, -12 },
  { 384, 9, 8, 11, 1, -11 },
  { 393, 8, 11, 10, 1, -12 },
  { 404, 9, 16, 10, 0, -16 },
  { 422, 15, 20, 17, 1, -15 },
  { 460, 13, 16, 13, 0, -16 },
  { 486, 10, 16, 12, 1, -16 },
  { 506, 11, 16, 13, 1, -16 },
  { 528, 10, 16, 12, 1, -16 },
  { 548, 9, 16, 11, 1, -16 },
  { 566, 9, 16, 10, 1, -16 },
  { 584, 11, 16, 13, 1, -16 },
  { 606, 11, 16, 13, 1, -16 },
  { 628, 4, 16, 6, 1, -16 },
  { 636, 10, 16, 11, 0, -16 },
  { 656, 11, 16, 12, 1, -16 },
  { 678, 9, 16, 11, 1, -16 },
  { 696, 15, 16, 17, 1, -16 },
  { 726, 11, 16, 13, 1, -16 },
  { 748, 11, 16, 13, 1, -16 },
  { 770, 11, 16, 13, 1, -16 },
  { 792, 11, 19, 13, 1, -16 },
  { 819, 11, 16, 12, 1, -16 },
  { 841, 10, 16, 12, 1, -16 },
  { 861, 11, 16, 12, 1, -16 },
  { 883, 11, 16, 13, 1, -16 },
  { 905, 13, 16, 13, 0, -16 },
  { 931, 16, 16, 16, 0, -16 },
  { 963, 12, 16, 12, 0, -16 },
  { 987, 12, 16, 12, 0, -16 },
  { 1011, 10, 16, 12, 1, -16 },
  { 1031, 4, 22, 6, 1, -18 },
  { 1042, 9, 17, 8, 0, -16 },
  { 1062, 5, 22, 6, 0, -18 },
  { 1076, 8, 8, 9, 0, -16 },
  { 1084, 9, 3, 9, 0, 0 },
  { 1088, 5, 3, 7, 1, -16 },
  { 1090, 9, 12, 10, 1, -12 },
  { 1104, 9, 17, 11, 1, -17 },
  { 1124, 9, 12, 10, 1, -12 },
  { 1138, 9, 17, 11, 1, -17 },
  { 1158, 9, 12, 11, 1, -12 },
  { 1172, 7, 17, 7, 0, -17 },
  { 1187, 9, 16, 11, 1, -12 },
  { 1205, 9, 17, 11, 1, -17 },
  { 1225, 4, 16, 6, 1, -16 },
  { 1233, 6, 20, 6, -1, -16 },
  { 1248, 10, 17, 11, 1, -17 },
  { 1270, 3, 17, 6, 1, -17 },
  { 1277, 14, 12, 16, 1, -12 },
  { 1298, 9, 12, 11, 1, -12 },
  { 1312, 9, 12, 11, 1, -12 },
  { 1326, 9, 16, 11, 1, -12 },
  { 1344, 9, 16, 11, 1, -12 },
  { 1362, 6, 12, 7, 1, -12 },
  { 1371, 8, 12, 10, 1, -12 },
  { 1383, 6, 15, 7, 0, -15 },
  { 1395, 9, 12, 11, 1, -12 },
  { 1409, 10, 12, 10, 0, -12 },
  { 1424, 13, 12, 14, 0, -12 },
  { 1444, 10, 12, 10, 0, -12 },
  { 1459, 10, 16, 10, 0, -12 },
  { 1479, 8, 12, 10, 1, -12 },
  { 1491, 5, 21, 7, 1, -17 },
  { 1505, 2, 19, 6, 2, -16 },
  { 1510, 5, 21, 7, 1, -17 },
  { 1524, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_EXTRABOLD22PT7B_H_
