#ifndef _ROBOTOCONDENSED_EXTRABOLD13PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFF, 0xFB, 0x38, 0xA2, 0x9F, 0x2B, 0xF3, 0x9C,
  0x50, 0x23, 0xBF, 0xBC, 0x38, 0x7B, 0xFB, 0x88, 0xE1, 0x52, 0xA7, 0x81,
  0x05, 0x9F, 0xAF, 0x0C, 0x38, 0xF1, 0xA3, 0xC3, 0x6F, 0xF7, 0x3E, 0x7E,
  0xFF, 0x2B, 0x69, 0x24, 0x9B, 0x22, 0x84, 0x62, 0x23, 0x33, 0x22, 0x64,
  0x80, 0x30, 0x4F, 0xCC, 0x79, 0x20, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x00,
  0x6D, 0x60, 0xFC, 0xF0, 0x33, 0x22, 0x66, 0x44, 0xC8, 0x77, 0xF7, 0xBD,
  0xEF, 0x7F, 0x70, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0x39, 0xFC, 0xC3, 0x18,
  0xC3, 0x1F, 0x7C, 0x39, 0xFC, 0xCF, 0x38, 0x3C, 0xDF, 0x78, 0x18, 0x63,
  0x8E, 0x79, 0xFF, 0xC6, 0x18, 0xFF, 0xF1, 0xEF, 0x8F, 0x7F, 0x70, 0x33,
  0xB1, 0xEF, 0xEF, 0x7F, 0x70, 0xFF, 0xF0, 0xC6, 0x18, 0x43, 0x0C, 0x60,
  0x77, 0xF7, 0xFF, 0x6F, 0x7F, 0x70, 0x77, 0xF7, 0xBF, 0xFC, 0x6E, 0x60,
  0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x09, 0xF9, 0xC3, 0x84, 0xFF, 0xC0,
  0x0F, 0xFC, 0x8E, 0x77, 0xE8, 0x7B, 0xF6, 0x33, 0x18, 0x06, 0x30, 0x1E,
  0x18, 0x98, 0x29, 0xD5, 0xAA, 0x97, 0x4A, 0xAD, 0x5B, 0x20, 0x08, 0x83,
  0xC0, 0x18, 0x18, 0x3C, 0x3C, 0x2C, 0x7E, 0x7E, 0x66, 0xC7, 0xFB, 0xEC,
  0xF6, 0xFB, 0x3C, 0xFF, 0xF8, 0x7B, 0xFC, 0xF0, 0xC3, 0x0C, 0xFF, 0x78,
  0xF3, 0xEC, 0xF3, 0xCF, 0x3C, 0xFE, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x1F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x18, 0xC0, 0x7B, 0xFC, 0xF0, 0xC3, 0x7C,
  0xFF, 0x78, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF, 0xFF, 0xC0,
  0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0xDE, 0x78, 0xCF, 0x6F, 0xBC, 0xF3, 0xED,
  0xB7, 0xCC, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xC7, 0xE7, 0xE7, 0xE7,
  0xEF, 0xFF, 0xFB, 0xDB, 0xDB, 0xCF, 0x3E, 0xFB, 0xFF, 0x7D, 0xF3, 0xCC,
  0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xFB, 0xFC, 0xF3, 0xFF, 0xEC,
  0x30, 0xC0, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0x30, 0x40, 0xFB,
  0xEC, 0xF3, 0xFB, 0xCD, 0xB6, 0xCC, 0x38, 0xF9, 0x9B, 0x83, 0xC1, 0xB9,
  0xBE, 0x3C, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xC6, 0xCD, 0x9B, 0x66, 0xC7, 0x8F, 0x1C,
  0x18, 0xCD, 0xA6, 0xDB, 0x6F, 0xB7, 0xFB, 0xF9, 0xDC, 0x6E, 0x33, 0x00,
  0xE6, 0xD9, 0xB1, 0xC3, 0x87, 0x1B, 0x36, 0xE6, 0xC6, 0xD9, 0xB1, 0x63,
  0x87, 0x06, 0x0C, 0x18, 0xFF, 0xF8, 0x30, 0xC3, 0x86, 0x18, 0x3F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC6, 0x18, 0xC6, 0x18, 0xC6, 0x18, 0xC0, 0xED,
  0xB6, 0xDB, 0x6D, 0xBE, 0x23, 0x94, 0xAD, 0x80, 0xFF, 0xC0, 0x62, 0x79,
  0xE0, 0xDF, 0xCF, 0xF6, 0xC0, 0xC6, 0x31, 0xEF, 0xEF, 0x7B, 0xFD, 0x80,
  0x79, 0xEC, 0xF0, 0xCD, 0xE7, 0x80, 0x0C, 0x30, 0xDF, 0x7F, 0x3C, 0xF3,
  0x7D, 0xF0, 0x39, 0xF4, 0xFF, 0x41, 0xE3, 0x80, 0x37, 0x6F, 0x66, 0x66,
  0x66, 0x7D, 0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x7D, 0xE0, 0xC6, 0x31, 0xEF,
  0xEF, 0x7B, 0xDE, 0xC0, 0xF3, 0xFF, 0xF0, 0x6C, 0x36, 0xDB, 0x6D, 0xFC,
  0xC6, 0x31, 0xBF, 0x73, 0xDE, 0xFE, 0xC0, 0xFF, 0xFF, 0xF0, 0xB6, 0xFF,
  0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xB7, 0xF7, 0xBD, 0xEF, 0x60, 0x39, 0xFC,
  0xF3, 0xCD, 0xF3, 0x80, 0xB7, 0xF7, 0xBD, 0xFF, 0xD8, 0xC6, 0x00, 0x7D,
  0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x0C, 0x30, 0xBF, 0x6D, 0xB0, 0x7B, 0xD8,
  0xF1, 0xED, 0xE0, 0x66, 0xF6, 0x66, 0x67, 0x70, 0xDE, 0xF7, 0xBD, 0xFF,
  0xE0, 0xCD, 0x67, 0x9E, 0x78, 0xC3, 0x00, 0xDB, 0xDB, 0x5A, 0x7E, 0x7E,
  0x76, 0x66, 0xC9, 0xE7, 0x8C, 0x79, 0xEC, 0xC0, 0xCF, 0x67, 0x9E, 0x78,
  0xC3, 0x0C, 0x61, 0x80, 0x7B, 0xC6, 0x66, 0x3F, 0xE0, 0x2D, 0xB6, 0xF3,
  0x6D, 0x90, 0xFF, 0xE0, 0x44, 0x66, 0x66, 0x36, 0x66, 0x44, 0xEF, 0xE9,
  0x80,
};

const GFXglyph RobotoCondensed_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 4, 0, -10 },
  { 6, 6, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 8, 1, -9 },
  { 28, 7, 9, 8, 0, -9 },
  { 36, 2, 4, 2, 0, -10 },
  { 37, 3, 13, 4, 1, -10 },
  { 42, 4, 13, 4, 0, -10 },
  { 49, 6, 6, 6, 0, -9 },
  { 54, 6, 7, 6, 0, -7 },
  { 60, 3, 4, 3, 0, -2 },
  { 62, 3, 2, 5, 1, -5 },
  { 63, 2, 2, 4, 1, -2 },
  { 64, 4, 10, 4, 0, -9 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 4, 9, 7, 1, -9 },
  { 80, 6, 9, 7, 0, -9 },
  { 87, 6, 9, 7, 0, -9 },
  { 94, 6, 9, 7, 0, -9 },
  { 101, 5, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 6, 9, 7, 0, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 5, 9, 7, 1, -9 },
  { 132, 2, 7, 4, 1, -7 },
  { 134, 3, 9, 3, 0, -7 },
  { 138, 5, 6, 6, 0, -7 },
  { 142, 5, 6, 7, 1, -7 },
  { 146, 4, 6, 6, 1, -7 },
  { 149, 5, 9, 6, 0, -9 },
  { 155, 9, 12, 10, 0, -9 },
  { 169, 8, 9, 8, 0, -9 },
  { 178, 6, 9, 7, 1, -9 },
  { 185, 6, 9, 7, 1, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 5, 9, 6, 1, -9 },
  { 205, 5, 9, 6, 1, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 2, 9, 4, 1, -9 },
  { 228, 6, 9, 6, 0, -9 },
  { 235, 6, 9, 7, 1, -9 },
  { 242, 5, 9, 6, 1, -9 },
  { 248, 8, 9, 10, 1, -9 },
  { 257, 6, 9, 8, 1, -9 },
  { 264, 6, 9, 8, 1, -9 },
  { 271, 6, 9, 7, 1, -9 },
  { 278, 6, 11, 8, 1, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 7, 9, 7, 0, -9 },
  { 310, 6, 9, 7, 1, -9 },
  { 317, 7, 9, 8, 0, -9 },
  { 325, 9, 9, 10, 0, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 7, 9, 7, 0, -9 },
  { 352, 7, 9, 7, 0, -9 },
  { 360, 2, 13, 3, 1, -11 },
  { 364, 5, 10, 5, 0, -9 },
  { 371, 3, 13, 3, 0, -11 },
  { 376, 5, 5, 5, 0, -9 },
  { 380, 5, 2, 5, 0, 0 },
  { 382, 4, 2, 4, 0, -10 },
  { 383, 6, 7, 6, 0, -7 },
  { 389, 5, 10, 6, 1, -10 },
  { 396, 6, 7, 6, 0, -7 },
  { 402, 6, 10, 6, 0, -10 },
  { 410, 6, 7, 6, 0, -7 },
  { 416, 4, 10, 4, 0, -10 },
  { 421, 6, 10, 7, 0, -7 },
  { 429, 5, 10, 6, 1, -10 },
  { 436, 2, 10, 3, 1, -10 },
  { 439, 3, 13, 3, 0, -10 },
  { 444, 5, 10, 6, 1, -10 },
  { 451, 2, 10, 3, 1, -10 },
  { 454, 8, 7, 10, 1, -7 },
  { 461, 5, 7, 6, 1, -7 },
  { 466, 6, 7, 6, 0, -7 },
  { 472, 5, 10, 6, 1, -7 },
  { 479, 6, 10, 6, 0, -7 },
  { 487, 3, 7, 4, 1, -7 },
  { 490, 5, 7, 6, 0, -7 },
  { 495, 4, 9, 4, 0, -9 },
  { 500, 5, 7, 6, 1, -7 },
  { 505, 6, 7, 6, 0, -7 },
  { 511, 8, 7, 8, 0, -7 },
  { 518, 6, 7, 6, 0, -7 },
  { 524, 6, 10, 6, 0, -7 },
  { 532, 5, 7, 6, 0, -7 },
  { 537, 3, 12, 4, 0, -10 },
  { 542, 1, 11, 3, 1, -9 },
  { 544, 4, 12, 4, 0, -10 },
  { 550, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_EXTRABOLD13PT7B_H_
