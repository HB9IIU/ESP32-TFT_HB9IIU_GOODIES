#ifndef _ROBOTOCONDENSED_EXTRABOLD15PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDD, 0xDD, 0x14, 0x28, 0xD3, 0xF3, 0xC5, 0x8A,
  0x7F, 0x28, 0x51, 0xA0, 0x10, 0x47, 0xBF, 0xCF, 0x0E, 0x1E, 0x1F, 0x3C,
  0xFF, 0x78, 0x80, 0xE0, 0xB4, 0xB4, 0xBC, 0xE8, 0x18, 0x16, 0x2F, 0x2B,
  0x4F, 0x06, 0x38, 0x1E, 0x1B, 0x0D, 0x83, 0x81, 0xC1, 0xEC, 0xDE, 0x6E,
  0x3F, 0x0E, 0xC0, 0xFF, 0x2D, 0xED, 0xB6, 0xDB, 0x66, 0xC8, 0x44, 0x62,
  0x33, 0x33, 0x33, 0x32, 0x64, 0x40, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x82,
  0x00, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x6D, 0xB4, 0xFF, 0xF0,
  0x10, 0x8C, 0x62, 0x11, 0x8C, 0x42, 0x31, 0x80, 0x73, 0xEC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0xE7, 0x00, 0x1F, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x3C,
  0xF9, 0xBB, 0x30, 0xE1, 0x86, 0x1C, 0x70, 0xFD, 0xF8, 0x3C, 0xFD, 0x98,
  0x31, 0xC3, 0x83, 0x83, 0xE6, 0xFC, 0xF0, 0x0C, 0x38, 0x71, 0xE3, 0xCD,
  0x9B, 0x7F, 0x7E, 0x18, 0x30, 0xFF, 0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0xCF,
  0xE7, 0x80, 0x39, 0xEE, 0x30, 0xFB, 0xFC, 0xF3, 0xCF, 0xF7, 0x80, 0xFF,
  0xFC, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC0, 0x7B, 0xED, 0xF7,
  0xF9, 0xEC, 0xF3, 0xCF, 0xF7, 0x80, 0x73, 0xED, 0xF3, 0xCF, 0xF7, 0xC7,
  0x19, 0xE6, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x6D, 0x00, 0x04, 0x77,
  0xB8, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x87, 0x1E, 0x37, 0xF2,
  0x00, 0x79, 0xFE, 0xC3, 0x1C, 0x63, 0x0C, 0x00, 0xC3, 0x00, 0x0F, 0x07,
  0x18, 0x81, 0x33, 0xB4, 0xD6, 0xB2, 0x56, 0xCA, 0xDB, 0x5B, 0x49, 0xB9,
  0x80, 0x18, 0x81, 0xF0, 0x1C, 0x0E, 0x07, 0x06, 0xC3, 0x61, 0xB1, 0xDC,
  0xFE, 0x7F, 0x31, 0xB8, 0xE0, 0xF9, 0xFB, 0x3E, 0x7F, 0xDF, 0xB3, 0xE7,
  0xCF, 0xFB, 0xE0, 0x79, 0xFB, 0x1E, 0x3C, 0x18, 0x30, 0x63, 0xC7, 0xF9,
  0xE0, 0xF9, 0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0xCD, 0xFB, 0xE0, 0xFF,
  0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3,
  0xEF, 0xB0, 0xC3, 0x0C, 0x00, 0x7D, 0xFF, 0x1E, 0x3C, 0x1B, 0xF7, 0xE3,
  0xC7, 0xFC, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F,
  0x18, 0xFF, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xEC,
  0xF8, 0xE0, 0xCF, 0x9B, 0x76, 0xCF, 0x9F, 0x3E, 0x6E, 0xCD, 0x9F, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE3, 0xF8, 0xFE,
  0x3F, 0xCF, 0xF7, 0xFD, 0xFD, 0x7F, 0x77, 0xDD, 0xF7, 0x7C, 0xDC, 0xC7,
  0xCF, 0x9F, 0xBF, 0x7A, 0xF7, 0xE7, 0xCF, 0x9F, 0x18, 0x39, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFC, 0xF0, 0xF9, 0xFB, 0x3E, 0x3C, 0xFF,
  0xBE, 0x60, 0xC1, 0x83, 0x00, 0x3D, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xFC, 0xF0, 0x70, 0x60, 0xF9, 0xFB, 0x3E, 0x7C, 0xFF, 0xBE, 0x6E,
  0xCD, 0x9F, 0x38, 0x79, 0xFB, 0x3E, 0x0F, 0x0F, 0x87, 0x67, 0xCF, 0xF9,
  0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xF9, 0xE0, 0xE3, 0x31,
  0x98, 0xCC, 0xE7, 0x61, 0xB0, 0xD8, 0x7C, 0x3C, 0x0E, 0x07, 0x00, 0xE6,
  0x6D, 0xDD, 0xBB, 0x37, 0x66, 0xEC, 0xDF, 0x9E, 0xF1, 0xDE, 0x3B, 0x87,
  0x70, 0xE6, 0x00, 0xE7, 0x67, 0x76, 0x3E, 0x3C, 0x1C, 0x3C, 0x3E, 0x76,
  0x67, 0xE7, 0xE7, 0x67, 0x66, 0x36, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFE, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x7F, 0x7F,
  0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xF8, 0xC3, 0x86, 0x18, 0x70, 0xC3, 0x0E,
  0x18, 0x61, 0xC3, 0xFD, 0xB6, 0xDB, 0x6D, 0xB7, 0xF8, 0x30, 0xC7, 0x96,
  0x48, 0xFF, 0xF0, 0x63, 0x38, 0xF9, 0xB1, 0xE6, 0xDD, 0x9F, 0x3F, 0xC3,
  0x0C, 0x30, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0x38, 0xF9, 0xB7, 0x0E,
  0x0D, 0x9F, 0x1C, 0x0E, 0x1C, 0x38, 0x77, 0xEF, 0xDB, 0xF7, 0xEE, 0xDD,
  0xFB, 0xB0, 0x7B, 0xEC, 0xF3, 0xFF, 0x0F, 0x9E, 0x3B, 0xD8, 0xCF, 0xFD,
  0x8C, 0x63, 0x18, 0xC0, 0x3E, 0xFD, 0x9F, 0x3E, 0x6C, 0xDF, 0x9B, 0x06,
  0xFC, 0xF0, 0xC3, 0x0C, 0x30, 0xFB, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xF3,
  0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x30, 0xDF,
  0x6F, 0x3C, 0xFB, 0x6D, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0x7B,
  0xBD, 0xDE, 0xEF, 0x77, 0xBB, 0xFB, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x3C,
  0xF9, 0x9F, 0x3E, 0x6C, 0xDF, 0x1E, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE,
  0xC3, 0x0C, 0x00, 0x76, 0xFD, 0xBF, 0x7E, 0xED, 0xDF, 0xBF, 0x0E, 0x1C,
  0x38, 0xFF, 0xCC, 0xCC, 0xCC, 0x39, 0xF6, 0xDE, 0x3F, 0x37, 0xCE, 0x66,
  0xFF, 0x66, 0x66, 0x73, 0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFB, 0xEE, 0xD9,
  0xB3, 0x67, 0x87, 0x0E, 0x1C, 0xCD, 0xB6, 0xDF, 0x6F, 0xB7, 0x73, 0xB8,
  0xDC, 0x66, 0x6C, 0xD9, 0xE1, 0xC3, 0x8F, 0x9B, 0x76, 0xEE, 0xD9, 0xB3,
  0x67, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0x80, 0xFF, 0xCC, 0x66, 0x73, 0xFF,
  0x13, 0x66, 0x66, 0xEC, 0x66, 0x66, 0x63, 0x10, 0xFF, 0xFF, 0xFF, 0xC0,
  0x46, 0x66, 0x66, 0x33, 0x66, 0x66, 0x66, 0x40, 0x67, 0xFA, 0x70,
};

const GFXglyph RobotoCondensed_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 5, 0, -11 },
  { 6, 7, 11, 8, 0, -11 },
  { 16, 6, 14, 8, 1, -13 },
  { 27, 8, 11, 10, 1, -11 },
  { 38, 9, 11, 9, 0, -11 },
  { 51, 2, 4, 2, 0, -11 },
  { 52, 3, 15, 5, 1, -12 },
  { 58, 4, 15, 5, 0, -12 },
  { 66, 7, 7, 7, 0, -11 },
  { 73, 7, 8, 7, 0, -9 },
  { 80, 3, 5, 4, 0, -2 },
  { 82, 4, 2, 6, 1, -6 },
  { 83, 2, 2, 4, 1, -2 },
  { 84, 5, 12, 5, 0, -11 },
  { 92, 6, 11, 8, 1, -11 },
  { 101, 4, 11, 8, 1, -11 },
  { 107, 7, 11, 8, 0, -11 },
  { 117, 7, 11, 8, 0, -11 },
  { 127, 7, 11, 8, 0, -11 },
  { 137, 6, 11, 8, 1, -11 },
  { 146, 6, 11, 8, 1, -11 },
  { 155, 7, 11, 8, 0, -11 },
  { 165, 6, 11, 8, 1, -11 },
  { 174, 6, 11, 8, 1, -11 },
  { 183, 2, 8, 4, 1, -8 },
  { 185, 3, 11, 4, 0, -8 },
  { 190, 6, 7, 7, 0, -8 },
  { 196, 6, 5, 8, 1, -7 },
  { 200, 5, 7, 7, 1, -8 },
  { 205, 6, 11, 7, 0, -11 },
  { 214, 11, 13, 11, 0, -10 },
  { 232, 9, 11, 9, 0, -11 },
  { 245, 7, 11, 8, 1, -11 },
  { 255, 7, 11, 9, 1, -11 },
  { 265, 7, 11, 8, 1, -11 },
  { 275, 6, 11, 7, 1, -11 },
  { 284, 6, 11, 7, 1, -11 },
  { 293, 7, 11, 9, 1, -11 },
  { 303, 7, 11, 9, 1, -11 },
  { 313, 2, 11, 4, 1, -11 },
  { 316, 7, 11, 7, 0, -11 },
  { 326, 7, 11, 8, 1, -11 },
  { 336, 6, 11, 7, 1, -11 },
  { 345, 10, 11, 11, 1, -11 },
  { 359, 7, 11, 9, 1, -11 },
  { 369, 7, 11, 9, 1, -11 },
  { 379, 7, 11, 9, 1, -11 },
  { 389, 7, 13, 9, 1, -11 },
  { 401, 7, 11, 8, 1, -11 },
  { 411, 7, 11, 8, 1, -11 },
  { 421, 8, 11, 8, 0, -11 },
  { 432, 7, 11, 9, 1, -11 },
  { 442, 9, 11, 9, 0, -11 },
  { 455, 11, 11, 11, 0, -11 },
  { 471, 8, 11, 8, 0, -11 },
  { 482, 8, 11, 8, 0, -11 },
  { 493, 8, 11, 8, 0, -11 },
  { 504, 3, 15, 4, 1, -12 },
  { 510, 6, 12, 6, 0, -11 },
  { 519, 3, 15, 4, 0, -12 },
  { 525, 6, 5, 6, 0, -11 },
  { 529, 6, 2, 6, 0, 0 },
  { 531, 4, 2, 5, 0, -11 },
  { 532, 7, 8, 7, 0, -8 },
  { 539, 6, 12, 7, 1, -12 },
  { 548, 7, 8, 7, 0, -8 },
  { 555, 7, 12, 7, 0, -12 },
  { 566, 6, 8, 7, 1, -8 },
  { 572, 5, 12, 5, 0, -12 },
  { 580, 7, 11, 8, 0, -8 },
  { 590, 6, 12, 7, 1, -12 },
  { 599, 2, 11, 4, 1, -11 },
  { 602, 3, 14, 4, 0, -11 },
  { 608, 6, 12, 7, 1, -12 },
  { 617, 2, 12, 4, 1, -12 },
  { 620, 9, 8, 11, 1, -8 },
  { 629, 6, 8, 7, 1, -8 },
  { 635, 7, 8, 7, 0, -8 },
  { 642, 6, 11, 7, 1, -8 },
  { 651, 7, 11, 7, 0, -8 },
  { 661, 4, 8, 5, 1, -8 },
  { 665, 6, 8, 7, 0, -8 },
  { 671, 4, 10, 5, 0, -10 },
  { 676, 6, 8, 7, 1, -8 },
  { 682, 7, 8, 7, 0, -8 },
  { 689, 9, 8, 9, 0, -8 },
  { 698, 7, 8, 7, 0, -8 },
  { 705, 7, 11, 7, 0, -8 },
  { 715, 5, 8, 7, 1, -8 },
  { 720, 4, 15, 4, 0, -12 },
  { 728, 2, 13, 4, 1, -11 },
  { 732, 4, 15, 4, 0, -12 },
  { 740, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_EXTRABOLD15PT7B_H_
