#ifndef _ROBOTOCONDENSED_EXTRABOLD25PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x7F, 0xF7, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x0D, 0xC1, 0xB0, 0x76, 0x0C, 0xC1, 0x99, 0xFF,
  0xFF, 0xF8, 0xDC, 0x1B, 0x07, 0x60, 0xEC, 0x7F, 0xEF, 0xFC, 0x6E, 0x0D,
  0xC1, 0xB0, 0x76, 0x0E, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0x83, 0xF8,
  0xFF, 0x9E, 0xF3, 0x8F, 0x71, 0xEF, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xF7, 0x8F, 0xF1, 0xFE, 0x39, 0xFF, 0x1F, 0xC1, 0xF0, 0x08, 0x01,
  0x00, 0x38, 0x01, 0xF0, 0x0E, 0xE6, 0x39, 0x98, 0xEE, 0xE3, 0xBB, 0x07,
  0xDC, 0x0E, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x67, 0x01, 0xBE, 0x0D, 0xDC,
  0x37, 0x31, 0x9D, 0xCE, 0x77, 0x00, 0xF8, 0x01, 0xC0, 0x1E, 0x01, 0xFC,
  0x1F, 0xE0, 0xF7, 0x07, 0x38, 0x39, 0xC1, 0xFE, 0x07, 0xE0, 0x3E, 0x03,
  0xF3, 0x9F, 0xDD, 0xFF, 0xEF, 0x7F, 0x79, 0xF3, 0xC7, 0x9F, 0xFC, 0x7F,
  0xF1, 0xF3, 0xC0, 0xFF, 0xFC, 0x04, 0x31, 0xC6, 0x38, 0xC7, 0x1C, 0x71,
  0xC7, 0x3C, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE1, 0x87, 0x0C,
  0x10, 0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x38, 0xC2, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x33, 0x3F, 0xFE, 0x7F, 0x83, 0xC0, 0xF8, 0x3B, 0x86, 0x38, 0x42,
  0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x39, 0xCE, 0x73, 0xB9, 0xCC, 0xFF,
  0xFF, 0xC0, 0x73, 0xDE, 0xE0, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0x1F, 0x07, 0xF1, 0xFF, 0x39, 0xEF, 0x1D, 0xE3, 0xBC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1D, 0xE3, 0x9C, 0xF3, 0xFE, 0x3F,
  0x83, 0xE0, 0x06, 0x3F, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x1F, 0x07, 0xF1, 0xFF, 0x79, 0xEF,
  0x1D, 0xE3, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x0F, 0xF1, 0xFF, 0x79,
  0xEF, 0x1C, 0x03, 0x80, 0xF0, 0xFC, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0,
  0x1F, 0xC3, 0xFC, 0xF7, 0xFE, 0x7F, 0x87, 0xE0, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0xCE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xCF, 0xF9,
  0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC7, 0xFC, 0xFF, 0xC4, 0x78, 0x07,
  0x80, 0xF0, 0x1F, 0xE3, 0xBC, 0xF3, 0xFE, 0x7F, 0x83, 0xE0, 0x07, 0x83,
  0xF0, 0xFE, 0x1E, 0x07, 0x80, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x7F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDE, 0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x1D, 0xE7, 0x9E, 0xF3, 0xFC, 0x3F,
  0x0F, 0xF1, 0xCF, 0x78, 0xEF, 0x1F, 0xE3, 0xFC, 0xF3, 0xFE, 0x7F, 0x83,
  0xE0, 0x1E, 0x07, 0xF1, 0xFE, 0x39, 0xEF, 0x1D, 0xE3, 0xBC, 0x7F, 0x8F,
  0xF3, 0xEF, 0xFD, 0xFF, 0x1E, 0xE0, 0x3C, 0x07, 0x83, 0xE1, 0xF8, 0x3E,
  0x07, 0x80, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0xF7, 0x10, 0x00, 0x83, 0xC7,
  0xEF, 0xEF, 0xC7, 0x03, 0xF0, 0xFE, 0x1F, 0x83, 0xC0, 0x20, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xF1, 0xFD, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x3E, 0x3F, 0xBF,
  0xFE, 0xFE, 0x38, 0x1C, 0x1E, 0x1E, 0x1F, 0x0F, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x78, 0x3C, 0x0E, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x87,
  0x87, 0x00, 0xE3, 0x00, 0x33, 0x87, 0x1D, 0x8F, 0xE6, 0xC7, 0x73, 0xE7,
  0x31, 0xF3, 0x18, 0xF1, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E, 0x73, 0x9F,
  0x1D, 0xCD, 0xCF, 0xFE, 0xE3, 0x9E, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xE3, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x0F, 0x78, 0x1E, 0xF0,
  0x38, 0xE0, 0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3D, 0xE0, 0x3C, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xEF, 0xFE, 0xFF, 0xCF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x39, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0,
  0x7C, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x87, 0x78, 0x3F, 0xC0, 0x1E, 0x00, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xEF, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xFE, 0x7F, 0x0F,
  0x80, 0xF0, 0xFF, 0x8F, 0xBC, 0x79, 0xE7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xF7, 0x8F, 0xBC, 0x79, 0xF3,
  0xC7, 0x9E, 0x3E, 0xF0, 0xF7, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x77, 0xFB, 0xBB, 0xFD, 0xDD, 0xFE, 0xEE, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F,
  0xCF, 0x9F, 0xE7, 0xCF, 0xF1, 0xC7, 0xF8, 0xE3, 0xC0, 0xF0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xF7, 0x7F,
  0xBB, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x8F, 0xFE,
  0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE,
  0xFF, 0xEF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3D, 0xE3,
  0xCF, 0xFE, 0x3F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF0,
  0xFF, 0x0F, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xFF, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0x1E, 0xF0, 0xFF, 0x0F, 0xF9,
  0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xF8,
  0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3C, 0x1C, 0xF0, 0x7B, 0xC1, 0xEE, 0x07, 0xB8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0xE3, 0xDE, 0x78, 0xF7,
  0x9E, 0x3D, 0xE7, 0xCF, 0x79, 0xF3, 0x9E, 0x7C, 0xE3, 0x9F, 0x78, 0xEF,
  0xDE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF0, 0xFE, 0xFC, 0x1F, 0xBF,
  0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x80,
  0x78, 0x79, 0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xF3,
  0xC3, 0xCF, 0x1F, 0x3E, 0x78, 0x79, 0xE1, 0xE0, 0xF8, 0x79, 0xE1, 0xE7,
  0x87, 0x8E, 0x3C, 0x3C, 0xF0, 0xF3, 0x81, 0xDE, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xFF, 0xF8, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xFF, 0xF8, 0x3C, 0x3C, 0x3C, 0x7E, 0x7E, 0x66, 0xE7, 0xE7,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0x87, 0x3E, 0x1F, 0xEF, 0xFB,
  0xCF, 0x03, 0xCF, 0xF7, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0x3B,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE,
  0xFF, 0xDE, 0x7B, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9E, 0xFF,
  0xDF, 0xFB, 0xDE, 0x00, 0x1E, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0x0F,
  0x03, 0xC0, 0xF3, 0xFC, 0xFF, 0xF9, 0xFE, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF3, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0x1F, 0x1F, 0xE7,
  0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x27, 0xFD, 0xFF,
  0x1F, 0x00, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3D, 0xDF, 0xFF,
  0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0xFD, 0xFF,
  0x3D, 0xC0, 0x72, 0x3D, 0xFF, 0x7F, 0x8F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x73, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3C, 0x6F, 0xF7, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC7, 0x00, 0x03, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xBC,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0xFF, 0x9E, 0xF7,
  0x9F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFE, 0x3D, 0xE7, 0xBC, 0xF3, 0xDE,
  0x7B, 0xC7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF7, 0x9E, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF7, 0xBF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x1F, 0x0F, 0xF1, 0xFF,
  0x79, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xDE, 0x79, 0xFF, 0x3F,
  0xC1, 0xF0, 0xF7, 0x1F, 0xFB, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x7B, 0xFF, 0x7F, 0xEF, 0x71, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0xF7, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xCE, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xB8, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x38, 0x70, 0xE7, 0xFF, 0xFF,
  0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0xCF, 0x8F, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3D, 0xC0, 0xF1, 0xEE, 0x3D, 0xE7, 0x3D, 0xE7, 0xBC, 0x77, 0x8E, 0xE1,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0xF3, 0x8E, 0xE7, 0x1D,
  0xCF, 0x7B, 0x9E, 0xF7, 0xFD, 0xCF, 0xFB, 0x8F, 0xFF, 0x1F, 0x7E, 0x3E,
  0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x80, 0x79, 0xEF, 0x38,
  0xEF, 0x1F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xEF,
  0x3C, 0xE7, 0x1E, 0xF1, 0xEE, 0x3D, 0xE7, 0x3D, 0xE7, 0xBC, 0x77, 0x8F,
  0xE1, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x3C, 0x3F, 0xFF, 0xFF, 0xF8, 0x08, 0x73, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xCF, 0x38, 0xE1, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x38, 0xE1,
  0xC2, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x8F, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC3, 0xC7, 0x3D, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E,
  0x30, 0x38, 0x77, 0xC6, 0x7E, 0xEE, 0x7E, 0xE3, 0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 6, 7, 8, 1, -19 },
  { 16, 11, 18, 13, 1, -18 },
  { 41, 11, 23, 13, 1, -21 },
  { 73, 14, 18, 16, 1, -18 },
  { 105, 13, 18, 15, 1, -18 },
  { 135, 2, 7, 4, 1, -19 },
  { 137, 6, 26, 8, 1, -20 },
  { 157, 6, 26, 8, 1, -20 },
  { 177, 11, 11, 11, 0, -18 },
  { 193, 10, 13, 12, 1, -15 },
  { 210, 5, 8, 6, 0, -3 },
  { 215, 6, 3, 10, 2, -9 },
  { 218, 5, 4, 7, 1, -4 },
  { 221, 8, 20, 8, 0, -18 },
  { 241, 11, 18, 13, 1, -18 },
  { 266, 7, 18, 13, 2, -18 },
  { 282, 11, 18, 13, 1, -18 },
  { 307, 11, 18, 13, 1, -18 },
  { 332, 11, 18, 13, 1, -18 },
  { 357, 11, 18, 13, 1, -18 },
  { 382, 11, 18, 13, 1, -18 },
  { 407, 11, 18, 13, 1, -18 },
  { 432, 11, 18, 13, 1, -18 },
  { 457, 11, 18, 13, 1, -18 },
  { 482, 4, 14, 7, 2, -14 },
  { 489, 5, 19, 7, 1, -14 },
  { 501, 9, 11, 11, 1, -13 },
  { 514, 9, 8, 13, 2, -12 },
  { 523, 10, 11, 11, 1, -13 },
  { 537, 9, 18, 11, 1, -18 },
  { 558, 17, 23, 19, 1, -17 },
  { 607, 15, 18, 15, 0, -18 },
  { 641, 12, 18, 14, 1, -18 },
  { 668, 13, 18, 14, 1, -18 },
  { 698, 12, 18, 14, 1, -18 },
  { 725, 11, 18, 12, 1, -18 },
  { 750, 10, 18, 12, 1, -18 },
  { 773, 13, 18, 15, 1, -18 },
  { 803, 13, 18, 15, 1, -18 },
  { 833, 4, 18, 7, 1, -18 },
  { 842, 10, 18, 12, 1, -18 },
  { 865, 13, 18, 14, 1, -18 },
  { 895, 10, 18, 12, 1, -18 },
  { 918, 17, 18, 19, 1, -18 },
  { 957, 13, 18, 15, 1, -18 },
  { 987, 13, 18, 15, 1, -18 },
  { 1017, 12, 18, 14, 1, -18 },
  { 1044, 13, 21, 15, 1, -18 },
  { 1079, 12, 18, 14, 1, -18 },
  { 1106, 12, 18, 14, 1, -18 },
  { 1133, 12, 18, 14, 1, -18 },
  { 1160, 12, 18, 14, 1, -18 },
  { 1187, 14, 18, 15, 0, -18 },
  { 1219, 18, 18, 19, 0, -18 },
  { 1260, 14, 18, 14, 0, -18 },
  { 1292, 14, 18, 14, 0, -18 },
  { 1324, 12, 18, 13, 1, -18 },
  { 1351, 5, 25, 7, 1, -21 },
  { 1367, 10, 20, 10, 0, -18 },
  { 1392, 5, 25, 7, 0, -21 },
  { 1408, 8, 9, 10, 1, -18 },
  { 1417, 10, 3, 10, 0, 0 },
  { 1421, 6, 4, 8, 1, -19 },
  { 1424, 10, 13, 12, 1, -13 },
  { 1441, 11, 19, 12, 1, -19 },
  { 1468, 10, 13, 11, 1, -13 },
  { 1485, 10, 19, 12, 1, -19 },
  { 1509, 10, 13, 12, 1, -13 },
  { 1526, 8, 19, 8, 0, -19 },
  { 1545, 10, 18, 13, 1, -13 },
  { 1568, 10, 19, 12, 1, -19 },
  { 1592, 4, 19, 6, 1, -19 },
  { 1602, 6, 24, 6, -1, -19 },
  { 1620, 11, 19, 12, 1, -19 },
  { 1647, 4, 19, 6, 1, -19 },
  { 1657, 16, 13, 19, 1, -13 },
  { 1683, 10, 13, 12, 1, -13 },
  { 1700, 11, 13, 12, 1, -13 },
  { 1718, 11, 18, 12, 1, -13 },
  { 1743, 10, 18, 12, 1, -13 },
  { 1766, 7, 13, 8, 1, -13 },
  { 1778, 10, 13, 11, 1, -13 },
  { 1795, 7, 16, 8, 0, -16 },
  { 1809, 10, 13, 12, 1, -13 },
  { 1826, 11, 13, 11, 0, -13 },
  { 1844, 15, 13, 16, 0, -13 },
  { 1869, 11, 13, 11, 0, -13 },
  { 1887, 11, 18, 11, 0, -13 },
  { 1912, 9, 13, 11, 1, -13 },
  { 1927, 6, 24, 7, 1, -20 },
  { 1945, 2, 21, 6, 2, -18 },
  { 1951, 6, 24, 7, 1, -20 },
  { 1969, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_EXTRABOLD25PT7B_H_
