#ifndef _ROBOTOCONDENSED_EXTRABOLD43PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x03, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0xE0, 0x07, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xF1, 0xFD, 0xF8, 0x7F, 0x7E, 0x0F, 0xDF, 0x83,
  0xF7, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0xCF,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x80, 0xF1, 0xE0, 0xE0,
  0xF1, 0xF1, 0xE0, 0xF1, 0xF1, 0xE0, 0xF1, 0xF3, 0xC0, 0xF1, 0xF3, 0xC0,
  0xF1, 0xE7, 0x80, 0xFF, 0xE7, 0x80, 0x7F, 0xEF, 0x00, 0x3F, 0xCE, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0xF3, 0xFC, 0x00, 0xF7, 0xFE, 0x01, 0xEF, 0xFE,
  0x01, 0xEF, 0x9E, 0x03, 0xCF, 0x1F, 0x03, 0xCF, 0x0F, 0x07, 0x8F, 0x0F,
  0x07, 0x0F, 0x1F, 0x0F, 0x0F, 0x9E, 0x06, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E,
  0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x7E, 0x1F, 0xF8, 0xFC, 0x7F, 0xF9, 0xF9, 0xFF, 0xFB,
  0xF3, 0xF7, 0xF7, 0xC7, 0xE7, 0xFF, 0x9F, 0xC7, 0xFF, 0x3F, 0x8F, 0xFE,
  0x7F, 0x0F, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x80, 0xFC, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xE0, 0x00, 0x40, 0x38, 0x0F,
  0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x00, 0x20, 0x40, 0x0E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x01, 0xC0, 0x20, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xC3, 0xC1,
  0x3E, 0x78, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0xF0,
  0x3E, 0x1F, 0x03, 0x81, 0xC0, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xC3, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xCF, 0xE7, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE3, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFB, 0xF8, 0x1F, 0x7F, 0x07, 0xCF, 0xE0, 0xF9, 0xFC, 0x3E,
  0x3F, 0x87, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x81,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF0, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xBF, 0xCF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7F, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xF3, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF, 0xE7, 0xE1, 0xFB, 0xF8,
  0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x9F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xF7, 0xFF, 0xFF,
  0xFF, 0x3C, 0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xF9, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1,
  0xE0, 0x20, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x0F, 0xC1, 0xE1, 0xE0, 0x7F,
  0x83, 0x8F, 0x03, 0xFF, 0x0F, 0x3C, 0x1F, 0xFC, 0x3C, 0xF0, 0xF8, 0xF0,
  0xF7, 0xC3, 0xC3, 0xC3, 0xDE, 0x1F, 0x0F, 0x0F, 0x78, 0x7C, 0x3C, 0x3D,
  0xE1, 0xE0, 0xF0, 0xF7, 0x87, 0x83, 0xC3, 0xDE, 0x3E, 0x1F, 0x0F, 0x78,
  0xF8, 0x7C, 0x3D, 0xE3, 0xE1, 0xF0, 0xF7, 0x8F, 0x87, 0xC3, 0xDE, 0x3E,
  0x1E, 0x0E, 0x78, 0xF8, 0x78, 0x79, 0xE1, 0xF3, 0xF1, 0xE7, 0x87, 0xFF,
  0xFF, 0x1E, 0x1F, 0xFF, 0xF8, 0x7C, 0x3F, 0x9F, 0xE0, 0xF0, 0x7C, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE3, 0xFE, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x3F, 0xEF, 0xF9, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xE7, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xE3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xE7,
  0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F,
  0x7F, 0x01, 0xFB, 0xFF, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0xEF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF8, 0xFB, 0xFF,
  0xEF, 0x8F, 0xBF, 0xFE, 0xF8, 0xFB, 0xFF, 0xEF, 0x9F, 0x3F, 0xFE, 0xFD,
  0xF3, 0xFF, 0xE7, 0xDF, 0x3F, 0xFE, 0x7D, 0xE3, 0xFF, 0xE7, 0xFE, 0x3F,
  0xFE, 0x3F, 0xE3, 0xFF, 0xE3, 0xFE, 0x3F, 0xFE, 0x3F, 0xC3, 0xFF, 0xE3,
  0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0x83,
  0xFF, 0xE0, 0xF8, 0x3F, 0xFE, 0x0F, 0x83, 0xF0, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFB, 0xE7, 0xFF, 0xEF,
  0x9F, 0xFF, 0xBF, 0x7F, 0xFE, 0x7D, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xDF, 0x80, 0xFE, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0x0F, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFB, 0xF8, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xDF, 0x80, 0xFE, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x0F, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xE7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFD,
  0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB, 0xFE, 0x7F, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0x7F, 0x07, 0xF3, 0xFE, 0xFF, 0x9F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0x7E, 0x1F, 0xE1, 0xFD, 0xF8, 0x7F, 0x87, 0xE7,
  0xE1, 0xFE, 0x1F, 0x9F, 0xC7, 0xF8, 0x7E, 0x7F, 0x1F, 0xE3, 0xF9, 0xFC,
  0x7F, 0xCF, 0xE3, 0xF3, 0xFF, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3F,
  0xF3, 0xF0, 0xFC, 0xFF, 0xCF, 0xC3, 0xFB, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x83, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x7C, 0x3E,
  0xF8, 0x78, 0xF0, 0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xDF, 0x07, 0xFE, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F,
  0xBF, 0x8F, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xF7, 0xF0,
  0xF9, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x3F,
  0x0F, 0xDF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xF3, 0xFB,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xDF, 0xE3,
  0xF3, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xF9, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x7E, 0x1F, 0x9F, 0xC7, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC1, 0xF3, 0xF1, 0xFE, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xF1, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFE, 0xFC, 0x1F, 0x3F, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x02, 0x3F, 0xC3, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x87, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x07, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xF3, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x30, 0x7F, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x3E, 0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x02, 0x03, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFB,
  0xF0, 0xFE, 0x7E, 0x3F, 0xCF, 0xC7, 0xF1, 0xF9, 0xFC, 0x3F, 0x3F, 0x87,
  0xEF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0x3F, 0xBF,
  0x07, 0xF7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F, 0x0F,
  0xDF, 0xE7, 0xFC, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF3, 0xFC, 0xFE, 0xFE, 0x3F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F,
  0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1,
  0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87,
  0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC,
  0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x7F, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x7C, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xE3,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0xFC, 0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x8F, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x8F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0x7F, 0x8F, 0xCF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x07, 0xC7, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xC7, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFB, 0xF0, 0x7C, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF1,
  0xFD, 0xF8, 0x7E, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83,
  0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFE, 0xFC, 0x3E, 0x7E, 0x7E, 0x0F, 0xEF, 0xC1,
  0xFD, 0xFC, 0x3F, 0x3F, 0x87, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x7E, 0xFC, 0x07, 0xDF,
  0x80, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87,
  0xFF, 0x8F, 0xE3, 0xF7, 0xC7, 0xF1, 0xF3, 0xF3, 0xF9, 0xF9, 0xF9, 0xFC,
  0xFC, 0xFC, 0xFE, 0x7E, 0x7E, 0xFF, 0xBF, 0x1F, 0x7F, 0xDF, 0x0F, 0xBD,
  0xEF, 0x87, 0xDE, 0xF7, 0xC3, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xF8, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xDF, 0x87, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x3F, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFE,
  0x7E, 0x3F, 0xBF, 0x87, 0xEF, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xC1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x87, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1,
  0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x78,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE3, 0xF8, 0x7F,
  0x0F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x0E, 0x01,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7F, 0x87,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x3F, 0x03, 0xC0, 0x70, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x1F,
  0x3F, 0xE1, 0xF7, 0xFE, 0x1E, 0x7F, 0xF3, 0xEF, 0xDF, 0xFE, 0xF8, 0xFF,
  0xEF, 0x87, 0xFC, 0xF8, 0x3F, 0x80, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 12, 12, 14, 1, -32 },
  { 47, 20, 31, 22, 1, -31 },
  { 125, 18, 39, 22, 2, -35 },
  { 213, 24, 31, 28, 2, -31 },
  { 306, 23, 31, 25, 1, -31 },
  { 396, 5, 12, 7, 1, -32 },
  { 404, 11, 44, 14, 2, -34 },
  { 465, 11, 44, 14, 1, -34 },
  { 526, 19, 19, 20, 1, -31 },
  { 572, 18, 22, 20, 1, -25 },
  { 622, 7, 13, 11, 1, -5 },
  { 634, 11, 5, 17, 3, -16 },
  { 641, 7, 7, 13, 3, -7 },
  { 648, 13, 34, 14, 0, -31 },
  { 704, 18, 31, 22, 2, -31 },
  { 774, 12, 31, 22, 3, -31 },
  { 821, 19, 31, 22, 1, -31 },
  { 895, 19, 31, 22, 1, -31 },
  { 969, 19, 31, 22, 1, -31 },
  { 1043, 18, 31, 22, 2, -31 },
  { 1113, 18, 31, 22, 2, -31 },
  { 1183, 19, 31, 22, 1, -31 },
  { 1257, 18, 31, 22, 2, -31 },
  { 1327, 18, 31, 22, 2, -31 },
  { 1397, 7, 24, 12, 3, -24 },
  { 1418, 9, 32, 11, 1, -24 },
  { 1454, 16, 20, 19, 1, -23 },
  { 1494, 16, 14, 22, 3, -20 },
  { 1522, 16, 20, 19, 2, -23 },
  { 1562, 17, 31, 20, 1, -31 },
  { 1628, 30, 40, 33, 1, -30 },
  { 1778, 26, 31, 26, 0, -31 },
  { 1879, 20, 31, 24, 2, -31 },
  { 1957, 21, 31, 25, 2, -31 },
  { 2039, 20, 31, 24, 2, -31 },
  { 2117, 18, 31, 21, 2, -31 },
  { 2187, 17, 31, 20, 2, -31 },
  { 2253, 21, 31, 25, 2, -31 },
  { 2335, 22, 31, 26, 2, -31 },
  { 2421, 6, 31, 12, 3, -31 },
  { 2445, 18, 31, 21, 1, -31 },
  { 2515, 22, 31, 24, 2, -31 },
  { 2601, 18, 31, 21, 2, -31 },
  { 2671, 28, 31, 33, 2, -31 },
  { 2780, 22, 31, 26, 2, -31 },
  { 2866, 22, 31, 26, 2, -31 },
  { 2952, 21, 31, 25, 2, -31 },
  { 3034, 22, 37, 26, 2, -31 },
  { 3136, 21, 31, 24, 2, -31 },
  { 3218, 21, 31, 23, 1, -31 },
  { 3300, 22, 31, 24, 1, -31 },
  { 3386, 21, 31, 25, 2, -31 },
  { 3468, 25, 31, 25, 0, -31 },
  { 3565, 30, 31, 32, 1, -31 },
  { 3682, 24, 31, 24, 0, -31 },
  { 3775, 23, 31, 24, 0, -31 },
  { 3865, 21, 31, 23, 1, -31 },
  { 3947, 9, 43, 11, 2, -36 },
  { 3996, 17, 34, 16, 0, -31 },
  { 4069, 8, 43, 11, 1, -36 },
  { 4112, 15, 15, 17, 1, -31 },
  { 4141, 17, 5, 17, 0, 0 },
  { 4152, 11, 7, 14, 1, -33 },
  { 4162, 18, 23, 20, 1, -23 },
  { 4214, 18, 32, 21, 2, -32 },
  { 4286, 18, 23, 20, 1, -23 },
  { 4338, 18, 32, 21, 1, -32 },
  { 4410, 18, 23, 21, 2, -23 },
  { 4462, 13, 32, 14, 1, -32 },
  { 4514, 19, 32, 22, 1, -23 },
  { 4590, 17, 32, 21, 2, -32 },
  { 4658, 7, 33, 11, 2, -33 },
  { 4687, 10, 42, 11, -1, -33 },
  { 4740, 19, 32, 21, 2, -32 },
  { 4816, 7, 32, 11, 2, -32 },
  { 4844, 28, 23, 32, 2, -23 },
  { 4925, 17, 23, 21, 2, -23 },
  { 4974, 19, 23, 21, 1, -23 },
  { 5029, 18, 32, 21, 2, -23 },
  { 5101, 18, 32, 21, 1, -23 },
  { 5173, 12, 23, 15, 2, -23 },
  { 5208, 17, 23, 20, 1, -23 },
  { 5257, 12, 28, 13, 1, -28 },
  { 5299, 17, 23, 21, 2, -23 },
  { 5348, 19, 23, 20, 0, -23 },
  { 5403, 25, 23, 27, 1, -23 },
  { 5475, 18, 23, 20, 1, -23 },
  { 5527, 19, 32, 20, 0, -23 },
  { 5603, 16, 23, 20, 2, -23 },
  { 5649, 11, 42, 13, 1, -34 },
  { 5707, 3, 37, 11, 4, -31 },
  { 5721, 11, 42, 13, 1, -34 },
  { 5779, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_EXTRABOLD43PT7B_H_
