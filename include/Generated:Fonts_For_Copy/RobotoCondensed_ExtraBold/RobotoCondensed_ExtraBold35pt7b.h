#ifndef _ROBOTOCONDENSED_EXTRABOLD35PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x00, 0x00, 0x1C, 0xFB, 0xEF, 0xBE, 0x70, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x03, 0x9C, 0x07, 0x9C,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFF, 0x07, 0xFF, 0x1F,
  0xFE, 0x3E, 0x7E, 0xFC, 0x7D, 0xF8, 0xFB, 0xF1, 0xF7, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7E, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x3E, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x73, 0xC3, 0x0E, 0x38, 0xE1, 0xC7, 0x1C,
  0x38, 0xE7, 0x07, 0x1D, 0xE0, 0xE7, 0xB8, 0x1F, 0xEF, 0x01, 0xFD, 0xC0,
  0x1F, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x9E, 0x00, 0x77, 0xF0, 0x1D, 0xFE,
  0x03, 0xB9, 0xE0, 0xEF, 0x3C, 0x3D, 0xE3, 0x87, 0x3C, 0x71, 0xE7, 0x9E,
  0x38, 0x73, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x1F, 0xF9, 0xE3, 0xFF, 0xBC,
  0xF9, 0xFF, 0x9F, 0x1F, 0xF3, 0xE3, 0xFC, 0x7E, 0x3F, 0x8F, 0xE7, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0xEE, 0x01, 0x07, 0x07, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x07, 0x01, 0x40, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC6, 0x7D, 0xDE, 0x7F, 0xFF, 0x1F, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x38,
  0x08, 0x10, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x11, 0xEF, 0xFF, 0xFD, 0xE0, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xF9, 0xFF, 0xE3,
  0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF, 0x8F, 0xFF,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xEF, 0xEF, 0xFF, 0x9F, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1E, 0xFC, 0x1E, 0xFC, 0x3C,
  0xFC, 0x3C, 0xFC, 0x7C, 0xFC, 0x78, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3,
  0xC7, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0,
  0xFB, 0xE1, 0xF7, 0xE7, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xE0,
  0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFB, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF,
  0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF7,
  0xC3, 0xE7, 0xCF, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0xFD, 0xF3, 0xE7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xEF, 0xCF,
  0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xE7, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF,
  0x0F, 0xBE, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x10, 0xF9, 0xFB, 0xF7,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x9F, 0x3C, 0x79, 0xE0, 0x80, 0x00, 0x08, 0x01, 0xC0,
  0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0x1F, 0xC0, 0xF8, 0x07, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x00, 0xF8, 0x3F,
  0xC7, 0xFE, 0xFF, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFE, 0xFD, 0xFB, 0xE3, 0xEF, 0x8F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x78, 0x3E, 0x1C, 0x38, 0x3F, 0xC7,
  0x3C, 0x3F, 0xE3, 0x9E, 0x3E, 0xF1, 0xCE, 0x1E, 0x78, 0xE7, 0x1E, 0x3C,
  0x73, 0x8F, 0x1E, 0x3B, 0xC7, 0x8F, 0x1D, 0xE3, 0x87, 0x8E, 0xF3, 0xC3,
  0x87, 0x79, 0xE1, 0xC3, 0xBC, 0xF0, 0xE1, 0xDE, 0x3C, 0xF1, 0xEF, 0x1E,
  0x78, 0xE3, 0x8F, 0xFF, 0xF1, 0xC3, 0xF7, 0xF0, 0xF0, 0xF1, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xBF, 0x9F, 0x83, 0xE7, 0xC0, 0xFD,
  0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xDF, 0x03,
  0xF7, 0xC0, 0xFD, 0xF8, 0x3E, 0x3F, 0xBF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF9, 0xFE, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7, 0xF7, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xF3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0xBE, 0x0F, 0xEF, 0x83, 0xF3,
  0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3,
  0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7E, 0xF8,
  0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0x7F, 0xFE, 0x1E, 0xFF, 0xFE, 0x3D, 0xFF, 0xBC, 0xFB, 0xFF,
  0x79, 0xE7, 0xFE, 0xFB, 0xDF, 0xFC, 0xF7, 0xBF, 0xF9, 0xFF, 0x7F, 0xF3,
  0xFC, 0xFF, 0xE7, 0xF9, 0xFF, 0xC7, 0xF3, 0xFF, 0x8F, 0xC7, 0xFF, 0x1F,
  0x8F, 0xFE, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0x78, 0x7E, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xBC, 0xFF, 0xEF,
  0x3F, 0xF9, 0xEF, 0xFE, 0x7B, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xFB, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x0F, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB,
  0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0x07,
  0xE3, 0xFB, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x02,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x8F, 0xF7,
  0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F,
  0xDF, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0xCF, 0x87, 0xE7, 0xC1, 0xF3,
  0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF,
  0x83, 0xF7, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E,
  0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x8F,
  0x81, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7D,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xF8, 0x3C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F,
  0xFC, 0x7E, 0x3F, 0x7C, 0x7E, 0x3F, 0x7C, 0x7F, 0x3E, 0x7C, 0xFF, 0x3E,
  0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7E, 0xFF, 0x3E, 0x3E, 0xFF, 0x7C,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFC, 0x3F, 0xE7, 0xFC,
  0x1F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xC1, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE7, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x7E, 0x7C,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7F,
  0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x1F, 0x81,
  0xF8, 0x3F, 0x83, 0xFC, 0x39, 0xC7, 0x9E, 0x79, 0xE7, 0x9E, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xCF, 0xDF,
  0x8F, 0x80, 0x1F, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xF1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x9F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F, 0x7C, 0x3C, 0xF8,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xCF, 0x80, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0xF8, 0x7D, 0xF3, 0xF7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F, 0x7E, 0x7F,
  0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xE7, 0xCF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x8F, 0xC7, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x80, 0x0F, 0xBE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xE7, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xEF, 0xCF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1F, 0x7C,
  0x00, 0xF8, 0x01, 0xF1, 0x87, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x0F,
  0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFB,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0xFD, 0xF1, 0xFB, 0xE7, 0xE7, 0xDF, 0x8F, 0xBE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x8F, 0x9F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7E, 0xF8, 0xFD, 0xF0, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xE1, 0xF3, 0xFF, 0xCF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFF, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE,
  0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F,
  0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xF0, 0xF1, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE3, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xEF, 0xCF, 0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0x0F,
  0xC0, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xEF, 0x8F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x7F,
  0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1E, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE,
  0xF8, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F,
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7C,
  0xF9, 0xF0, 0xFC, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xF3, 0xF3, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9,
  0xF7, 0x9F, 0x9E, 0x79, 0xFB, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x3E, 0x7E,
  0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x07, 0x0F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0xFC, 0xF8, 0xF0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1F, 0x0F, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1F, 0x1F, 0x0F, 0x1F, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0,
  0x40, 0x1C, 0x00, 0x7F, 0x0F, 0x7F, 0x8F, 0xFF, 0xDE, 0xF3, 0xFE, 0xF1,
  0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 9, 2, -25 },
  { 20, 9, 10, 11, 1, -26 },
  { 32, 16, 25, 18, 1, -25 },
  { 82, 15, 32, 18, 1, -29 },
  { 142, 19, 25, 22, 2, -25 },
  { 202, 19, 25, 21, 1, -25 },
  { 262, 4, 10, 6, 1, -26 },
  { 267, 8, 36, 11, 2, -28 },
  { 303, 9, 36, 11, 1, -28 },
  { 344, 16, 15, 16, 0, -25 },
  { 374, 14, 19, 16, 1, -21 },
  { 408, 6, 11, 9, 1, -4 },
  { 417, 9, 4, 14, 2, -13 },
  { 422, 6, 6, 10, 2, -6 },
  { 427, 11, 27, 11, 0, -25 },
  { 465, 14, 25, 18, 2, -25 },
  { 509, 10, 25, 18, 3, -25 },
  { 541, 15, 25, 18, 1, -25 },
  { 588, 15, 25, 18, 1, -25 },
  { 635, 16, 25, 18, 1, -25 },
  { 685, 15, 25, 18, 1, -25 },
  { 732, 15, 25, 18, 2, -25 },
  { 779, 15, 25, 18, 1, -25 },
  { 826, 14, 25, 18, 2, -25 },
  { 870, 15, 25, 18, 1, -25 },
  { 917, 6, 20, 10, 2, -20 },
  { 932, 7, 27, 9, 1, -20 },
  { 956, 13, 17, 16, 1, -19 },
  { 984, 13, 12, 18, 2, -17 },
  { 1004, 13, 17, 16, 2, -19 },
  { 1032, 14, 25, 16, 1, -25 },
  { 1076, 25, 32, 27, 1, -24 },
  { 1176, 21, 25, 21, 0, -25 },
  { 1242, 16, 25, 20, 2, -25 },
  { 1292, 18, 25, 20, 1, -25 },
  { 1349, 16, 25, 20, 2, -25 },
  { 1399, 14, 25, 17, 2, -25 },
  { 1443, 14, 25, 17, 2, -25 },
  { 1487, 17, 25, 21, 2, -25 },
  { 1541, 18, 25, 21, 2, -25 },
  { 1598, 6, 25, 10, 2, -25 },
  { 1617, 14, 25, 17, 1, -25 },
  { 1661, 18, 25, 19, 2, -25 },
  { 1718, 14, 25, 17, 2, -25 },
  { 1762, 23, 25, 27, 2, -25 },
  { 1834, 18, 25, 21, 2, -25 },
  { 1891, 19, 25, 21, 1, -25 },
  { 1951, 17, 25, 20, 2, -25 },
  { 2005, 19, 30, 21, 1, -25 },
  { 2077, 17, 25, 20, 2, -25 },
  { 2131, 17, 25, 19, 1, -25 },
  { 2185, 17, 25, 19, 1, -25 },
  { 2239, 16, 25, 20, 2, -25 },
  { 2289, 20, 25, 20, 0, -25 },
  { 2352, 24, 25, 26, 1, -25 },
  { 2427, 19, 25, 20, 0, -25 },
  { 2487, 19, 25, 19, 0, -25 },
  { 2547, 17, 25, 19, 1, -25 },
  { 2601, 7, 35, 9, 2, -29 },
  { 2632, 14, 27, 13, 0, -25 },
  { 2680, 6, 35, 9, 1, -29 },
  { 2707, 12, 12, 14, 1, -25 },
  { 2725, 14, 4, 14, 0, 0 },
  { 2732, 9, 5, 12, 1, -26 },
  { 2738, 15, 18, 16, 1, -18 },
  { 2772, 14, 26, 17, 2, -26 },
  { 2818, 14, 18, 16, 1, -18 },
  { 2850, 15, 26, 17, 1, -26 },
  { 2899, 15, 18, 17, 1, -18 },
  { 2933, 10, 26, 12, 1, -26 },
  { 2966, 15, 25, 18, 1, -18 },
  { 3013, 14, 26, 17, 2, -26 },
  { 3059, 5, 25, 9, 2, -25 },
  { 3075, 8, 32, 9, -1, -25 },
  { 3107, 15, 26, 17, 2, -26 },
  { 3156, 5, 26, 9, 2, -26 },
  { 3173, 22, 18, 26, 2, -18 },
  { 3223, 14, 18, 17, 2, -18 },
  { 3255, 15, 18, 17, 1, -18 },
  { 3289, 14, 25, 17, 2, -18 },
  { 3333, 15, 25, 17, 1, -18 },
  { 3380, 9, 18, 12, 2, -18 },
  { 3401, 14, 18, 16, 1, -18 },
  { 3433, 10, 23, 11, 0, -23 },
  { 3462, 14, 18, 17, 2, -18 },
  { 3494, 15, 18, 16, 0, -18 },
  { 3528, 20, 18, 22, 1, -18 },
  { 3573, 16, 18, 16, 0, -18 },
  { 3609, 16, 25, 16, 0, -18 },
  { 3659, 14, 18, 16, 1, -18 },
  { 3691, 8, 33, 10, 1, -27 },
  { 3724, 3, 30, 9, 3, -25 },
  { 3736, 8, 33, 10, 1, -27 },
  { 3769, 16, 8, 19, 2, -14 },
};

const GFXfont RobotoCondensed_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_EXTRABOLD35PT7B_H_
