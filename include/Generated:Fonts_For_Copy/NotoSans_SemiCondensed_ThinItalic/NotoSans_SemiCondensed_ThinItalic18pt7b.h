#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x00, 0x80, 0x99, 0xAA, 0xA0, 0x04,
  0x82, 0x20, 0x90, 0x24, 0x3F, 0xC4, 0x81, 0x20, 0x48, 0xFF, 0x09, 0x02,
  0x41, 0x10, 0x48, 0x00, 0x04, 0x10, 0xFA, 0x44, 0x8A, 0x0C, 0x08, 0x1C,
  0x28, 0x91, 0x2F, 0x84, 0x08, 0x00, 0x38, 0x52, 0x24, 0x92, 0x24, 0x8A,
  0x23, 0x79, 0x65, 0xA9, 0x0A, 0x45, 0x12, 0x44, 0x91, 0x43, 0x80, 0x0E,
  0x08, 0x84, 0x42, 0x21, 0x20, 0xA0, 0x60, 0x49, 0x44, 0xC1, 0xA0, 0x50,
  0x67, 0xD0, 0xF8, 0x18, 0x88, 0x84, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11, 0x10, 0x10,
  0x23, 0x41, 0x73, 0x09, 0x02, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x29, 0x40, 0xF0, 0x80, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x45, 0x0A, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x47, 0x00, 0x36, 0xA2, 0x22, 0x44,
  0x44, 0x48, 0x80, 0x1E, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFC, 0x1E, 0x21, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x02,
  0x02, 0x02, 0x02, 0x02, 0xFC, 0x01, 0x03, 0x05, 0x09, 0x0A, 0x12, 0x22,
  0x42, 0x42, 0xFF, 0x04, 0x04, 0x04, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x3C,
  0x02, 0x02, 0x01, 0x02, 0x02, 0x02, 0xFC, 0x0F, 0x10, 0x20, 0x40, 0x40,
  0xBC, 0xC2, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0xFE, 0x04, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0x0E, 0x11, 0x21, 0x21,
  0x21, 0x12, 0x1C, 0x22, 0x42, 0x81, 0x82, 0x82, 0x7C, 0x1E, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x43, 0x3D, 0x02, 0x02, 0x04, 0x04, 0xF8, 0x24, 0x00,
  0x00, 0x10, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x07, 0x18, 0x60, 0x80,
  0x60, 0x18, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x0C,
  0x30, 0xC0, 0x78, 0x10, 0x41, 0x08, 0x42, 0x10, 0x42, 0x00, 0x00, 0x80,
  0x07, 0x83, 0x0C, 0x80, 0xA0, 0x14, 0x7B, 0x12, 0x64, 0x4C, 0x89, 0x91,
  0x32, 0x4A, 0x76, 0x40, 0x08, 0x00, 0xC0, 0x07, 0x80, 0x02, 0x02, 0x05,
  0x05, 0x09, 0x09, 0x11, 0x1F, 0x21, 0x21, 0x41, 0x41, 0x81, 0x3E, 0x21,
  0x21, 0x41, 0x41, 0x42, 0x7C, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x0F,
  0x88, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x03, 0xE0, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x81,
  0x40, 0xA0, 0x90, 0x8F, 0x80, 0x3F, 0x20, 0x20, 0x40, 0x40, 0x40, 0x7C,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xF8, 0x3F, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xC4, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x72, 0x02, 0x80, 0xA0, 0x48, 0x11, 0x04, 0x3F, 0x00,
  0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x27, 0xFA, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x04, 0x82, 0x00, 0x38, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10,
  0x8E, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x70, 0x20, 0x90, 0x88, 0x88, 0x84, 0x82, 0x81, 0xC0,
  0xA0, 0x88, 0x44, 0x21, 0x10, 0x88, 0x40, 0x21, 0x08, 0x84, 0x21, 0x10,
  0x84, 0x21, 0x0F, 0x80, 0x20, 0x12, 0x01, 0x20, 0x35, 0x05, 0x50, 0x65,
  0x0A, 0x50, 0xA9, 0x12, 0x92, 0x29, 0x24, 0x8C, 0x48, 0xC4, 0x88, 0x40,
  0x20, 0x48, 0x13, 0x05, 0x42, 0x50, 0x92, 0x24, 0x8A, 0x24, 0x85, 0x21,
  0x48, 0x32, 0x08, 0x82, 0x00, 0x1F, 0x08, 0x22, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x11, 0x08, 0x3C, 0x00, 0x3E, 0x21,
  0x21, 0x41, 0x41, 0x42, 0x44, 0x78, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F,
  0x08, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28,
  0x11, 0x08, 0x34, 0x02, 0x00, 0x40, 0x10, 0x3E, 0x21, 0x21, 0x41, 0x41,
  0x42, 0x44, 0xB8, 0x88, 0x88, 0x84, 0x84, 0x84, 0x1F, 0x20, 0x20, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0xFE, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x20, 0x48, 0x14,
  0x05, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08,
  0x7C, 0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0,
  0xA0, 0xC0, 0x40, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x49,
  0x22, 0x49, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x30, 0xC1, 0x06, 0x08, 0x20,
  0x00, 0x10, 0x44, 0x20, 0x90, 0x24, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x14,
  0x08, 0x82, 0x21, 0x08, 0x82, 0x00, 0x83, 0x0A, 0x14, 0x49, 0x0A, 0x18,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x0F, 0xC0, 0x1C, 0x42, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5, 0x55,
  0x40, 0x1C, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x38, 0x08, 0x28, 0x51, 0x24, 0x28, 0x60, 0x80, 0xFC, 0xA4, 0x18, 0x4D,
  0x0C, 0x18, 0x30, 0xA1, 0x42, 0x8D, 0xE8, 0x10, 0x10, 0x10, 0x20, 0x2E,
  0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x1C, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x81, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x1D, 0x22, 0x42,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x18, 0x94, 0x61, 0x9B, 0x88,
  0x20, 0x81, 0xE0, 0x03, 0x82, 0x01, 0x00, 0x81, 0xE0, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x60, 0x00,
  0x0E, 0x88, 0x88, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x46, 0x3D, 0x00,
  0x80, 0x80, 0x47, 0xC0, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x21,
  0x41, 0x42, 0x42, 0x42, 0x82, 0x82, 0x10, 0x00, 0x22, 0x44, 0x44, 0x48,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0xE0, 0x10, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24, 0x48,
  0x50, 0x70, 0x48, 0x48, 0x84, 0x84, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44,
  0x88, 0x0C, 0x63, 0x29, 0x21, 0x12, 0x11, 0x42, 0x14, 0x21, 0x42, 0x14,
  0x21, 0x84, 0x28, 0x42, 0x0E, 0x31, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42,
  0x82, 0x82, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x0E,
  0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x1D, 0x22, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04,
  0x08, 0x08, 0x08, 0x0C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x82, 0x00, 0x3D,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x0B, 0xE0, 0x24, 0xF4, 0x48, 0x88, 0x88,
  0x8C, 0x42, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x44, 0xF4, 0x86, 0x18, 0xA4,
  0x92, 0x8A, 0x30, 0x40, 0x88, 0x62, 0x29, 0x4A, 0x52, 0xA5, 0x29, 0x4C,
  0x63, 0x18, 0x84, 0x00, 0x11, 0x12, 0x14, 0x08, 0x08, 0x14, 0x24, 0x44,
  0x82, 0x10, 0xC4, 0x21, 0x10, 0x44, 0x12, 0x04, 0x80, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x80, 0xE0, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x40, 0xF8, 0x0C, 0x42, 0x08, 0x20, 0x84, 0x10, 0xC1, 0x04, 0x20, 0x82,
  0x08, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0C,
  0x41, 0x04, 0x10, 0x82, 0x30, 0xFF,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 5, 2, -13 },
  { 11, 10, 13, 9, 0, -13 },
  { 28, 7, 15, 9, 1, -14 },
  { 42, 10, 13, 12, 1, -13 },
  { 59, 9, 13, 10, 0, -13 },
  { 74, 1, 5, 3, 2, -13 },
  { 75, 5, 16, 4, 1, -13 },
  { 85, 5, 16, 4, -1, -13 },
  { 95, 7, 7, 8, 2, -14 },
  { 102, 8, 9, 9, 1, -11 },
  { 111, 3, 4, 3, -1, -2 },
  { 113, 4, 1, 5, 1, -5 },
  { 114, 1, 1, 3, 0, -1 },
  { 115, 8, 13, 5, -1, -13 },
  { 128, 7, 13, 9, 1, -13 },
  { 140, 4, 13, 9, 3, -13 },
  { 147, 8, 13, 9, 0, -13 },
  { 160, 8, 13, 9, 0, -13 },
  { 173, 8, 13, 9, 0, -13 },
  { 186, 8, 13, 9, 0, -13 },
  { 199, 8, 13, 9, 1, -13 },
  { 212, 7, 13, 9, 2, -13 },
  { 224, 8, 13, 9, 0, -13 },
  { 237, 8, 13, 9, 0, -13 },
  { 250, 3, 10, 3, 0, -10 },
  { 254, 4, 12, 3, -1, -10 },
  { 260, 8, 7, 9, 1, -10 },
  { 267, 8, 4, 9, 1, -8 },
  { 271, 8, 7, 9, 1, -10 },
  { 278, 6, 13, 6, 1, -13 },
  { 288, 11, 15, 13, 1, -13 },
  { 309, 8, 13, 8, -1, -13 },
  { 322, 8, 13, 9, 1, -13 },
  { 335, 9, 13, 9, 1, -13 },
  { 350, 9, 13, 10, 1, -13 },
  { 365, 8, 13, 8, 1, -13 },
  { 378, 8, 13, 8, 1, -13 },
  { 391, 10, 13, 11, 1, -13 },
  { 408, 10, 13, 11, 1, -13 },
  { 425, 5, 13, 4, 0, -13 },
  { 434, 7, 16, 4, -3, -13 },
  { 448, 9, 13, 8, 1, -13 },
  { 463, 5, 13, 8, 1, -13 },
  { 472, 12, 13, 13, 1, -13 },
  { 492, 10, 13, 11, 1, -13 },
  { 509, 10, 13, 11, 1, -13 },
  { 526, 8, 13, 9, 1, -13 },
  { 539, 10, 16, 11, 1, -13 },
  { 559, 8, 13, 9, 1, -13 },
  { 572, 8, 13, 8, 0, -13 },
  { 585, 7, 13, 7, 2, -13 },
  { 597, 10, 13, 11, 1, -13 },
  { 614, 8, 13, 8, 2, -13 },
  { 627, 13, 13, 13, 2, -13 },
  { 649, 10, 13, 8, -1, -13 },
  { 666, 7, 13, 7, 2, -13 },
  { 678, 9, 13, 8, 0, -13 },
  { 693, 6, 16, 5, 0, -13 },
  { 705, 2, 13, 6, 2, -13 },
  { 709, 6, 16, 5, -1, -13 },
  { 721, 7, 7, 9, 1, -13 },
  { 728, 6, 1, 6, -1, 2 },
  { 729, 2, 3, 4, 3, -14 },
  { 730, 7, 10, 9, 1, -10 },
  { 739, 8, 14, 9, 0, -14 },
  { 753, 6, 10, 7, 1, -10 },
  { 761, 8, 14, 9, 1, -14 },
  { 775, 6, 10, 8, 1, -10 },
  { 783, 9, 18, 4, -2, -14 },
  { 804, 9, 14, 9, 0, -10 },
  { 820, 8, 14, 9, 0, -14 },
  { 834, 4, 13, 3, 0, -13 },
  { 841, 7, 17, 3, -3, -13 },
  { 856, 8, 14, 7, 0, -14 },
  { 870, 4, 14, 3, 0, -14 },
  { 877, 12, 10, 13, 0, -10 },
  { 892, 8, 10, 9, 0, -10 },
  { 902, 7, 10, 9, 1, -10 },
  { 911, 8, 14, 9, 0, -10 },
  { 925, 8, 14, 9, 1, -10 },
  { 939, 6, 10, 6, 0, -10 },
  { 947, 6, 10, 7, 0, -10 },
  { 955, 4, 12, 5, 1, -12 },
  { 961, 7, 9, 9, 1, -9 },
  { 969, 6, 9, 6, 1, -9 },
  { 976, 10, 9, 10, 1, -9 },
  { 988, 8, 9, 7, -1, -9 },
  { 997, 10, 13, 7, -2, -9 },
  { 1014, 7, 9, 6, 0, -9 },
  { 1022, 6, 16, 6, 1, -13 },
  { 1034, 1, 18, 8, 4, -14 },
  { 1037, 6, 16, 6, -1, -13 },
  { 1049, 8, 1, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC18PT7B_H_
