#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x10, 0x33, 0x02, 0x30,
  0x63, 0x06, 0x20, 0x62, 0x04, 0x60, 0x46, 0x0C, 0x40, 0xC4, 0x08, 0x40,
  0x8C, 0x08, 0x81, 0x88, 0x10, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x10, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x0C, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0xE1, 0x07, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x17, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0, 0x80, 0xC1, 0x80,
  0xE0, 0xCF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x18, 0x20, 0x00, 0x40,
  0x60, 0x60, 0x01, 0x80, 0x80, 0x40, 0x06, 0x03, 0x00, 0x80, 0x08, 0x04,
  0x01, 0x00, 0x30, 0x18, 0x02, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x00, 0xC0,
  0x08, 0x06, 0x01, 0x80, 0x10, 0x08, 0x02, 0x00, 0x20, 0x30, 0x04, 0x00,
  0xC0, 0xC0, 0x18, 0x01, 0x81, 0x00, 0x30, 0x02, 0x06, 0x00, 0x60, 0x04,
  0x18, 0x00, 0xC0, 0x18, 0x20, 0x01, 0x80, 0x30, 0xC3, 0xF2, 0x00, 0x43,
  0x0C, 0x34, 0x01, 0x84, 0x30, 0x2C, 0x02, 0x18, 0xC0, 0x78, 0x0C, 0x61,
  0x00, 0xD0, 0x30, 0x86, 0x01, 0xB0, 0xC3, 0x08, 0x03, 0x3F, 0x0C, 0x30,
  0x06, 0x10, 0x10, 0x60, 0x0C, 0x00, 0x60, 0x80, 0x18, 0x00, 0x83, 0x00,
  0x30, 0x03, 0x06, 0x00, 0x40, 0x0C, 0x0C, 0x00, 0x80, 0x10, 0x10, 0x01,
  0x00, 0x60, 0x20, 0x06, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x80, 0x10,
  0x0C, 0x01, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80, 0x40, 0x04, 0x03, 0x01,
  0x80, 0x08, 0x04, 0x06, 0x00, 0x18, 0x18, 0x08, 0x00, 0x30, 0x60, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x40, 0x02, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x60, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x21, 0x80,
  0x18, 0x06, 0x30, 0x00, 0x80, 0x62, 0x00, 0x0C, 0x04, 0x60, 0x00, 0x40,
  0xC6, 0x00, 0x06, 0x18, 0x40, 0x00, 0x21, 0x04, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x16, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x36, 0x06, 0x00, 0x0C, 0x20, 0x30, 0x01, 0x83, 0x01,
  0xC0, 0x70, 0x10, 0x0F, 0xFC, 0x01, 0x80, 0x08, 0x00, 0x00, 0x13, 0x33,
  0x22, 0x66, 0x44, 0x4C, 0x88, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x08, 0x02, 0x01, 0xC0, 0x40, 0x0C, 0x18, 0x00, 0x62, 0x00, 0x06, 0x40,
  0x60, 0x3F, 0xFC, 0x03, 0x00, 0x00, 0xA0, 0x00, 0x22, 0x00, 0x08, 0x40,
  0x06, 0x04, 0x01, 0x80, 0x80, 0x60, 0x08, 0x08, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x08, 0x30,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7D, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x62,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x04, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x83,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x07, 0x01, 0xB0, 0x32, 0x0E, 0x21, 0x82, 0x30, 0x6C, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x04, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0x80, 0x60, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x0C, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xA0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x98, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20, 0x00, 0x60, 0x10,
  0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x40, 0x18, 0x00, 0x20, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x08, 0x0C, 0x00, 0x04, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x20, 0xFF, 0x80, 0x23, 0x81, 0xC0,
  0x66, 0x00, 0x60, 0x68, 0x00, 0x30, 0x50, 0x00, 0x30, 0x70, 0x00, 0x10,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x60, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x18, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0E,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x20, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x9C,
  0x00, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x08, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x60,
  0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18, 0x07, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC0,
  0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01,
  0x82, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88,
  0x00, 0x01, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x38, 0xC0,
  0x00, 0x71, 0x80, 0x01, 0xC1, 0x00, 0x06, 0x83, 0x00, 0x1B, 0x03, 0x80,
  0xE6, 0x01, 0xFF, 0x08, 0x00, 0x40, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x38, 0x00, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x0E, 0x07, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x01,
  0xC0, 0x70, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x00, 0x20,
  0xC0, 0x03, 0xFE, 0x01, 0x86, 0x00, 0x70, 0x30, 0x0C, 0x60, 0x06, 0x01,
  0x80, 0x63, 0x00, 0x60, 0x0C, 0x03, 0x10, 0x06, 0x00, 0x40, 0x19, 0x80,
  0x20, 0x02, 0x00, 0xCC, 0x03, 0x00, 0x30, 0x06, 0x40, 0x10, 0x01, 0x80,
  0x26, 0x01, 0x80, 0x08, 0x01, 0x30, 0x08, 0x00, 0x40, 0x19, 0x80, 0xC0,
  0x06, 0x00, 0xC8, 0x06, 0x00, 0x30, 0x04, 0x40, 0x20, 0x01, 0x00, 0x22,
  0x01, 0x00, 0x18, 0x03, 0x10, 0x08, 0x00, 0xC0, 0x11, 0x80, 0x40, 0x0E,
  0x01, 0x8C, 0x02, 0x00, 0x70, 0x08, 0x60, 0x10, 0x07, 0x80, 0xC1, 0x00,
  0xC0, 0x6C, 0x0C, 0x08, 0x03, 0x06, 0x20, 0xC0, 0x40, 0x1F, 0xE1, 0xFC,
  0x03, 0x00, 0x3C, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00, 0x10,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x04, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x10,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x00, 0x20,
  0x1F, 0x80, 0x08, 0x00, 0x30, 0x02, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x0E, 0x01, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0C, 0x00, 0x30, 0x02, 0x00, 0x07, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x81, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x70, 0x0C, 0x03,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x03, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x07, 0xE0, 0x00, 0x20,
  0x01, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xE0, 0x04, 0x00, 0x0E, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x03, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x3E, 0x00,
  0x70, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE2, 0x00, 0x07, 0xFF, 0x10,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x23,
  0x80, 0x00, 0x03, 0x34, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x00, 0xB0, 0x80,
  0x00, 0x05, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xA0, 0x1A, 0x00, 0x00, 0x03, 0xC0,
  0x34, 0x00, 0x00, 0x0D, 0x80, 0x48, 0x00, 0x00, 0x12, 0x00, 0x90, 0x00,
  0x00, 0x64, 0x03, 0x30, 0x00, 0x00, 0x98, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x0C, 0xC0, 0x00, 0x04, 0x60, 0x10, 0x80, 0x00, 0x18, 0x80, 0x21, 0x00,
  0x00, 0x61, 0x00, 0xC2, 0x00, 0x00, 0xC6, 0x01, 0x84, 0x00, 0x03, 0x0C,
  0x03, 0x08, 0x00, 0x04, 0x10, 0x04, 0x18, 0x00, 0x18, 0x20, 0x08, 0x30,
  0x00, 0x20, 0x40, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x01, 0x03,
  0x00, 0x80, 0x80, 0x06, 0x04, 0x01, 0x01, 0x00, 0x18, 0x08, 0x02, 0x02,
  0x00, 0x30, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x20, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x40, 0x18, 0x06, 0x00, 0x81, 0x80,
  0x20, 0x08, 0x01, 0x06, 0x00, 0x40, 0x10, 0x03, 0x0C, 0x00, 0x80, 0x60,
  0x06, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x40, 0x06, 0x01, 0x00, 0x09, 0x80,
  0x08, 0x02, 0x00, 0x12, 0x00, 0x10, 0x04, 0x00, 0x2C, 0x00, 0x20, 0x18,
  0x00, 0x50, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x1A, 0x00, 0x00, 0x60, 0x36, 0x00,
  0x00, 0x80, 0x4C, 0x00, 0x01, 0x00, 0x88, 0x00, 0x06, 0x03, 0x18, 0x00,
  0x0C, 0x06, 0x30, 0x00, 0x10, 0x0C, 0x20, 0x00, 0x20, 0x10, 0x60, 0x00,
  0x40, 0x20, 0xC0, 0x01, 0x80, 0xC0, 0x80, 0x03, 0x01, 0x81, 0x80, 0x04,
  0x03, 0x03, 0x00, 0x08, 0x04, 0x02, 0x00, 0x30, 0x08, 0x06, 0x00, 0x60,
  0x30, 0x0C, 0x00, 0xC0, 0x60, 0x08, 0x01, 0x00, 0x80, 0x18, 0x02, 0x01,
  0x00, 0x30, 0x0C, 0x02, 0x00, 0x20, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x18,
  0x00, 0xC0, 0x40, 0x20, 0x00, 0x80, 0x80, 0x40, 0x01, 0x83, 0x01, 0x80,
  0x03, 0x06, 0x03, 0x00, 0x02, 0x08, 0x06, 0x00, 0x06, 0x10, 0x08, 0x00,
  0x0C, 0x20, 0x10, 0x00, 0x08, 0xC0, 0x60, 0x00, 0x19, 0x80, 0xC0, 0x00,
  0x32, 0x01, 0x00, 0x00, 0x24, 0x02, 0x00, 0x00, 0x68, 0x04, 0x00, 0x00,
  0xF0, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x02,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x60, 0x7E, 0x00, 0x20, 0x03, 0x80, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x02, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0x80, 0x07, 0x00, 0x40, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x60, 0xFE, 0x00, 0x20, 0x03, 0x80, 0x10, 0x00, 0x60, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x04, 0x00,
  0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x07, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x20, 0x08, 0x00, 0x30, 0x04, 0x00, 0x18,
  0x03, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80,
  0x60, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x3C, 0x01,
  0x80, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x08, 0x00, 0x1C, 0x03, 0xC0, 0x1C, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01,
  0x80, 0x20, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x16, 0x00, 0x01, 0xC0, 0x00, 0x6C,
  0x00, 0x07, 0x80, 0x00, 0x98, 0x00, 0x0B, 0x00, 0x03, 0x30, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x4C, 0x00, 0x08, 0xC0, 0x01, 0x98, 0x00, 0x31,
  0x80, 0x02, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x10,
  0x10, 0x01, 0x02, 0x00, 0x60, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x08,
  0x08, 0x01, 0x00, 0x80, 0x30, 0x10, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x04, 0x03, 0x00, 0x80, 0x40, 0x08, 0x0C,
  0x01, 0x01, 0x80, 0x10, 0x18, 0x02, 0x03, 0x00, 0x20, 0x20, 0x04, 0x04,
  0x00, 0x40, 0xC0, 0x08, 0x18, 0x00, 0x81, 0x00, 0x10, 0x20, 0x01, 0x06,
  0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0x86,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x11, 0x80, 0x02, 0x10, 0x00, 0x23,
  0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x0C, 0x80, 0x00, 0x98, 0x00, 0x1B,
  0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x05,
  0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x80, 0x08, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09,
  0x00, 0x00, 0x32, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x18, 0x10, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x03, 0x00, 0x80, 0x06, 0x03,
  0x00, 0x04, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x23, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x90, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02,
  0x02, 0x02, 0x03, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x18, 0x06, 0x00, 0x08, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x00, 0x1F, 0x83, 0x00, 0x78,
  0xE3, 0x01, 0xC0, 0x22, 0x03, 0x80, 0x12, 0x02, 0x00, 0x1A, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0x40, 0x00, 0xE0, 0x40, 0x01, 0xE0, 0x60, 0x03,
  0x40, 0x60, 0x06, 0x40, 0x30, 0x0C, 0x40, 0x18, 0x18, 0x40, 0x0F, 0xF0,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x07, 0xF0, 0x03, 0x0E,
  0x38, 0x03, 0x30, 0x0C, 0x02, 0x60, 0x06, 0x02, 0xC0, 0x02, 0x06, 0x80,
  0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00,
  0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x70, 0x00, 0x30, 0x78, 0x00,
  0x20, 0x48, 0x00, 0x60, 0x4C, 0x00, 0xC0, 0x46, 0x03, 0x80, 0xC3, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x1C, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0x82, 0x00, 0x1E, 0x78, 0x40, 0x0E, 0x01, 0x88,
  0x03, 0x00, 0x1B, 0x00, 0x40, 0x01, 0x60, 0x18, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x04, 0x00, 0x0F, 0x00, 0x80,
  0x03, 0x40, 0x18, 0x00, 0x68, 0x03, 0x00, 0x19, 0x00, 0x30, 0x0E, 0x60,
  0x03, 0x03, 0x88, 0x00, 0x3F, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0x3C, 0x01, 0x80, 0x60, 0x30, 0x02, 0x06, 0x00, 0x20,
  0xC0, 0x03, 0x18, 0x00, 0x31, 0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x06,
  0x60, 0x00, 0xC6, 0x00, 0x18, 0x40, 0x07, 0x0C, 0x01, 0xC0, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x1C, 0x06, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x80, 0x1E, 0x78, 0x40, 0x38, 0x06, 0x20, 0x30, 0x01, 0xB0, 0x10, 0x00,
  0x58, 0x18, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20,
  0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x40, 0x00, 0xF0,
  0x20, 0x00, 0xD0, 0x18, 0x00, 0x68, 0x0C, 0x00, 0x6C, 0x03, 0x00, 0xE6,
  0x00, 0xC0, 0xE2, 0x00, 0x3F, 0xC1, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x06, 0x00, 0x70, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0xFE, 0x00, 0xC7, 0x8F, 0x01, 0x98, 0x06, 0x02, 0x60,
  0x06, 0x05, 0x80, 0x04, 0x1E, 0x00, 0x08, 0x38, 0x00, 0x10, 0x70, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x30,
  0x00, 0x80, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x10, 0xC0, 0x00, 0x23, 0x80, 0x00, 0x4D, 0x80, 0x01, 0x93, 0x00, 0x02,
  0x42, 0x00, 0x05, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x40, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x40, 0x01, 0x00, 0x80, 0x03,
  0x03, 0x00, 0x02, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x00, 0x03, 0x07, 0xE0, 0x0F, 0xC0, 0x18, 0xE3, 0x81,
  0xC7, 0x80, 0x8C, 0x06, 0x18, 0x0C, 0x04, 0x80, 0x11, 0x80, 0x30, 0x28,
  0x00, 0xD8, 0x00, 0x83, 0xC0, 0x07, 0x80, 0x04, 0x1C, 0x00, 0x38, 0x00,
  0x20, 0xC0, 0x01, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x30, 0x00,
  0x60, 0x00, 0xC3, 0x00, 0x02, 0x00, 0x06, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x40,
  0x00, 0xC3, 0x00, 0x02, 0x00, 0x06, 0x18, 0x00, 0x10, 0x00, 0x20, 0x80,
  0x01, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x40, 0x00,
  0xC3, 0x00, 0x02, 0x00, 0x06, 0x18, 0x00, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x40, 0x00, 0xC3,
  0x00, 0x02, 0x00, 0x06, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0x01, 0x80,
  0x01, 0x04, 0x00, 0x08, 0x00, 0x18, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x03,
  0x07, 0xF0, 0x06, 0x3C, 0x78, 0x08, 0xC0, 0x30, 0x13, 0x00, 0x30, 0x2C,
  0x00, 0x60, 0xF0, 0x00, 0x41, 0xC0, 0x00, 0x83, 0x80, 0x01, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00,
  0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC7, 0x80, 0x18, 0x07, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x32,
  0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0x3F, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC1, 0xFC, 0x00, 0x30, 0xE3, 0x80, 0x08,
  0xE0, 0x30, 0x02, 0x60, 0x06, 0x00, 0xB0, 0x00, 0x80, 0x68, 0x00, 0x30,
  0x1E, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x40, 0x60, 0x00,
  0x10, 0x38, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x18, 0x1C, 0x00,
  0x0C, 0x07, 0x80, 0x03, 0x01, 0x20, 0x01, 0x80, 0x4C, 0x01, 0xC0, 0x11,
  0x80, 0xE0, 0x0C, 0x3F, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0x00, 0x78, 0xE1, 0x01, 0xC0, 0x31, 0x03, 0x00, 0x19,
  0x02, 0x00, 0x0B, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x08, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x40, 0x00, 0xF0,
  0x40, 0x01, 0xA0, 0x60, 0x01, 0xA0, 0x60, 0x03, 0x20, 0x30, 0x06, 0x60,
  0x18, 0x1C, 0x60, 0x0F, 0xF0, 0x40, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE0,
  0x63, 0xC8, 0x08, 0xC0, 0x01, 0x30, 0x00, 0x2C, 0x00, 0x0D, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1E, 0x3F, 0x03, 0x00, 0x30, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x08, 0x00, 0x60, 0xE0, 0x1C, 0x03, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x03, 0xFF, 0x7F, 0xFC, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40,
  0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xC0, 0x80, 0x06,
  0x81, 0x00, 0x19, 0x03, 0x00, 0x66, 0x03, 0x03, 0x88, 0x03, 0xFC, 0x10,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10,
  0x40, 0x03, 0x04, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x06, 0x03, 0x00, 0x20, 0x20, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x31,
  0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x02, 0x80, 0x04, 0xC0,
  0x06, 0x80, 0x0C, 0xC0, 0x04, 0x80, 0x08, 0xC0, 0x0C, 0x80, 0x18, 0xC0,
  0x08, 0x80, 0x10, 0xC0, 0x08, 0x80, 0x30, 0x40, 0x18, 0x80, 0x30, 0x40,
  0x10, 0x80, 0x20, 0x40, 0x30, 0x80, 0x60, 0x40, 0x20, 0x80, 0x40, 0x40,
  0x60, 0x80, 0xC0, 0x40, 0x40, 0x80, 0x80, 0x40, 0xC0, 0xC1, 0x80, 0x40,
  0x80, 0xC1, 0x00, 0x41, 0x80, 0xC1, 0x00, 0x41, 0x00, 0xC3, 0x00, 0x43,
  0x00, 0xC2, 0x00, 0x42, 0x00, 0xC6, 0x00, 0x46, 0x00, 0x44, 0x00, 0x44,
  0x00, 0x4C, 0x00, 0x4C, 0x00, 0x48, 0x00, 0x48, 0x00, 0x58, 0x00, 0x58,
  0x00, 0x50, 0x00, 0x50, 0x00, 0x50, 0x00, 0x50, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x10, 0x06, 0x00, 0x08, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x02, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x40, 0x00, 0x20, 0x06,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x70, 0xF0, 0x03, 0xC0,
  0x1C, 0x06, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 40, 12, 1, -40 },
  { 56, 12, 14, 16, 6, -40 },
  { 77, 29, 40, 29, 1, -40 },
  { 222, 24, 46, 26, 2, -43 },
  { 360, 31, 42, 38, 4, -41 },
  { 523, 28, 42, 31, 1, -41 },
  { 670, 4, 14, 9, 6, -40 },
  { 677, 15, 49, 14, 2, -40 },
  { 769, 16, 49, 14, -4, -40 },
  { 867, 19, 20, 25, 7, -42 },
  { 915, 24, 26, 28, 3, -33 },
  { 993, 7, 13, 10, -2, -6 },
  { 1005, 13, 2, 16, 2, -16 },
  { 1009, 3, 3, 11, 1, -3 },
  { 1011, 23, 40, 17, -2, -40 },
  { 1126, 23, 42, 27, 3, -41 },
  { 1247, 12, 40, 27, 8, -40 },
  { 1307, 25, 41, 27, 0, -41 },
  { 1436, 26, 42, 27, 0, -41 },
  { 1573, 25, 40, 27, 0, -40 },
  { 1698, 25, 41, 27, 1, -40 },
  { 1827, 24, 42, 27, 3, -41 },
  { 1953, 23, 40, 27, 5, -40 },
  { 2068, 25, 42, 27, 1, -41 },
  { 2200, 23, 42, 27, 2, -41 },
  { 2321, 9, 30, 11, 1, -30 },
  { 2355, 13, 37, 11, -3, -30 },
  { 2416, 24, 24, 28, 3, -32 },
  { 2488, 24, 13, 28, 3, -26 },
  { 2527, 24, 24, 28, 3, -32 },
  { 2599, 18, 41, 19, 3, -41 },
  { 2692, 37, 45, 40, 2, -40 },
  { 2901, 26, 40, 26, -3, -40 },
  { 3031, 26, 40, 29, 2, -40 },
  { 3161, 27, 42, 28, 4, -41 },
  { 3303, 29, 40, 32, 2, -40 },
  { 3448, 26, 40, 26, 2, -40 },
  { 3578, 26, 40, 24, 2, -40 },
  { 3708, 29, 42, 34, 4, -41 },
  { 3861, 31, 40, 33, 2, -40 },
  { 4016, 17, 40, 13, -1, -40 },
  { 4101, 21, 50, 11, -9, -40 },
  { 4233, 29, 40, 26, 2, -40 },
  { 4378, 17, 40, 24, 2, -40 },
  { 4463, 39, 40, 41, 2, -40 },
  { 4658, 31, 40, 33, 2, -40 },
  { 4813, 29, 42, 35, 4, -41 },
  { 4966, 25, 40, 27, 2, -40 },
  { 5091, 29, 51, 35, 4, -41 },
  { 5276, 25, 40, 27, 2, -40 },
  { 5401, 26, 42, 25, 0, -41 },
  { 5538, 23, 40, 23, 5, -40 },
  { 5653, 30, 41, 33, 4, -40 },
  { 5807, 25, 40, 26, 5, -40 },
  { 5932, 39, 40, 42, 6, -40 },
  { 6127, 31, 40, 24, -3, -40 },
  { 6282, 23, 40, 23, 5, -40 },
  { 6397, 29, 40, 25, -1, -40 },
  { 6542, 21, 49, 16, -1, -40 },
  { 6671, 8, 40, 17, 6, -40 },
  { 6711, 21, 49, 16, -4, -40 },
  { 6840, 24, 23, 28, 2, -40 },
  { 6909, 19, 1, 19, -5, 6 },
  { 6912, 6, 9, 12, 8, -43 },
  { 6919, 24, 31, 27, 2, -30 },
  { 7012, 24, 44, 28, 1, -43 },
  { 7144, 19, 31, 22, 3, -30 },
  { 7218, 27, 44, 28, 2, -43 },
  { 7367, 20, 31, 24, 3, -30 },
  { 7445, 28, 56, 13, -7, -43 },
  { 7641, 25, 43, 28, 1, -30 },
  { 7776, 23, 43, 27, 1, -43 },
  { 7900, 11, 40, 11, 1, -40 },
  { 7955, 20, 53, 11, -8, -40 },
  { 8088, 23, 43, 22, 1, -43 },
  { 8212, 11, 43, 10, 1, -43 },
  { 8272, 37, 30, 41, 1, -30 },
  { 8411, 23, 30, 27, 1, -30 },
  { 8498, 22, 31, 27, 3, -30 },
  { 8584, 26, 43, 28, -1, -30 },
  { 8724, 24, 43, 28, 2, -30 },
  { 8853, 19, 30, 18, 1, -30 },
  { 8925, 20, 31, 21, 0, -30 },
  { 9003, 14, 38, 15, 2, -37 },
  { 9070, 23, 31, 27, 2, -30 },
  { 9160, 20, 30, 20, 3, -30 },
  { 9235, 32, 30, 33, 3, -30 },
  { 9355, 25, 30, 22, -2, -30 },
  { 9449, 29, 44, 21, -6, -30 },
  { 9609, 22, 30, 20, -1, -30 },
  { 9692, 19, 49, 18, 2, -40 },
  { 9809, 2, 57, 26, 13, -43 },
  { 9824, 19, 49, 18, -3, -40 },
  { 9941, 24, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC56PT7B_H_
