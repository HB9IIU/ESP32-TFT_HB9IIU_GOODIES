#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x57, 0x6C, 0xC0, 0x79, 0x3C, 0x5A, 0xB7, 0x70,
  0x66, 0x5A, 0xE0, 0xC0, 0x6A, 0xA0, 0xFC, 0xB0, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAC, 0x65, 0x1E, 0x2E,
  0xF2, 0x71, 0x9E, 0x73, 0xDE, 0xD6, 0x80, 0x6D, 0x5E, 0x77, 0x9C, 0x90,
  0x98, 0x38, 0x80, 0xE0, 0xC7, 0x00, 0x65, 0x48, 0x7D, 0xF7, 0xAA, 0x30,
  0x2F, 0xDA, 0x75, 0xA9, 0xE0, 0x78, 0x88, 0xE0, 0x75, 0x99, 0xE0, 0x6A,
  0xCC, 0x6B, 0xC8, 0x78, 0xA9, 0xF0, 0x55, 0xB9, 0x90, 0x5A, 0x80, 0x55,
  0x70, 0x56, 0xCA, 0xA0, 0x5A, 0xC0, 0x4A, 0x77, 0xDA, 0x80, 0x55, 0xBA,
  0xA0, 0x79, 0x99, 0xF0, 0x6F, 0xC8, 0x79, 0x99, 0xD2, 0x6F, 0xDA, 0x71,
  0x1E, 0xF2, 0x48, 0x55, 0x99, 0xE0, 0xBB, 0x48, 0xCE, 0xAD, 0x4A, 0x00,
  0x69, 0x6A, 0xBA, 0x48, 0x65, 0x4E, 0x72, 0x49, 0x00, 0xF8, 0x55, 0x60,
  0x4E, 0x80, 0xE0, 0x80, 0x76, 0xF0, 0x4E, 0xDE, 0x72, 0x60, 0x16, 0xAA,
  0xE0, 0x77, 0x60, 0x36, 0x44, 0x44, 0x80, 0x76, 0xF3, 0x80, 0x4E, 0xDA,
  0x78, 0x15, 0x58, 0x57, 0x6A, 0xF8, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76,
  0xF0, 0x76, 0xF9, 0x00, 0x76, 0xF2, 0x40, 0x6A, 0xE7, 0x6A, 0x80, 0xB6,
  0xF0, 0xB7, 0x40, 0xBB, 0xEA, 0xA9, 0x60, 0x55, 0x64, 0x48, 0x6A, 0x60,
  0x69, 0x49, 0x00, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 1, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 4, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 1, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 1, 6, 2, 0, -5 },
  { 19, 2, 2, 3, 1, -5 },
  { 20, 3, 3, 4, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 1, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 1, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 2, 5, 3, 1, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 1, 4, 1, 0, -4 },
  { 48, 1, 5, 1, 0, -4 },
  { 49, 3, 3, 4, 0, -4 },
  { 51, 3, 1, 4, 0, -3 },
  { 52, 3, 3, 4, 0, -4 },
  { 54, 3, 5, 2, 0, -5 },
  { 56, 5, 6, 5, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 2, 5, 2, 0, -5 },
  { 83, 2, 6, 1, -1, -5 },
  { 85, 4, 5, 3, 0, -5 },
  { 88, 2, 5, 3, 0, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 4, 6, 4, 0, -5 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 3, 5, 3, 1, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 5, 3, 1, -5 },
  { 116, 5, 5, 5, 1, -5 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 3, 5, 3, 1, -5 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 3, 6, 2, 0, -5 },
  { 129, 1, 5, 2, 1, -5 },
  { 130, 2, 6, 2, 0, -5 },
  { 132, 3, 3, 3, 0, -5 },
  { 134, 3, 1, 2, -1, 0 },
  { 135, 1, 1, 2, 1, -5 },
  { 136, 3, 4, 3, 0, -4 },
  { 138, 3, 5, 3, 0, -5 },
  { 140, 3, 4, 3, 0, -4 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 4, 7, 2, -1, -5 },
  { 151, 3, 6, 3, 0, -4 },
  { 154, 3, 5, 3, 0, -5 },
  { 156, 1, 5, 1, 0, -5 },
  { 157, 2, 7, 1, -1, -5 },
  { 159, 3, 5, 3, 0, -5 },
  { 161, 1, 5, 1, 0, -5 },
  { 162, 5, 4, 5, 0, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 3, 6, 3, 0, -4 },
  { 172, 3, 6, 4, 0, -4 },
  { 175, 2, 4, 2, 0, -4 },
  { 176, 2, 4, 3, 0, -4 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 4, 6, 3, -1, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 3, 6, 2, 0, -5 },
  { 195, 1, 7, 3, 1, -5 },
  { 196, 2, 6, 2, 0, -5 },
  { 198, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC7PT7B_H_
