#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x21, 0x01, 0x18, 0x18,
  0xC0, 0xC6, 0x04, 0x20, 0x21, 0x01, 0x18, 0x18, 0xC0, 0xC4, 0x04, 0x20,
  0x21, 0x01, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEC, 0xF8, 0x01,
  0x83, 0x03, 0x01, 0xC0, 0x80, 0x00, 0x60, 0x20, 0x00, 0x30, 0x08, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x07, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x08, 0x38, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00,
  0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x18,
  0x00, 0x08, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x80, 0x80, 0x61,
  0xC0, 0x3F, 0x13, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x00,
  0xF7, 0x80, 0x00, 0xC0, 0x70, 0x60, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x10,
  0x0C, 0x03, 0x00, 0x0C, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x01,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x03,
  0x01, 0x00, 0x18, 0x00, 0x80, 0xC0, 0x04, 0x00, 0x20, 0x60, 0x01, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x06, 0x0C, 0x00, 0x30, 0x01, 0x06, 0x02, 0x0C,
  0x00, 0xC1, 0x87, 0xF3, 0x00, 0x30, 0xC3, 0x86, 0xC0, 0x08, 0x21, 0x80,
  0xB0, 0x06, 0x18, 0xC0, 0x34, 0x01, 0x0C, 0x30, 0x0D, 0x80, 0xC2, 0x18,
  0x03, 0x60, 0x61, 0x86, 0x00, 0xCE, 0x70, 0xC3, 0x00, 0x31, 0xF0, 0x20,
  0xC0, 0x0C, 0x00, 0x18, 0x30, 0x03, 0x00, 0x0C, 0x08, 0x00, 0xC0, 0x02,
  0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x02, 0x00,
  0x30, 0x10, 0x01, 0x80, 0x18, 0x04, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18,
  0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x18, 0x00, 0x40, 0x18, 0x04, 0x00, 0x10,
  0x0C, 0x03, 0x00, 0x06, 0x06, 0x01, 0x80, 0x01, 0xC3, 0x80, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x04, 0x00, 0x04, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x20, 0x70, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x04, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x46, 0x00, 0x60, 0x06, 0x60, 0x01, 0x00,
  0x26, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x30, 0x13, 0x00, 0x01, 0x81, 0x98,
  0x00, 0x06, 0x18, 0xC0, 0x00, 0x30, 0xC4, 0x00, 0x00, 0xCC, 0x20, 0x00,
  0x06, 0xC1, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x68, 0x18, 0x00, 0x06, 0x60, 0x60, 0x00, 0x61, 0x03,
  0x80, 0x0E, 0x0C, 0x0F, 0x01, 0xC0, 0x30, 0x1F, 0xF8, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0x21,
  0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x40, 0x18, 0x03, 0x80, 0x80, 0x06, 0x04, 0x00,
  0x0C, 0x20, 0x00, 0x39, 0x01, 0xC0, 0x73, 0xFE, 0x00, 0xE0, 0x00, 0x0A,
  0x00, 0x01, 0x90, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x18, 0x18, 0x01,
  0x80, 0x40, 0x18, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF,
  0xFC, 0x5F, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x0C, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x07, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x1E, 0x03, 0xA0, 0x31, 0x07, 0x18, 0x60, 0xCE, 0x06,
  0xE0, 0x24, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x01, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x10, 0x18,
  0x00, 0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x03, 0xC0, 0x03,
  0x0F, 0xFE, 0x00, 0xC7, 0x01, 0xC0, 0x27, 0x00, 0x18, 0x0B, 0x00, 0x03,
  0x06, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x10, 0x70, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x03, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x00, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x04, 0x04, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x03, 0x00, 0x07, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x07, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x82, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0xD0, 0x18, 0x00, 0x64, 0x07, 0x00, 0x73, 0x00, 0x71,
  0xF0, 0x80, 0x0F, 0xF0, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x08, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x03, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0xF8, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0xFE, 0x00, 0x61, 0x80, 0x07, 0xFF, 0x00, 0xC6, 0x00, 0x38, 0x06, 0x00,
  0x8C, 0x00, 0xE0, 0x08, 0x01, 0x30, 0x03, 0x00, 0x10, 0x02, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x80, 0x18, 0x00, 0xC0, 0x1B, 0x00, 0x60, 0x01, 0x00,
  0x36, 0x00, 0xC0, 0x02, 0x00, 0x68, 0x03, 0x00, 0x0C, 0x00, 0xD0, 0x06,
  0x00, 0x18, 0x01, 0x60, 0x08, 0x00, 0x20, 0x02, 0xC0, 0x30, 0x00, 0xC0,
  0x0D, 0x80, 0x60, 0x01, 0x80, 0x1B, 0x00, 0xC0, 0x03, 0x00, 0x26, 0x01,
  0x00, 0x0C, 0x00, 0xC8, 0x02, 0x00, 0x18, 0x01, 0x90, 0x04, 0x00, 0x70,
  0x06, 0x20, 0x08, 0x00, 0xA0, 0x0C, 0x40, 0x18, 0x03, 0x40, 0x30, 0x80,
  0x30, 0x0C, 0x80, 0xC1, 0x80, 0x30, 0x31, 0x83, 0x03, 0x00, 0x70, 0xC3,
  0x9C, 0x06, 0x00, 0x7F, 0x03, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x04,
  0x00, 0x7F, 0xFF, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x10,
  0x00, 0xF0, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x0C, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x10,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x38, 0x02, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x70, 0x00, 0x80,
  0x07, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x18, 0x02, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x31, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x08, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0x40, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x02, 0x07, 0x00, 0x00, 0x02, 0x0E,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x7C,
  0x00, 0x00, 0x04, 0xCC, 0x00, 0x00, 0x05, 0x84, 0x00, 0x00, 0x0D, 0x06,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0xD0, 0x00, 0x00, 0x02, 0xC0, 0x34, 0x00,
  0x00, 0x01, 0xA0, 0x0D, 0x00, 0x00, 0x00, 0xD8, 0x02, 0x40, 0x00, 0x00,
  0x36, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x66, 0x00, 0x00, 0x06, 0x40,
  0x19, 0x80, 0x00, 0x03, 0x10, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x01, 0x08,
  0x00, 0x00, 0x63, 0x00, 0xC2, 0x00, 0x00, 0x10, 0xC0, 0x30, 0x80, 0x00,
  0x0C, 0x20, 0x0C, 0x30, 0x00, 0x06, 0x08, 0x02, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x18,
  0x10, 0x00, 0x18, 0x10, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x01, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x40, 0x40, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x30, 0x08, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x08, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x18,
  0x03, 0x00, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC1, 0x80, 0x08, 0x03, 0x00, 0x30, 0x60, 0x02, 0x00, 0x80,
  0x04, 0x30, 0x01, 0x80, 0x20, 0x01, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x46,
  0x00, 0x18, 0x06, 0x00, 0x19, 0x00, 0x04, 0x01, 0x80, 0x06, 0xC0, 0x03,
  0x00, 0x40, 0x01, 0xA0, 0x00, 0xC0, 0x30, 0x00, 0x78, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x34, 0x00, 0x00, 0x20,
  0x0D, 0x80, 0x00, 0x08, 0x02, 0x60, 0x00, 0x06, 0x01, 0x88, 0x00, 0x01,
  0x80, 0x63, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x10, 0x04, 0x10, 0x00,
  0x04, 0x01, 0x06, 0x00, 0x03, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x30, 0x20,
  0x00, 0x30, 0x0C, 0x0C, 0x00, 0x08, 0x02, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x40, 0x01, 0x80, 0x60, 0x18, 0x00, 0x60, 0x18, 0x06, 0x00, 0x10, 0x06,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x30, 0x03, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x08, 0x03, 0x00, 0x08, 0x02,
  0x00, 0x80, 0x03, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x10,
  0x18, 0x06, 0x00, 0x06, 0x04, 0x01, 0x00, 0x01, 0x83, 0x00, 0x40, 0x00,
  0x20, 0xC0, 0x30, 0x00, 0x0C, 0x30, 0x0C, 0x00, 0x03, 0x08, 0x03, 0x00,
  0x00, 0x42, 0x00, 0x80, 0x00, 0x19, 0x80, 0x20, 0x00, 0x06, 0x60, 0x18,
  0x00, 0x00, 0x98, 0x06, 0x00, 0x00, 0x34, 0x01, 0x80, 0x00, 0x0D, 0x00,
  0x40, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x40, 0x07, 0x00, 0x04, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x70, 0x04, 0x00,
  0x1C, 0x00, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x40,
  0x07, 0x00, 0x04, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0, 0x04, 0x00, 0x78, 0x00,
  0xFF, 0xFE, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01,
  0x80, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0xC0, 0x01, 0x00, 0x10, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80, 0x00,
  0x14, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x40,
  0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x40, 0x00, 0xC3, 0x00,
  0x06, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x30, 0x00, 0x41,
  0x00, 0x06, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00,
  0xC0, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x40, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x43, 0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x01, 0x8C, 0x00, 0x04,
  0x60, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00, 0x19, 0x80, 0x00, 0x4C, 0x00,
  0x06, 0x60, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x04, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x08, 0x03, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x06, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x08,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x18, 0x03, 0x00, 0x02, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x06, 0x18, 0x20, 0xC1, 0x82,
  0x0C, 0x10, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0xC0, 0x38, 0x0C, 0x60,
  0x30, 0x03, 0x20, 0x30, 0x00, 0x90, 0x30, 0x00, 0x68, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00,
  0x02, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x70, 0x40, 0x00, 0x38, 0x30,
  0x00, 0x3C, 0x18, 0x00, 0x34, 0x0C, 0x00, 0x32, 0x03, 0x00, 0x31, 0x01,
  0xC0, 0x39, 0x80, 0x70, 0x70, 0xC0, 0x1F, 0xF0, 0x40, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x01, 0xF0,
  0x00, 0x61, 0xFF, 0x80, 0x08, 0x70, 0x38, 0x01, 0x18, 0x01, 0x80, 0x66,
  0x00, 0x30, 0x0D, 0x80, 0x03, 0x01, 0x60, 0x00, 0x60, 0x28, 0x00, 0x04,
  0x07, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0D, 0x00, 0x03, 0x01, 0xB0,
  0x00, 0xC0, 0x23, 0x00, 0x30, 0x04, 0x30, 0x1C, 0x01, 0x83, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x38, 0x02,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x60, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0xFF, 0x83, 0x00, 0x1C, 0x07, 0x10, 0x01, 0x80, 0x18, 0x80,
  0x18, 0x00, 0x6C, 0x01, 0x80, 0x01, 0x60, 0x18, 0x00, 0x0F, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0xE0, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x03, 0x80,
  0x40, 0x00, 0x1C, 0x02, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x1A, 0x00, 0xC0,
  0x01, 0xD0, 0x06, 0x00, 0x0D, 0x80, 0x18, 0x00, 0xCC, 0x00, 0xE0, 0x1C,
  0x40, 0x03, 0x81, 0xC2, 0x00, 0x0F, 0xF8, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0x03, 0x00, 0x70, 0x06,
  0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x20, 0x00,
  0x61, 0x80, 0x03, 0x06, 0x00, 0x38, 0x10, 0x0F, 0x80, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x08, 0x07, 0x80, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x20, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0x00, 0x38, 0x0E, 0x20, 0x06,
  0x00, 0x22, 0x00, 0xC0, 0x03, 0x20, 0x18, 0x00, 0x16, 0x03, 0x00, 0x01,
  0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x18, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x07, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0xE0,
  0x20, 0x00, 0x0E, 0x02, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x34, 0x03, 0x00,
  0x07, 0x40, 0x30, 0x00, 0x6C, 0x01, 0x80, 0x0C, 0xC0, 0x1C, 0x03, 0x88,
  0x00, 0xE0, 0x70, 0x80, 0x07, 0xFC, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x07, 0xC0, 0x06, 0x1F, 0xF8, 0x02,
  0x1C, 0x0E, 0x01, 0x18, 0x01, 0x81, 0x98, 0x00, 0xC0, 0xD8, 0x00, 0x20,
  0x58, 0x00, 0x10, 0x38, 0x00, 0x08, 0x18, 0x00, 0x04, 0x1C, 0x00, 0x02,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x20, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x07, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x10,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x46, 0xC0, 0x00, 0x26, 0x60, 0x00, 0x36, 0x18, 0x00, 0x1E, 0x0C, 0x00,
  0x0E, 0x02, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x20,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x00, 0x40, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00,
  0x04, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x81, 0xF0, 0x00, 0xF0, 0x00, 0x83, 0xFE, 0x03, 0xFE,
  0x00, 0x47, 0x03, 0x03, 0x01, 0x80, 0x26, 0x00, 0xC3, 0x00, 0x60, 0x36,
  0x00, 0x23, 0x00, 0x10, 0x1A, 0x00, 0x1B, 0x00, 0x0C, 0x0A, 0x00, 0x0F,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x00, 0x03, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x83, 0x80, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x40, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x40, 0x00, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x80, 0x00, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x00, 0x81,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x80, 0xF8, 0x00, 0x83, 0xFF, 0x00, 0x43,
  0x81, 0xC0, 0x23, 0x00, 0x30, 0x33, 0x00, 0x18, 0x1B, 0x00, 0x04, 0x0B,
  0x00, 0x02, 0x07, 0x00, 0x01, 0x03, 0x00, 0x00, 0x83, 0x80, 0x00, 0x41,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x0F, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x83,
  0xFF, 0x00, 0x02, 0x1C, 0x0E, 0x00, 0x08, 0xC0, 0x0C, 0x00, 0x66, 0x00,
  0x30, 0x01, 0xB0, 0x00, 0x60, 0x05, 0x80, 0x01, 0x80, 0x16, 0x00, 0x02,
  0x00, 0x70, 0x00, 0x08, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x08, 0x01,
  0x40, 0x00, 0x60, 0x0D, 0x00, 0x03, 0x00, 0x36, 0x00, 0x18, 0x00, 0xCC,
  0x00, 0xC0, 0x02, 0x18, 0x0E, 0x00, 0x18, 0x3F, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x30, 0x0E, 0x03,
  0x88, 0x06, 0x00, 0x62, 0x03, 0x00, 0x0C, 0x81, 0x80, 0x01, 0x60, 0xC0,
  0x00, 0x78, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x18, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x38,
  0x20, 0x00, 0x1E, 0x0C, 0x00, 0x0D, 0x03, 0x00, 0x03, 0x40, 0xC0, 0x01,
  0xB0, 0x18, 0x00, 0xCC, 0x07, 0x00, 0x63, 0x00, 0xE0, 0x70, 0x80, 0x1F,
  0xF0, 0x60, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0xF0, 0x10, 0x7F, 0x01, 0x0C, 0x00, 0x11, 0x80, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x08, 0x00, 0x30,
  0x3C, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x3F, 0xFE, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x10, 0x1F, 0xC0,
  0x04, 0x00, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x10, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x60, 0x40, 0x00, 0x70, 0x20,
  0x00, 0x68, 0x10, 0x00, 0x6C, 0x0C, 0x00, 0x66, 0x03, 0x00, 0x62, 0x01,
  0xC0, 0xE1, 0x00, 0x7F, 0xE0, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x40, 0x00, 0x21,
  0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x01, 0x0C,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x30, 0x00,
  0x04, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x68, 0x00, 0x18, 0x00, 0x19, 0x00,
  0x03, 0x80, 0x02, 0x20, 0x00, 0xF0, 0x00, 0xC4, 0x00, 0x16, 0x00, 0x18,
  0x80, 0x06, 0xC0, 0x06, 0x10, 0x00, 0x98, 0x00, 0xC2, 0x00, 0x33, 0x00,
  0x10, 0x40, 0x04, 0x60, 0x06, 0x08, 0x01, 0x84, 0x00, 0x81, 0x00, 0x20,
  0x80, 0x30, 0x20, 0x0C, 0x10, 0x04, 0x04, 0x01, 0x82, 0x01, 0x80, 0xC0,
  0x60, 0x40, 0x30, 0x18, 0x0C, 0x08, 0x0C, 0x03, 0x03, 0x01, 0x01, 0x80,
  0x60, 0x60, 0x20, 0x20, 0x0C, 0x08, 0x04, 0x0C, 0x01, 0x83, 0x00, 0xC1,
  0x00, 0x30, 0x40, 0x18, 0x60, 0x06, 0x18, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x10, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x0C, 0x80, 0x06, 0x40, 0x01, 0xB0, 0x00, 0x58, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBC, 0x78, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x00, 0xFB, 0xC8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 44, 13, 2, -44 },
  { 62, 13, 16, 18, 6, -44 },
  { 88, 32, 44, 32, 1, -44 },
  { 264, 26, 50, 29, 2, -46 },
  { 427, 34, 45, 41, 4, -44 },
  { 619, 29, 45, 34, 2, -44 },
  { 783, 5, 16, 10, 6, -44 },
  { 793, 17, 54, 15, 2, -44 },
  { 908, 17, 54, 15, -4, -44 },
  { 1023, 21, 22, 28, 8, -46 },
  { 1081, 25, 29, 31, 4, -36 },
  { 1172, 8, 15, 11, -3, -7 },
  { 1187, 14, 1, 18, 2, -17 },
  { 1189, 3, 4, 12, 2, -4 },
  { 1191, 26, 44, 18, -3, -44 },
  { 1334, 25, 45, 29, 3, -44 },
  { 1475, 13, 44, 29, 9, -44 },
  { 1547, 27, 44, 29, 0, -44 },
  { 1696, 28, 45, 29, 0, -44 },
  { 1854, 27, 44, 29, 0, -44 },
  { 2003, 28, 45, 29, 1, -44 },
  { 2161, 26, 45, 29, 3, -44 },
  { 2308, 25, 44, 29, 5, -44 },
  { 2446, 26, 45, 29, 2, -44 },
  { 2593, 26, 45, 29, 2, -44 },
  { 2740, 9, 32, 12, 1, -32 },
  { 2776, 14, 40, 12, -3, -32 },
  { 2846, 25, 26, 31, 4, -35 },
  { 2928, 25, 15, 31, 4, -29 },
  { 2975, 25, 26, 31, 4, -35 },
  { 3057, 20, 44, 21, 3, -44 },
  { 3167, 39, 48, 44, 3, -43 },
  { 3401, 28, 44, 28, -3, -44 },
  { 3555, 29, 44, 31, 2, -44 },
  { 3715, 30, 45, 31, 4, -44 },
  { 3884, 31, 44, 35, 2, -44 },
  { 4055, 28, 44, 28, 2, -44 },
  { 4209, 28, 44, 26, 2, -44 },
  { 4363, 32, 45, 37, 4, -44 },
  { 4543, 34, 44, 36, 2, -44 },
  { 4730, 19, 44, 14, -1, -44 },
  { 4835, 23, 55, 12, -10, -44 },
  { 4994, 32, 44, 29, 2, -44 },
  { 5170, 19, 44, 26, 2, -44 },
  { 5275, 42, 44, 44, 2, -44 },
  { 5506, 34, 44, 36, 2, -44 },
  { 5693, 32, 45, 38, 4, -44 },
  { 5873, 28, 44, 29, 2, -44 },
  { 6027, 32, 54, 38, 4, -44 },
  { 6243, 28, 44, 30, 2, -44 },
  { 6397, 28, 45, 27, 0, -44 },
  { 6555, 26, 44, 25, 5, -44 },
  { 6698, 33, 45, 36, 4, -44 },
  { 6884, 27, 44, 28, 6, -44 },
  { 7033, 42, 44, 45, 7, -44 },
  { 7264, 34, 44, 26, -4, -44 },
  { 7451, 25, 44, 25, 6, -44 },
  { 7589, 31, 44, 28, -1, -44 },
  { 7760, 23, 54, 18, -1, -44 },
  { 7916, 9, 44, 19, 6, -44 },
  { 7966, 22, 54, 18, -4, -44 },
  { 8115, 26, 25, 30, 2, -44 },
  { 8197, 20, 2, 20, -5, 6 },
  { 8202, 6, 10, 13, 9, -47 },
  { 8210, 25, 34, 30, 3, -33 },
  { 8317, 27, 47, 30, 1, -46 },
  { 8476, 21, 34, 23, 3, -33 },
  { 8566, 29, 47, 30, 3, -46 },
  { 8737, 22, 34, 26, 3, -33 },
  { 8831, 31, 62, 14, -8, -47 },
  { 9072, 28, 48, 30, 1, -33 },
  { 9240, 25, 46, 29, 1, -46 },
  { 9384, 12, 44, 11, 1, -44 },
  { 9450, 21, 59, 12, -8, -44 },
  { 9605, 25, 46, 24, 1, -46 },
  { 9749, 12, 46, 11, 1, -46 },
  { 9818, 41, 33, 45, 1, -33 },
  { 9988, 25, 33, 29, 1, -33 },
  { 10092, 24, 34, 30, 3, -33 },
  { 10194, 30, 47, 30, -2, -33 },
  { 10371, 26, 47, 30, 3, -33 },
  { 10524, 20, 33, 20, 1, -33 },
  { 10607, 22, 34, 22, 0, -33 },
  { 10701, 15, 41, 16, 2, -40 },
  { 10778, 25, 33, 29, 3, -32 },
  { 10882, 22, 32, 22, 3, -32 },
  { 10970, 35, 32, 35, 3, -32 },
  { 11110, 27, 32, 24, -2, -32 },
  { 11218, 32, 47, 22, -7, -32 },
  { 11406, 24, 32, 22, -1, -32 },
  { 11502, 21, 54, 20, 2, -44 },
  { 11644, 2, 61, 28, 14, -46 },
  { 11660, 21, 54, 20, -3, -44 },
  { 11802, 25, 5, 31, 4, -24 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC61PT7B_H_
