#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x29, 0x5C, 0xAF, 0xAA, 0x80, 0x11, 0xD8, 0xC2,
  0x18, 0xD8, 0x40, 0xED, 0xB5, 0xF6, 0xB6, 0xE0, 0x3A, 0x4C, 0xC9, 0xCB,
  0xE0, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80, 0x2A, 0x5A,
  0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x7A, 0x53,
  0x18, 0xCB, 0x80, 0x75, 0x24, 0x90, 0x71, 0x11, 0x24, 0xF0, 0x78, 0x44,
  0x61, 0x0B, 0xC0, 0x13, 0x35, 0x97, 0x20, 0x7A, 0x18, 0x21, 0x0B, 0xC0,
  0x78, 0xCA, 0x9A, 0xE0, 0xF2, 0x24, 0x48, 0x80, 0x7A, 0x54, 0xC9, 0x4B,
  0xC0, 0x7A, 0x62, 0xA3, 0x0B, 0x80, 0x40, 0x80, 0x40, 0xA0, 0x34, 0x86,
  0x10, 0xF0, 0xF0, 0x84, 0x34, 0x80, 0xE4, 0xE8, 0x20, 0x3C, 0x85, 0x7D,
  0x5A, 0xB7, 0xA0, 0x3C, 0x10, 0xCA, 0x55, 0xA6, 0x20, 0x7A, 0x52, 0xE8,
  0xC7, 0xC0, 0x7C, 0x21, 0x08, 0x43, 0x80, 0x7A, 0x52, 0x98, 0xC7, 0xC0,
  0x7A, 0x10, 0xE8, 0x43, 0x80, 0x7A, 0x10, 0xE8, 0x42, 0x00, 0x7C, 0x21,
  0x68, 0xCB, 0xC0, 0x45, 0x14, 0x5F, 0x8A, 0x28, 0x80, 0x69, 0x25, 0x20,
  0x11, 0x11, 0x22, 0x22, 0xC0, 0x4D, 0x46, 0x18, 0xA2, 0x49, 0x00, 0x49,
  0x29, 0x38, 0x42, 0x85, 0x9B, 0x5A, 0xB6, 0xA9, 0x00, 0x45, 0x96, 0x55,
  0x9A, 0x68, 0x80, 0x7C, 0x63, 0x18, 0xCB, 0xC0, 0x7A, 0x52, 0xE8, 0x42,
  0x00, 0x7C, 0x63, 0x18, 0xCB, 0x44, 0x20, 0x7A, 0x52, 0xE9, 0x4A, 0x40,
  0x7A, 0x10, 0x41, 0x0B, 0xC0, 0xF4, 0x44, 0x88, 0x80, 0x8C, 0x63, 0x19,
  0x4B, 0x80, 0x99, 0xAA, 0xCC, 0x80, 0x93, 0x66, 0xD6, 0xAD, 0x91, 0x24,
  0x00, 0x24, 0xA1, 0x04, 0x31, 0x48, 0x80, 0x9A, 0xA4, 0x88, 0x80, 0x78,
  0x84, 0x44, 0x43, 0xC0, 0x74, 0x44, 0x88, 0x88, 0xC0, 0xFE, 0x31, 0x11,
  0x22, 0x22, 0xC0, 0x21, 0x93, 0x10, 0xF0, 0x90, 0x7C, 0x65, 0x2F, 0x00,
  0x42, 0x1C, 0x94, 0xC6, 0x5E, 0x78, 0x88, 0xE0, 0x08, 0x4E, 0x98, 0xCA,
  0x5E, 0x79, 0xE8, 0xE0, 0x19, 0x0C, 0x42, 0x21, 0x08, 0x46, 0x00, 0x7C,
  0x65, 0x2F, 0x0B, 0x80, 0x44, 0x65, 0x59, 0x99, 0x05, 0xA8, 0x00, 0x94,
  0x92, 0xC0, 0x44, 0x45, 0x64, 0xAA, 0x55, 0x6A, 0x7E, 0xA6, 0x4C, 0x99,
  0x40, 0x75, 0x99, 0x90, 0x79, 0x99, 0xF0, 0x7A, 0x63, 0x2F, 0x42, 0x00,
  0x7C, 0x65, 0x2F, 0x08, 0x40, 0x74, 0x88, 0x80, 0xF8, 0x62, 0xE0, 0x4D,
  0x29, 0x30, 0x4A, 0x65, 0x2F, 0x00, 0xBB, 0x48, 0xAF, 0x6D, 0x4A, 0x00,
  0x56, 0x4A, 0xA0, 0x4A, 0x4C, 0x42, 0x13, 0x00, 0x72, 0x48, 0xE0, 0x32,
  0x44, 0xC4, 0x88, 0x40, 0xFF, 0xC0, 0x31, 0x12, 0x32, 0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 7, 1, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 2, 0, -7 },
  { 30, 3, 9, 2, -1, -7 },
  { 34, 4, 4, 5, 1, -8 },
  { 36, 4, 5, 5, 1, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 0, -1 },
  { 42, 4, 7, 3, 0, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 7, 5, 1, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 2, 5, 2, 0, -5 },
  { 92, 2, 6, 2, 0, -5 },
  { 94, 4, 5, 5, 1, -6 },
  { 97, 4, 3, 5, 1, -5 },
  { 99, 4, 5, 5, 1, -6 },
  { 102, 3, 7, 3, 1, -7 },
  { 105, 7, 8, 7, 0, -7 },
  { 112, 5, 7, 5, -1, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 5, 7, 5, 1, -7 },
  { 127, 5, 7, 6, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 4, 0, -7 },
  { 142, 5, 7, 6, 1, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 3, 7, 2, 0, -7 },
  { 156, 4, 9, 2, -2, -7 },
  { 161, 6, 7, 5, 0, -7 },
  { 167, 3, 7, 4, 0, -7 },
  { 170, 7, 7, 7, 0, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 5, 7, 6, 1, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 5, 9, 6, 1, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 5, 7, 4, 0, -7 },
  { 209, 4, 7, 4, 1, -7 },
  { 213, 5, 7, 6, 1, -7 },
  { 218, 4, 7, 5, 1, -7 },
  { 222, 7, 7, 7, 1, -7 },
  { 229, 6, 7, 4, -1, -7 },
  { 235, 4, 7, 4, 1, -7 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 4, 9, 3, 0, -7 },
  { 249, 1, 7, 3, 1, -7 },
  { 250, 4, 9, 3, -1, -7 },
  { 255, 5, 4, 5, 0, -7 },
  { 258, 4, 1, 3, -1, 1 },
  { 259, 2, 2, 2, 1, -8 },
  { 260, 5, 5, 5, 0, -5 },
  { 264, 5, 8, 5, 0, -8 },
  { 269, 4, 5, 4, 0, -5 },
  { 272, 5, 8, 5, 0, -8 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 5, 10, 2, -1, -8 },
  { 287, 5, 7, 5, 0, -5 },
  { 292, 4, 8, 5, 0, -8 },
  { 296, 2, 7, 2, 0, -7 },
  { 298, 3, 9, 2, -1, -7 },
  { 302, 4, 8, 4, 0, -8 },
  { 306, 2, 8, 2, 0, -8 },
  { 308, 7, 5, 7, 0, -5 },
  { 313, 4, 5, 5, 0, -5 },
  { 316, 4, 5, 5, 0, -5 },
  { 319, 5, 7, 5, 0, -5 },
  { 324, 5, 7, 5, 0, -5 },
  { 329, 4, 5, 3, 0, -5 },
  { 332, 4, 5, 4, 0, -5 },
  { 335, 3, 7, 3, 0, -7 },
  { 338, 5, 5, 5, 0, -5 },
  { 342, 3, 5, 4, 1, -5 },
  { 344, 5, 5, 6, 1, -5 },
  { 348, 4, 5, 4, 0, -5 },
  { 351, 5, 7, 4, -1, -5 },
  { 356, 4, 5, 4, 0, -5 },
  { 359, 4, 9, 3, 0, -7 },
  { 364, 1, 10, 5, 2, -8 },
  { 366, 4, 9, 3, -1, -7 },
  { 371, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC10PT7B_H_
