#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x21, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x08, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2, 0x01,
  0x0C, 0x02, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80, 0x43, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1E, 0x18,
  0x3E, 0x00, 0x70, 0x30, 0x08, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x71, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x5E, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x03, 0x80, 0x60, 0x0C, 0x1E, 0x00, 0xF8, 0x19, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x18, 0x03, 0xCF, 0x00, 0x00, 0x60, 0x0E, 0x06, 0x00,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x00, 0x30, 0x30, 0x1F, 0x18, 0x00, 0x60, 0xE0, 0xFF, 0x30, 0x00,
  0xC1, 0x83, 0x07, 0x60, 0x03, 0x06, 0x0C, 0x07, 0xC0, 0x06, 0x1C, 0x30,
  0x07, 0x80, 0x18, 0x30, 0xC0, 0x0F, 0x00, 0x30, 0xC1, 0x80, 0x1B, 0x00,
  0xC1, 0x86, 0x00, 0x37, 0x03, 0x06, 0x0C, 0x00, 0x67, 0xBC, 0x18, 0x30,
  0x00, 0xC7, 0xF0, 0x30, 0x60, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x30, 0x00,
  0x07, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x06, 0x0E, 0x00, 0xC0, 0x01,
  0x83, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x04, 0x38, 0x00, 0x18,
  0x01, 0x86, 0x00, 0x03, 0x80, 0x21, 0x80, 0x00, 0x30, 0x0C, 0x30, 0x00,
  0x03, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x61, 0x80, 0x00, 0x06, 0x18, 0x30,
  0x00, 0x00, 0xC7, 0x06, 0x00, 0x00, 0x0C, 0xC0, 0xC0, 0x00, 0x01, 0xB0,
  0x18, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x00, 0x3B, 0x01, 0xC0, 0x00, 0x0E, 0x60, 0x18, 0x00,
  0x03, 0x86, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0x38, 0x00, 0x70, 0x0C, 0x03,
  0xE0, 0x7C, 0x01, 0x80, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0x41, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0x70, 0x08, 0x00, 0x0E, 0x04, 0x00, 0x01, 0xC2, 0x00,
  0x00, 0x33, 0x00, 0xF0, 0x07, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x90, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81,
  0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x30, 0x03, 0x80, 0x18, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x76, 0x00, 0xE6, 0x03, 0x86, 0x07, 0x0C, 0x0E, 0x0C, 0x38, 0x0C, 0xF0,
  0x0C, 0x40, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x1F, 0xF0, 0x00, 0xC1, 0xFF, 0xF0,
  0x03, 0x1E, 0x01, 0xE0, 0x08, 0xE0, 0x01, 0xC0, 0x66, 0x00, 0x03, 0x01,
  0xB0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x18, 0x00, 0x03, 0x60, 0x70, 0x00,
  0x19, 0x00, 0xE0, 0x00, 0xCC, 0x01, 0xC0, 0x0E, 0x30, 0x03, 0xE7, 0xF0,
  0xC0, 0x03, 0xFF, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x0F, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0xE0, 0x07, 0x02,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0xC1, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x0C, 0x30, 0x00, 0x70, 0x03, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x03, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x33, 0x00, 0x18, 0x00, 0x10, 0x00,
  0xCC, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x0D,
  0x80, 0x18, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x00, 0x60, 0x01, 0x98,
  0x01, 0x80, 0x01, 0x80, 0x06, 0x60, 0x04, 0x00, 0x06, 0x00, 0x19, 0x80,
  0x30, 0x00, 0x18, 0x00, 0xCC, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x63, 0x00, 0x30,
  0x00, 0x70, 0x01, 0x8C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x30, 0x03, 0x00,
  0x0F, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x6C, 0x01, 0x83, 0x00, 0x30, 0x03,
  0xB0, 0x0E, 0x0C, 0x00, 0x60, 0x0C, 0xC0, 0x70, 0x30, 0x01, 0xC0, 0xE3,
  0x83, 0x80, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0x80, 0x07, 0xF0, 0x0F,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x40,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x7E,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x10, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0xF1, 0x80, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x04, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x80, 0x38, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x0C, 0x3C,
  0x00, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x00, 0x03, 0x3B, 0x80, 0x00, 0x00,
  0x1B, 0x8C, 0x00, 0x00, 0x01, 0xB8, 0x60, 0x00, 0x00, 0x0D, 0x81, 0x80,
  0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x34,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x0D, 0x00, 0x00, 0x00, 0x03, 0x60, 0x03,
  0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x98, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x01, 0x98, 0x00, 0x00, 0x03, 0x98,
  0x00, 0xC2, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x40, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02,
  0x00, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x30, 0x00, 0xE0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x81, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x00, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x60,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x36, 0x00, 0x00, 0x06, 0x00, 0x36,
  0x00, 0x00, 0x06, 0x00, 0x26, 0x00, 0x00, 0x06, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x00, 0x63, 0x00, 0x00, 0x06, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x01, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x08,
  0x00, 0x01, 0x81, 0x80, 0x18, 0x00, 0x01, 0x81, 0x80, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x30, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x30, 0x00, 0x00, 0x66, 0x00, 0x30, 0x00, 0x00, 0x36,
  0x00, 0x60, 0x00, 0x00, 0x36, 0x00, 0x60, 0x00, 0x00, 0x36, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x7C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x01, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x04, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x40, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x04, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x40,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x06, 0x00, 0x18, 0x06, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x10, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x04, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x02, 0x03, 0x00, 0x03, 0xF8, 0x04, 0x00, 0x7F, 0xF8, 0x20,
  0x03, 0x80, 0x70, 0x80, 0x18, 0x00, 0xC6, 0x00, 0xC0, 0x01, 0x98, 0x06,
  0x00, 0x02, 0x60, 0x30, 0x00, 0x0D, 0x01, 0x80, 0x00, 0x3C, 0x06, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xA0,
  0x18, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x36, 0x01, 0x80, 0x01, 0x98, 0x03,
  0x00, 0x0C, 0x40, 0x0E, 0x00, 0xE1, 0x00, 0x1E, 0x0F, 0x0C, 0x00, 0x1F,
  0xF0, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x06,
  0x0F, 0xFF, 0x00, 0x18, 0x70, 0x0E, 0x00, 0x63, 0x80, 0x1C, 0x01, 0x18,
  0x00, 0x30, 0x0C, 0xC0, 0x00, 0x60, 0x36, 0x00, 0x01, 0x80, 0xF8, 0x00,
  0x03, 0x03, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x07,
  0x80, 0x00, 0x18, 0x1E, 0x00, 0x00, 0xE0, 0x58, 0x00, 0x07, 0x01, 0x30,
  0x00, 0x18, 0x0C, 0xE0, 0x01, 0xC0, 0x31, 0xC0, 0x0E, 0x00, 0xC3, 0xC0,
  0xF0, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x04, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x06,
  0x00, 0x07, 0xFF, 0x83, 0x00, 0x03, 0x80, 0x78, 0xC0, 0x01, 0x80, 0x06,
  0x30, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0x60, 0x00, 0x12, 0x00, 0x30, 0x00,
  0x07, 0x80, 0x18, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x30,
  0x00, 0x03, 0x40, 0x0C, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x6C, 0x00,
  0x60, 0x00, 0x33, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x0E, 0x20,
  0x00, 0xE0, 0x0E, 0x18, 0x00, 0x1E, 0x0F, 0x06, 0x00, 0x01, 0xFF, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x70,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0xF0, 0x20, 0x00,
  0xF0, 0x18, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x40, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x80, 0x03, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x38,
  0x40, 0x03, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x03, 0x30, 0x03, 0x00, 0x00,
  0x90, 0x03, 0x00, 0x00, 0x68, 0x03, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0x1A, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x0D, 0x80,
  0x18, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x0E, 0x60, 0x03, 0x00, 0x0E, 0x60,
  0x01, 0xC0, 0x1E, 0x30, 0x00, 0x78, 0x3C, 0x18, 0x00, 0x0F, 0xF8, 0x0C,
  0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x7F,
  0x00, 0x0C, 0x1F, 0xFE, 0x00, 0x61, 0xC0, 0x38, 0x03, 0x18, 0x00, 0xE0,
  0x19, 0x80, 0x03, 0x00, 0x98, 0x00, 0x0C, 0x0D, 0x80, 0x00, 0x60, 0x78,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x38, 0x00, 0x20, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x04, 0x0E, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C, 0x6C,
  0x00, 0x01, 0x8C, 0xC0, 0x00, 0x19, 0x86, 0x00, 0x01, 0xB0, 0x60, 0x00,
  0x1E, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x06, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x0C, 0xE0, 0x06, 0x1C, 0x00, 0xE0,
  0x13, 0x00, 0x0C, 0x70, 0x00, 0xC0, 0x64, 0x00, 0x0C, 0xC0, 0x01, 0x80,
  0xD8, 0x00, 0x1B, 0x00, 0x01, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x02,
  0x80, 0x00, 0x78, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0C, 0x1F, 0xFE, 0x00, 0x61, 0xC0, 0x38, 0x03, 0x18, 0x00, 0xE0, 0x11,
  0x80, 0x03, 0x01, 0x98, 0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x78, 0x00,
  0x03, 0x03, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x04,
  0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x0F, 0xFF, 0x00, 0x01, 0x87, 0x00,
  0xE0, 0x00, 0x63, 0x80, 0x1C, 0x00, 0x11, 0xC0, 0x03, 0x00, 0x0C, 0xC0,
  0x00, 0x60, 0x03, 0x70, 0x00, 0x18, 0x00, 0xD8, 0x00, 0x03, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x80, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x78, 0x00, 0x01, 0x80,
  0x1E, 0x00, 0x00, 0xE0, 0x06, 0x80, 0x00, 0x70, 0x01, 0x30, 0x00, 0x18,
  0x00, 0xCE, 0x00, 0x1C, 0x00, 0x31, 0xC0, 0x0E, 0x00, 0x0C, 0x3C, 0x0F,
  0x00, 0x03, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x3F, 0xFC, 0x08, 0x00, 0xE0,
  0x1C, 0x10, 0x03, 0x80, 0x0C, 0x60, 0x0C, 0x00, 0x0C, 0xC0, 0x30, 0x00,
  0x09, 0x00, 0xC0, 0x00, 0x1A, 0x03, 0x80, 0x00, 0x3C, 0x06, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00, 0x01, 0xA0, 0x30, 0x00,
  0x07, 0xC0, 0x30, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x33, 0x00, 0xC0, 0x00,
  0xE6, 0x00, 0xC0, 0x03, 0x88, 0x01, 0xC0, 0x1C, 0x30, 0x01, 0xE0, 0xF0,
  0x60, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x38, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0x07, 0xFC, 0x06, 0x1C, 0x00, 0x0C, 0x60, 0x00,
  0x11, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x10, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0F, 0xC0, 0x78, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x1F, 0xFF, 0xE0, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x02, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0xD8, 0x18, 0x00, 0x0E, 0x80, 0xC0, 0x00, 0x64, 0x03, 0x00, 0x0E,
  0x60, 0x1C, 0x00, 0xE3, 0x00, 0x78, 0x1C, 0x18, 0x01, 0xFF, 0xC0, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x10, 0x03, 0x80,
  0x08, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00,
  0x38, 0x00, 0x04, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0x68, 0x00,
  0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0,
  0x01, 0x88, 0x00, 0x30, 0xC0, 0x01, 0x88, 0x00, 0x30, 0xC0, 0x01, 0x08,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x40,
  0x40, 0x06, 0x0C, 0x00, 0xC0, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0x40, 0x0C,
  0x0C, 0x01, 0x80, 0x40, 0x0C, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x18, 0x00,
  0x61, 0x80, 0x04, 0x18, 0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x70, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x17, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x0E, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 51, 15, 2, -51 },
  { 84, 15, 19, 21, 7, -51 },
  { 120, 36, 51, 37, 2, -51 },
  { 350, 31, 58, 34, 2, -54 },
  { 575, 39, 52, 48, 5, -51 },
  { 829, 35, 52, 39, 2, -51 },
  { 1057, 6, 19, 11, 7, -51 },
  { 1072, 20, 62, 17, 2, -51 },
  { 1227, 20, 62, 17, -5, -51 },
  { 1382, 25, 26, 32, 9, -54 },
  { 1464, 30, 32, 36, 4, -41 },
  { 1584, 9, 17, 12, -3, -8 },
  { 1604, 16, 2, 21, 2, -20 },
  { 1608, 3, 4, 13, 2, -4 },
  { 1610, 30, 51, 21, -3, -51 },
  { 1802, 30, 52, 34, 3, -51 },
  { 1997, 16, 51, 34, 10, -51 },
  { 2099, 32, 51, 34, 0, -51 },
  { 2303, 33, 52, 34, 0, -51 },
  { 2518, 32, 51, 34, 0, -51 },
  { 2722, 32, 52, 34, 1, -51 },
  { 2930, 30, 52, 34, 4, -51 },
  { 3125, 29, 51, 34, 6, -51 },
  { 3310, 31, 52, 34, 2, -51 },
  { 3512, 30, 52, 34, 2, -51 },
  { 3707, 11, 38, 13, 1, -38 },
  { 3760, 15, 47, 13, -3, -38 },
  { 3849, 30, 31, 36, 4, -41 },
  { 3966, 30, 16, 36, 4, -33 },
  { 4026, 30, 31, 36, 4, -41 },
  { 4143, 22, 51, 24, 4, -51 },
  { 4284, 46, 56, 51, 3, -50 },
  { 4606, 33, 51, 33, -4, -51 },
  { 4817, 34, 51, 37, 2, -51 },
  { 5034, 34, 52, 36, 5, -51 },
  { 5255, 37, 51, 41, 2, -51 },
  { 5491, 33, 51, 33, 2, -51 },
  { 5702, 33, 51, 30, 2, -51 },
  { 5913, 37, 52, 43, 5, -51 },
  { 6154, 40, 51, 42, 2, -51 },
  { 6409, 21, 51, 17, -1, -51 },
  { 6543, 26, 63, 14, -11, -51 },
  { 6748, 37, 51, 33, 2, -51 },
  { 6984, 22, 51, 30, 2, -51 },
  { 7125, 50, 51, 52, 2, -51 },
  { 7444, 40, 51, 42, 2, -51 },
  { 7699, 36, 52, 44, 5, -51 },
  { 7933, 33, 51, 34, 2, -51 },
  { 8144, 36, 63, 44, 5, -51 },
  { 8428, 33, 51, 35, 2, -51 },
  { 8639, 32, 52, 31, 0, -51 },
  { 8847, 30, 51, 29, 6, -51 },
  { 9039, 38, 52, 42, 5, -51 },
  { 9286, 31, 51, 33, 7, -51 },
  { 9484, 50, 51, 53, 8, -51 },
  { 9803, 39, 51, 30, -4, -51 },
  { 10052, 30, 51, 29, 6, -51 },
  { 10244, 36, 51, 32, -1, -51 },
  { 10474, 26, 62, 21, -1, -51 },
  { 10676, 10, 51, 22, 7, -51 },
  { 10740, 26, 62, 21, -5, -51 },
  { 10942, 30, 29, 35, 3, -51 },
  { 11051, 24, 2, 24, -6, 7 },
  { 11057, 8, 11, 15, 10, -54 },
  { 11068, 30, 39, 34, 3, -38 },
  { 11215, 30, 55, 35, 2, -54 },
  { 11422, 25, 39, 27, 3, -38 },
  { 11544, 34, 55, 35, 3, -54 },
  { 11778, 26, 39, 31, 3, -38 },
  { 11905, 35, 71, 17, -9, -54 },
  { 12216, 33, 55, 35, 1, -38 },
  { 12443, 29, 54, 34, 2, -54 },
  { 12639, 13, 51, 13, 2, -51 },
  { 12722, 25, 68, 13, -10, -51 },
  { 12935, 28, 54, 27, 2, -54 },
  { 13124, 13, 54, 13, 2, -54 },
  { 13212, 47, 38, 52, 2, -38 },
  { 13436, 29, 38, 34, 2, -38 },
  { 13574, 29, 39, 35, 3, -38 },
  { 13716, 34, 54, 35, -2, -38 },
  { 13946, 31, 55, 35, 3, -38 },
  { 14160, 23, 38, 23, 2, -38 },
  { 14270, 25, 39, 26, 0, -38 },
  { 14392, 17, 48, 19, 3, -47 },
  { 14494, 29, 38, 34, 3, -37 },
  { 14632, 25, 37, 25, 4, -37 },
  { 14748, 40, 37, 41, 4, -37 },
  { 14933, 32, 37, 28, -3, -37 },
  { 15081, 38, 54, 26, -8, -37 },
  { 15338, 27, 37, 26, -1, -37 },
  { 15463, 25, 62, 23, 2, -51 },
  { 15657, 2, 71, 33, 17, -54 },
  { 15675, 25, 62, 23, -4, -51 },
  { 15869, 30, 6, 36, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC71PT7B_H_
