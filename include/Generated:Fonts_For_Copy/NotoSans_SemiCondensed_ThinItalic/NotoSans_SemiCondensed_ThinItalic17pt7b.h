#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x44, 0x40, 0x08, 0xB6, 0xD0, 0x09, 0x04, 0x82,
  0x47, 0xF1, 0x20, 0x90, 0x49, 0xFE, 0x24, 0x12, 0x12, 0x09, 0x00, 0x04,
  0x0E, 0x35, 0x28, 0x28, 0x28, 0x18, 0x0C, 0x12, 0x12, 0x12, 0xDC, 0x30,
  0x20, 0x78, 0x92, 0x48, 0x92, 0x28, 0x95, 0xA5, 0x9A, 0xA5, 0x51, 0x14,
  0x49, 0x24, 0x49, 0x1C, 0x1E, 0x08, 0x84, 0x42, 0x41, 0x40, 0xC0, 0xA0,
  0x89, 0x85, 0x41, 0x20, 0x8F, 0xA0, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x80, 0x10, 0x82, 0x10, 0x84, 0x21, 0x10, 0x84, 0x44, 0x22,
  0x00, 0x12, 0x45, 0x4A, 0x52, 0x60, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x56, 0xE0, 0x80, 0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x0A,
  0x27, 0x80, 0x35, 0x91, 0x22, 0x22, 0x24, 0x44, 0x3E, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x3E, 0x01, 0x01, 0x01,
  0x02, 0x1C, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x03, 0x05, 0x06, 0x0A,
  0x12, 0x22, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x08, 0x1F, 0x10, 0x20, 0x20,
  0x20, 0x5C, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x1E, 0x41, 0x02, 0x0B,
  0x98, 0xA1, 0x42, 0x85, 0x0A, 0x23, 0x80, 0x7E, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x00, 0x1E, 0x21, 0x21, 0x21, 0x12, 0x1C,
  0x24, 0x42, 0x82, 0x82, 0x82, 0x7C, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x26, 0x1A, 0x02, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x02, 0x44, 0x80, 0x02, 0x18, 0xC6, 0x04, 0x06, 0x03, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x43, 0x18, 0x40, 0x78, 0x42,
  0x11, 0x11, 0x08, 0x80, 0x01, 0x00, 0x0F, 0x86, 0x09, 0x00, 0xA3, 0x18,
  0x93, 0x22, 0x64, 0x8D, 0x12, 0xA2, 0x53, 0xF2, 0x00, 0x40, 0x04, 0x20,
  0x78, 0x00, 0x02, 0x06, 0x06, 0x0A, 0x09, 0x11, 0x11, 0x2F, 0x21, 0x41,
  0x41, 0x81, 0x3E, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x84, 0x82, 0x82, 0x82,
  0x84, 0xF8, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x84, 0xF8, 0x3E, 0x81, 0x02, 0x04, 0x0F, 0xA0, 0x40, 0x81, 0x02, 0x07,
  0xC0, 0x3E, 0x81, 0x02, 0x04, 0x08, 0x2F, 0x40, 0x81, 0x02, 0x04, 0x00,
  0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x1D, 0x02, 0x81, 0x40, 0xA0,
  0x4F, 0xC0, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x13, 0xFA, 0x05, 0x02, 0x81,
  0x41, 0x20, 0x90, 0x40, 0x38, 0x84, 0x42, 0x10, 0x88, 0x42, 0x11, 0x80,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x38, 0x00, 0x21, 0x42, 0x44, 0x48, 0x50, 0x60, 0x50, 0x90, 0x88, 0x88,
  0x84, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0xF0, 0x20, 0x2C,
  0x0D, 0x81, 0xA8, 0x55, 0x0A, 0xA2, 0xA4, 0x54, 0x92, 0x92, 0x52, 0x8A,
  0x62, 0x44, 0x40, 0x20, 0xB0, 0x54, 0x2A, 0x15, 0x12, 0x4A, 0x25, 0x12,
  0x85, 0x43, 0x20, 0x90, 0x40, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x40, 0xA0, 0x8F, 0x80, 0x3C, 0x45, 0x0A, 0x14, 0x28,
  0xDE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x8E, 0x80, 0x80, 0x40, 0x10, 0x3C,
  0x45, 0x0A, 0x14, 0x28, 0x9E, 0x44, 0x89, 0x12, 0x14, 0x20, 0x1F, 0x20,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x04, 0xF8, 0xFE, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x20, 0xA0, 0x50,
  0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x8F, 0x80, 0x83,
  0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x41, 0x04, 0x00, 0x84, 0x18,
  0x42, 0x8C, 0x28, 0xC4, 0x94, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xC3, 0x0C,
  0x30, 0x82, 0x08, 0x20, 0x10, 0x88, 0x84, 0x41, 0x40, 0xC0, 0x40, 0x20,
  0x28, 0x24, 0x11, 0x10, 0x90, 0x40, 0x87, 0x0A, 0x24, 0x89, 0x0C, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x80, 0xFC, 0x1C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0xA5, 0x55, 0x1C, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x08, 0x30, 0x91, 0x24,
  0x50, 0x60, 0x80, 0xF8, 0x94, 0x3E, 0x8A, 0x14, 0x28, 0x50, 0xA1, 0x44,
  0xF8, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42,
  0x42, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x01, 0x01, 0x01,
  0x02, 0x3E, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0xF4, 0x3D, 0x18,
  0x62, 0xF2, 0x08, 0x20, 0x78, 0x03, 0x04, 0x08, 0x08, 0x1E, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1F, 0x21,
  0x41, 0x41, 0x42, 0x82, 0x82, 0x44, 0x7A, 0x04, 0x04, 0x04, 0xF8, 0x10,
  0x20, 0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42, 0x85, 0x0C, 0x18, 0x40, 0x10,
  0x02, 0x24, 0x44, 0x44, 0x88, 0x04, 0x00, 0x02, 0x08, 0x21, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x30, 0x10, 0x20, 0x81, 0x02, 0x24, 0x92, 0x28,
  0x70, 0x91, 0x24, 0x48, 0x40, 0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x80,
  0x3E, 0xE2, 0x31, 0x22, 0x14, 0x21, 0x42, 0x24, 0x22, 0x44, 0x28, 0x42,
  0x84, 0x20, 0x3E, 0x44, 0x8A, 0x14, 0x28, 0x50, 0xC1, 0x84, 0x3C, 0x86,
  0x0C, 0x18, 0x30, 0xA1, 0x44, 0xF0, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x86, 0x0C, 0x18, 0x50,
  0xA1, 0x44, 0xF4, 0x10, 0x20, 0x40, 0x80, 0x3C, 0x82, 0x10, 0x41, 0x04,
  0x20, 0x80, 0x3D, 0x04, 0x08, 0x10, 0x20, 0x82, 0xF0, 0x44, 0xF4, 0x88,
  0x88, 0x88, 0xC0, 0x42, 0x86, 0x14, 0x28, 0x50, 0xA1, 0x44, 0xF8, 0x86,
  0x28, 0xA4, 0x92, 0x8A, 0x30, 0x40, 0x88, 0xC4, 0x66, 0x33, 0x2A, 0x55,
  0x33, 0x19, 0x08, 0x84, 0x00, 0x21, 0x12, 0x14, 0x14, 0x08, 0x18, 0x24,
  0x44, 0xC4, 0x10, 0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x0E, 0x00, 0x3C, 0x10, 0x84, 0x20, 0x84, 0x20, 0xF8,
  0x0C, 0x41, 0x04, 0x10, 0x82, 0x30, 0x20, 0x84, 0x10, 0x41, 0x02, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x10, 0x82, 0x08, 0x20, 0x83, 0x10, 0x41, 0x04,
  0x20, 0x8C, 0x00, 0x73, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 3, 4, 5, 2, -12 },
  { 9, 9, 12, 9, 0, -12 },
  { 23, 8, 14, 8, 0, -13 },
  { 37, 10, 12, 11, 1, -12 },
  { 52, 9, 12, 9, 0, -12 },
  { 66, 1, 4, 3, 2, -12 },
  { 67, 4, 15, 4, 1, -12 },
  { 75, 5, 15, 4, -1, -12 },
  { 85, 6, 6, 8, 2, -13 },
  { 90, 7, 8, 9, 1, -10 },
  { 97, 2, 4, 3, -1, -2 },
  { 98, 3, 1, 5, 1, -5 },
  { 99, 1, 1, 3, 0, -1 },
  { 100, 7, 12, 5, -1, -12 },
  { 111, 7, 12, 8, 1, -12 },
  { 122, 4, 12, 8, 2, -12 },
  { 128, 8, 12, 8, 0, -12 },
  { 140, 8, 12, 8, 0, -12 },
  { 152, 8, 12, 8, 0, -12 },
  { 164, 8, 12, 8, 0, -12 },
  { 176, 7, 12, 8, 1, -12 },
  { 187, 7, 12, 8, 1, -12 },
  { 198, 8, 12, 8, 0, -12 },
  { 210, 8, 12, 8, 0, -12 },
  { 222, 3, 9, 3, 0, -9 },
  { 226, 4, 11, 3, -1, -9 },
  { 232, 7, 8, 9, 1, -10 },
  { 239, 7, 4, 9, 1, -8 },
  { 243, 7, 8, 9, 1, -10 },
  { 250, 5, 12, 6, 1, -12 },
  { 258, 11, 14, 12, 1, -12 },
  { 278, 8, 12, 8, -1, -12 },
  { 290, 8, 12, 9, 1, -12 },
  { 302, 8, 12, 9, 1, -12 },
  { 314, 8, 12, 10, 1, -12 },
  { 326, 7, 12, 8, 1, -12 },
  { 337, 7, 12, 7, 1, -12 },
  { 348, 9, 12, 10, 1, -12 },
  { 362, 9, 12, 10, 1, -12 },
  { 376, 5, 12, 4, 0, -12 },
  { 384, 7, 15, 3, -3, -12 },
  { 398, 8, 12, 8, 1, -12 },
  { 410, 5, 12, 7, 1, -12 },
  { 418, 11, 12, 12, 1, -12 },
  { 435, 9, 12, 10, 1, -12 },
  { 449, 9, 12, 10, 1, -12 },
  { 463, 7, 12, 8, 1, -12 },
  { 474, 9, 15, 10, 1, -12 },
  { 491, 7, 12, 8, 1, -12 },
  { 502, 8, 12, 7, 0, -12 },
  { 514, 7, 12, 7, 2, -12 },
  { 525, 9, 12, 10, 1, -12 },
  { 539, 7, 12, 8, 2, -12 },
  { 550, 12, 12, 13, 2, -12 },
  { 568, 9, 12, 7, -1, -12 },
  { 582, 7, 12, 7, 2, -12 },
  { 593, 8, 12, 8, 0, -12 },
  { 605, 6, 15, 5, 0, -12 },
  { 617, 2, 12, 5, 2, -12 },
  { 620, 6, 15, 5, -1, -12 },
  { 632, 7, 7, 8, 1, -12 },
  { 639, 5, 1, 6, -1, 1 },
  { 640, 2, 3, 4, 2, -13 },
  { 641, 7, 9, 8, 1, -9 },
  { 649, 8, 13, 8, 0, -13 },
  { 662, 6, 9, 7, 1, -9 },
  { 669, 8, 13, 8, 1, -13 },
  { 682, 6, 9, 7, 1, -9 },
  { 689, 8, 17, 4, -2, -13 },
  { 706, 8, 13, 8, 0, -9 },
  { 719, 7, 13, 8, 0, -13 },
  { 731, 4, 12, 3, 0, -12 },
  { 737, 6, 16, 3, -2, -12 },
  { 749, 7, 13, 7, 0, -13 },
  { 761, 4, 13, 3, 0, -13 },
  { 768, 12, 9, 12, 0, -9 },
  { 782, 7, 9, 8, 0, -9 },
  { 790, 7, 9, 8, 1, -9 },
  { 798, 8, 13, 8, 0, -9 },
  { 811, 7, 13, 8, 1, -9 },
  { 823, 6, 9, 5, 0, -9 },
  { 830, 6, 9, 6, 0, -9 },
  { 837, 4, 11, 4, 1, -11 },
  { 843, 7, 9, 8, 1, -9 },
  { 851, 6, 9, 6, 1, -9 },
  { 858, 9, 9, 10, 1, -9 },
  { 869, 8, 9, 7, -1, -9 },
  { 878, 9, 13, 6, -2, -9 },
  { 893, 6, 9, 6, 0, -9 },
  { 900, 6, 15, 5, 0, -12 },
  { 912, 1, 17, 8, 4, -13 },
  { 915, 6, 15, 5, -1, -12 },
  { 927, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC17PT7B_H_
