#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x23, 0x42, 0x42, 0x42, 0x44, 0x44, 0x84, 0x84, 0x84, 0x00, 0x40, 0x80,
  0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x3F, 0xFF, 0xE0, 0x40, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08,
  0x10, 0x1F, 0xFF, 0xE0, 0x20, 0x40, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFC, 0x03, 0x23, 0x0C, 0x20, 0x08,
  0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x08, 0x80, 0x0C,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x30, 0x01, 0x18, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x82,
  0x20, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x21, 0x98, 0x04, 0x20, 0x80, 0x42, 0x08, 0x08, 0x40, 0x81, 0x04,
  0x08, 0x10, 0xC0, 0x82, 0x08, 0x08, 0x60, 0x80, 0x84, 0x08, 0x08, 0x80,
  0x81, 0x18, 0x08, 0x11, 0x1E, 0x81, 0x22, 0x38, 0x22, 0x41, 0x86, 0x48,
  0x1C, 0xC8, 0x81, 0x70, 0x88, 0x10, 0x11, 0x01, 0x02, 0x10, 0x10, 0x21,
  0x01, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x21, 0x01, 0x04, 0x30,
  0x10, 0x42, 0x01, 0x08, 0x40, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x63, 0x00,
  0x10, 0x60, 0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x04, 0x04, 0x00, 0x82, 0x00, 0x23, 0x00, 0x05, 0x80, 0x01, 0x80,
  0x00, 0xA0, 0x00, 0xC8, 0x00, 0x41, 0x01, 0x20, 0x60, 0x50, 0x08, 0x24,
  0x01, 0x0A, 0x00, 0x44, 0x80, 0x0A, 0x20, 0x02, 0x88, 0x00, 0x42, 0x00,
  0x30, 0xC0, 0x12, 0x18, 0x18, 0x83, 0xF8, 0x10, 0x29, 0x24, 0xA4, 0x80,
  0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x00, 0x01, 0x00, 0x20, 0x02,
  0x08, 0x20, 0x42, 0x03, 0x20, 0x0F, 0xF0, 0x40, 0x1A, 0x02, 0x20, 0x41,
  0x08, 0x10, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x08, 0x44, 0x22, 0x10, 0x88, 0x80, 0xFF, 0x80, 0xF0, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10,
  0x40, 0x40, 0x81, 0x00, 0xFC, 0x00, 0x03, 0x05, 0x19, 0x21, 0xC2, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x00, 0x78, 0x00, 0xC3,
  0x01, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xC3, 0x01, 0x80,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x03, 0x80, 0x1F, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x40,
  0x18, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x42, 0x00,
  0x41, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x30, 0x10, 0x10, 0x08, 0x10, 0x04, 0x10, 0x02, 0x1F, 0xFF, 0xF0, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x17, 0xC0,
  0x18, 0x70, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x80, 0x60, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xC1, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x47, 0xE0, 0x58, 0x10, 0x60, 0x08, 0xA0, 0x08,
  0xC0, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x40, 0x20, 0x60, 0x40, 0x3F, 0x80,
  0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x00, 0x78, 0x03, 0x84, 0x06, 0x02, 0x04, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x04, 0x02, 0x04, 0x04, 0x02,
  0x18, 0x01, 0x60, 0x03, 0xC0, 0x0C, 0x20, 0x18, 0x10, 0x20, 0x08, 0x40,
  0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x18, 0x60, 0x30, 0x1F, 0xC0, 0x00, 0xF0, 0x03, 0x0C, 0x04,
  0x06, 0x0C, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x30, 0x06, 0x10,
  0x0A, 0x0C, 0x32, 0x03, 0xC4, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0xFE,
  0x00, 0x08, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F,
  0x03, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x10, 0x01, 0x00,
  0x08, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x30, 0x0F, 0x02, 0x20, 0x30, 0x81, 0x60, 0x40, 0x81, 0x40, 0x80,
  0x81, 0x41, 0x80, 0x82, 0x81, 0x01, 0x02, 0x83, 0x01, 0x02, 0x82, 0x01,
  0x02, 0x82, 0x02, 0x02, 0x82, 0x02, 0x04, 0x82, 0x02, 0x04, 0x82, 0x06,
  0x08, 0x82, 0x0A, 0x18, 0x83, 0x1A, 0x30, 0x81, 0xE1, 0xE0, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x0F, 0xFE, 0x04, 0x01, 0x04, 0x00, 0x82, 0x00, 0x42,
  0x00, 0x11, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xC0, 0x00, 0x40, 0x03, 0xFF, 0x01, 0x00, 0x60, 0x40, 0x08, 0x10, 0x01,
  0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x41, 0x80, 0x20, 0x40, 0x70, 0x1F, 0xF8, 0x04, 0x01, 0x01, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x40, 0x30, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x18, 0x30, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00,
  0x20, 0x40, 0x04, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x10, 0x03, 0x02, 0x00, 0xC0,
  0x40, 0x60, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x0E, 0x0E, 0x01, 0x80, 0x10, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x1F, 0xC4, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x02, 0x00, 0x10, 0x30, 0x01, 0x01,
  0x80, 0x30, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00, 0x41,
  0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x81, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00,
  0x18, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x3F,
  0x00, 0x02, 0x00, 0x60, 0x80, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80, 0x40,
  0x60, 0x08, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x01, 0x18,
  0x00, 0x46, 0x00, 0x09, 0x80, 0x01, 0x48, 0x00, 0x31, 0x00, 0x04, 0x30,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x18,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x0C,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x02, 0x00, 0x00, 0xC1, 0x40, 0x00,
  0x50, 0x50, 0x00, 0x18, 0x14, 0x00, 0x0A, 0x05, 0x00, 0x02, 0x81, 0x40,
  0x01, 0x20, 0x90, 0x00, 0x50, 0x24, 0x00, 0x24, 0x09, 0x00, 0x19, 0x02,
  0x20, 0x04, 0x41, 0x08, 0x02, 0x10, 0x42, 0x00, 0x88, 0x10, 0x80, 0x42,
  0x04, 0x20, 0x10, 0x81, 0x08, 0x08, 0x20, 0x82, 0x02, 0x08, 0x20, 0x81,
  0x04, 0x08, 0x10, 0xC1, 0x02, 0x04, 0x20, 0x40, 0x81, 0x10, 0x10, 0x40,
  0x44, 0x08, 0x10, 0x12, 0x02, 0x04, 0x04, 0x80, 0x81, 0x01, 0x40, 0x20,
  0xC0, 0x30, 0x08, 0x20, 0x08, 0x04, 0x00, 0x02, 0x00, 0x08, 0x30, 0x00,
  0x41, 0x40, 0x02, 0x0A, 0x00, 0x20, 0x50, 0x01, 0x02, 0x40, 0x08, 0x22,
  0x00, 0x41, 0x10, 0x04, 0x08, 0x40, 0x20, 0x42, 0x01, 0x04, 0x10, 0x08,
  0x20, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x41, 0x04, 0x02,
  0x08, 0x20, 0x10, 0x41, 0x00, 0x44, 0x08, 0x02, 0x20, 0x40, 0x11, 0x04,
  0x00, 0x48, 0x20, 0x02, 0x41, 0x00, 0x14, 0x08, 0x00, 0x60, 0xC0, 0x03,
  0x04, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x0C, 0x18, 0x03, 0x00, 0xC0,
  0x40, 0x04, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x01,
  0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x40,
  0x01, 0x06, 0x00, 0x20, 0x20, 0x06, 0x01, 0x00, 0x80, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x10, 0x40, 0x08, 0x20,
  0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x41, 0x00, 0x40, 0x81, 0xC0, 0x7F, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0C,
  0x18, 0x03, 0x00, 0xC0, 0x40, 0x04, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x14,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x40, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x06, 0x00, 0x20, 0x20, 0x04, 0x01, 0x00,
  0x80, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x02, 0x01, 0x81,
  0x00, 0x40, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x84, 0x00, 0x86, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0xC0, 0xFF,
  0x80, 0x41, 0x00, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08,
  0x40, 0x02, 0x00, 0x00, 0x3C, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x40, 0x18, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x04, 0x00, 0x20,
  0x40, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x01, 0xFE, 0x00, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x40, 0x80, 0x41, 0x00, 0x41, 0x00, 0x42, 0x00, 0x42, 0x00,
  0x44, 0x00, 0x44, 0x00, 0x48, 0x00, 0x48, 0x00, 0x50, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x06, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x80, 0x44, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x42, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x01, 0x20, 0x12, 0x00, 0x50, 0x04, 0x80, 0x14, 0x01,
  0x40, 0x06, 0x00, 0x50, 0x01, 0x80, 0x14, 0x00, 0x40, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x10, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00, 0x04, 0x60, 0x00,
  0x44, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x90, 0x00, 0x19, 0x00, 0x01, 0x10, 0x00, 0x20, 0x80,
  0x04, 0x08, 0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x00, 0x40, 0x30, 0x04,
  0x02, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x20, 0xC0, 0x03, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x20, 0x40, 0x10, 0x80, 0x11, 0x80, 0x11, 0x00, 0x12, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x08, 0x1F, 0x80, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x40, 0x01,
  0xFC, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x08, 0x08,
  0x30, 0x10, 0x40, 0x21, 0x00, 0x26, 0x00, 0x48, 0x00, 0xA0, 0x00, 0x80,
  0xFF, 0xF0, 0xC4, 0x22, 0x11, 0x01, 0xE2, 0x08, 0x64, 0x20, 0x28, 0x80,
  0x62, 0x00, 0xC4, 0x00, 0x90, 0x03, 0x20, 0x06, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80,
  0x51, 0x01, 0xC1, 0x06, 0x81, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x78, 0x09, 0x8C, 0x12, 0x02, 0x14, 0x02, 0x18, 0x03, 0x18, 0x01, 0x10,
  0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xA0, 0x08, 0xA0, 0x10, 0x90,
  0x20, 0x8F, 0xC0, 0x01, 0xF0, 0x30, 0x42, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0xE2, 0x03, 0x09, 0x02, 0x02, 0x82,
  0x00, 0xC2, 0x00, 0x63, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC2, 0x00,
  0x61, 0x00, 0x60, 0x80, 0x70, 0x40, 0x68, 0x10, 0x64, 0x07, 0xE6, 0x00,
  0x01, 0xE0, 0x30, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x48,
  0x06, 0x80, 0x64, 0x3C, 0x3A, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x10, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x24, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x80, 0xC2, 0x40, 0x80, 0xA0, 0x80, 0x30, 0x80, 0x18,
  0xC0, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0x80, 0x18, 0x40, 0x18, 0x20,
  0x1C, 0x10, 0x1A, 0x04, 0x19, 0x01, 0xF9, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x18, 0x18,
  0x03, 0xF0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x78, 0x13, 0x08, 0x28, 0x08,
  0xA0, 0x11, 0x80, 0x23, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x09, 0x00, 0x22, 0x00, 0x44, 0x00, 0x80, 0x04, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x00, 0x10, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x06, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x06,
  0x10, 0x08, 0x20, 0x20, 0x80, 0x81, 0x02, 0x02, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x22, 0x00, 0x4C, 0x00, 0xA4, 0x01, 0x88, 0x06, 0x10, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x41, 0x00, 0x82, 0x00, 0x84, 0x01, 0x00,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x00, 0x08, 0xF0, 0x3C, 0x0B, 0x08, 0xC2, 0x16, 0x05, 0x81, 0x14, 0x05,
  0x01, 0x18, 0x06, 0x01, 0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x30, 0x04,
  0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08,
  0x02, 0x40, 0x08, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x04, 0x40, 0x10,
  0x04, 0x40, 0x10, 0x04, 0x80, 0x10, 0x04, 0x80, 0x20, 0x04, 0x80, 0x20,
  0x08, 0x08, 0x78, 0x13, 0x08, 0x48, 0x08, 0xA0, 0x11, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x98, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24,
  0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x80, 0x01, 0xE0, 0x18, 0x60, 0x80, 0x84, 0x01, 0x20, 0x05,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x13, 0x00, 0x84, 0x04,
  0x0F, 0xE0, 0x02, 0x1E, 0x00, 0x98, 0xC0, 0x48, 0x08, 0x14, 0x02, 0x06,
  0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x0C, 0x18, 0x02, 0x0A, 0x01, 0x02, 0x40, 0x80, 0x9F, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE2, 0x0C, 0x24,
  0x20, 0x28, 0x80, 0x52, 0x00, 0x64, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x06,
  0x40, 0x18, 0x80, 0x71, 0x00, 0xA1, 0x06, 0x41, 0xF9, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0xF0, 0x90, 0x12, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03, 0xE0, 0x60,
  0xC6, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x20, 0x30, 0xFF, 0x00, 0x04, 0x04, 0x02, 0x01, 0x03, 0xFA,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x01, 0x00, 0xF8, 0x10, 0x02, 0x20,
  0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x0C, 0x40, 0x18, 0x80, 0x61, 0x01, 0x42, 0x06, 0x83, 0xF1, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x05, 0x00, 0x68, 0x02, 0x40, 0x21, 0x01, 0x08, 0x10,
  0x40, 0x82, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0x09,
  0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0xA0, 0x18, 0x05, 0x00, 0xC0, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x12,
  0x04, 0x81, 0x10, 0x24, 0x08, 0x82, 0x20, 0x84, 0x10, 0x84, 0x21, 0x04,
  0x41, 0x08, 0x22, 0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40, 0x48, 0x0A,
  0x02, 0x80, 0x60, 0x14, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x00, 0x08, 0x01, 0x0C, 0x03, 0x04, 0x02, 0x04, 0x04, 0x02, 0x08, 0x02,
  0x10, 0x02, 0x30, 0x01, 0x20, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x30, 0x20, 0x20,
  0x10, 0x40, 0x10, 0x80, 0x18, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x07, 0x00, 0x60, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x00, 0x63, 0x01, 0x80, 0xEE, 0x00,
  0x10,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 9, 11, 4, -26 },
  { 33, 19, 26, 19, 1, -26 },
  { 95, 16, 30, 18, 1, -28 },
  { 155, 20, 27, 25, 3, -27 },
  { 223, 18, 27, 20, 1, -27 },
  { 284, 3, 9, 6, 4, -26 },
  { 288, 10, 32, 9, 1, -26 },
  { 328, 10, 32, 9, -2, -26 },
  { 368, 12, 13, 17, 5, -28 },
  { 388, 16, 17, 19, 2, -22 },
  { 422, 5, 9, 6, -2, -4 },
  { 428, 9, 1, 11, 1, -11 },
  { 430, 2, 2, 7, 1, -2 },
  { 431, 16, 26, 11, -2, -26 },
  { 483, 15, 27, 18, 2, -27 },
  { 534, 8, 26, 18, 5, -26 },
  { 560, 17, 27, 18, 0, -27 },
  { 618, 17, 27, 18, 0, -27 },
  { 676, 17, 27, 18, 0, -27 },
  { 734, 16, 26, 18, 1, -26 },
  { 786, 16, 27, 18, 2, -27 },
  { 840, 15, 26, 18, 3, -26 },
  { 889, 16, 27, 18, 1, -27 },
  { 943, 16, 27, 18, 1, -27 },
  { 997, 5, 20, 7, 1, -20 },
  { 1010, 8, 25, 7, -2, -20 },
  { 1035, 16, 16, 19, 2, -21 },
  { 1067, 16, 8, 19, 2, -17 },
  { 1083, 16, 16, 19, 2, -21 },
  { 1115, 12, 27, 13, 2, -27 },
  { 1156, 24, 29, 26, 2, -26 },
  { 1243, 17, 26, 17, -2, -26 },
  { 1299, 18, 26, 19, 1, -26 },
  { 1358, 18, 27, 19, 2, -27 },
  { 1419, 19, 26, 21, 1, -26 },
  { 1481, 17, 26, 17, 1, -26 },
  { 1537, 17, 26, 16, 1, -26 },
  { 1593, 20, 27, 22, 2, -27 },
  { 1661, 21, 26, 22, 1, -26 },
  { 1730, 12, 26, 9, -1, -26 },
  { 1769, 14, 32, 8, -6, -26 },
  { 1825, 19, 26, 17, 1, -26 },
  { 1887, 12, 26, 16, 1, -26 },
  { 1926, 26, 26, 27, 1, -26 },
  { 2011, 21, 26, 22, 1, -26 },
  { 2080, 20, 27, 23, 2, -27 },
  { 2148, 17, 26, 18, 1, -26 },
  { 2204, 20, 33, 23, 2, -27 },
  { 2287, 17, 26, 18, 1, -26 },
  { 2343, 17, 27, 16, 0, -27 },
  { 2401, 16, 26, 15, 3, -26 },
  { 2453, 20, 26, 22, 2, -26 },
  { 2518, 16, 26, 17, 4, -26 },
  { 2570, 26, 26, 27, 4, -26 },
  { 2655, 20, 26, 16, -2, -26 },
  { 2720, 16, 26, 15, 3, -26 },
  { 2772, 19, 26, 17, -1, -26 },
  { 2834, 13, 32, 11, 0, -26 },
  { 2886, 5, 26, 12, 4, -26 },
  { 2903, 14, 32, 11, -3, -26 },
  { 2959, 15, 15, 18, 2, -27 },
  { 2988, 12, 1, 12, -3, 4 },
  { 2990, 4, 6, 8, 5, -28 },
  { 2993, 15, 20, 18, 2, -20 },
  { 3031, 16, 28, 18, 1, -28 },
  { 3087, 13, 20, 14, 2, -20 },
  { 3120, 17, 28, 18, 2, -28 },
  { 3180, 13, 20, 16, 2, -20 },
  { 3213, 19, 37, 9, -5, -28 },
  { 3301, 17, 29, 18, 0, -20 },
  { 3363, 15, 28, 18, 1, -28 },
  { 3416, 7, 27, 7, 1, -27 },
  { 3440, 13, 36, 7, -5, -27 },
  { 3499, 15, 28, 14, 1, -28 },
  { 3552, 7, 28, 7, 1, -28 },
  { 3577, 24, 20, 27, 1, -20 },
  { 3637, 15, 20, 18, 1, -20 },
  { 3675, 14, 20, 18, 2, -20 },
  { 3710, 18, 29, 18, -1, -20 },
  { 3776, 15, 29, 18, 2, -20 },
  { 3831, 12, 20, 12, 1, -20 },
  { 3861, 13, 20, 14, 0, -20 },
  { 3894, 9, 24, 10, 1, -24 },
  { 3921, 15, 20, 18, 2, -20 },
  { 3959, 13, 20, 13, 2, -20 },
  { 3992, 21, 20, 22, 2, -20 },
  { 4045, 16, 20, 15, -1, -20 },
  { 4085, 19, 29, 14, -4, -20 },
  { 4154, 15, 20, 13, -1, -20 },
  { 4192, 13, 32, 12, 1, -26 },
  { 4244, 1, 37, 17, 9, -28 },
  { 4249, 13, 32, 12, -2, -26 },
  { 4301, 16, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC37PT7B_H_
