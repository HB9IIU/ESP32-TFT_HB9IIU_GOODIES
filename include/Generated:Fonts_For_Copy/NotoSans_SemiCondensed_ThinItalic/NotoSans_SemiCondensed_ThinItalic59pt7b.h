#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x11, 0x83, 0x10, 0x33, 0x03, 0x30, 0x23, 0x02, 0x20, 0x62, 0x06, 0x60,
  0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xCC, 0x08, 0x80, 0x80, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x04, 0x00, 0x80, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x80, 0x10,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x02, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xE1, 0x07, 0x01, 0xC1, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x80, 0x00, 0x18, 0x40, 0x00, 0x07,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x05, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x04, 0x02, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x00, 0x01, 0x01, 0x81, 0x00, 0x83, 0x80, 0xF8, 0x4F,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x01, 0xC3, 0x00, 0x03, 0x00,
  0xC0, 0xC0, 0x01, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x10, 0x01, 0x80,
  0x60, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x30, 0x02, 0x00, 0xC0,
  0x10, 0x01, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x00, 0x60, 0x30, 0x02, 0x00, 0x30, 0x30, 0x01, 0x00, 0x18, 0x10,
  0x01, 0x80, 0x08, 0x18, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x60, 0x06, 0x08,
  0x1C, 0x30, 0x02, 0x0C, 0x3F, 0x98, 0x03, 0x0C, 0x30, 0x6C, 0x01, 0x84,
  0x30, 0x16, 0x01, 0x86, 0x30, 0x0D, 0x00, 0xC6, 0x18, 0x06, 0xC0, 0xC2,
  0x18, 0x03, 0x60, 0xC3, 0x0C, 0x01, 0x9F, 0xC3, 0x04, 0x00, 0xC3, 0x81,
  0x86, 0x00, 0x60, 0x01, 0x83, 0x00, 0x30, 0x01, 0x81, 0x00, 0x10, 0x00,
  0xC1, 0x80, 0x08, 0x00, 0xC0, 0xC0, 0x04, 0x00, 0x40, 0x60, 0x06, 0x00,
  0x60, 0x20, 0x03, 0x00, 0x60, 0x10, 0x01, 0x00, 0x20, 0x08, 0x00, 0x80,
  0x30, 0x04, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x60, 0x10, 0x01, 0x00, 0x60,
  0x18, 0x00, 0x80, 0x30, 0x18, 0x00, 0x60, 0x30, 0x08, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0x0C, 0x38, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x86, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x07, 0x01, 0x00, 0x08, 0x60, 0x0C, 0x00, 0xC6,
  0x00, 0x20, 0x06, 0x30, 0x01, 0x80, 0x23, 0x00, 0x06, 0x03, 0x10, 0x00,
  0x30, 0x31, 0x80, 0x00, 0xC1, 0x8C, 0x00, 0x02, 0x18, 0x40, 0x00, 0x18,
  0x82, 0x00, 0x00, 0x4C, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x0D, 0x01, 0x80, 0x00, 0xCC, 0x0E, 0x00,
  0x0C, 0x30, 0x38, 0x00, 0xC1, 0x80, 0xE0, 0x3C, 0x06, 0x03, 0xFF, 0x80,
  0x10, 0x03, 0x80, 0x00, 0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x63, 0x10,
  0x84, 0x62, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x20, 0x08, 0x03, 0x80, 0x40, 0x07, 0x06, 0x00,
  0x0C, 0x20, 0x00, 0x19, 0x00, 0xC0, 0x29, 0xFE, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0xC8, 0x00, 0x0C, 0x40, 0x00, 0x83, 0x00, 0x18, 0x08, 0x01,
  0x80, 0x60, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x20, 0x40, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0x40, 0x00, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0F,
  0x01, 0xB0, 0x33, 0x0E, 0x21, 0x82, 0x70, 0x6C, 0x06, 0x80, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x40, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x40, 0x20, 0x00, 0x30, 0x08, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x10, 0x18,
  0x00, 0x04, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xDF, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x04, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x1F, 0x80, 0x0C, 0x3F, 0xF0, 0x04, 0x70, 0x0C, 0x02, 0x60,
  0x03, 0x03, 0x60, 0x00, 0xC1, 0xE0, 0x00, 0x20, 0xE0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x40, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00,
  0x80, 0x30, 0x00, 0x30, 0x08, 0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x40, 0x60, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x08, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x18, 0x07, 0x00, 0x03, 0x03, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x01, 0x80, 0x07, 0x00, 0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x88, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x70, 0x40, 0x00, 0x78, 0x30, 0x00, 0x68, 0x0C, 0x00, 0x64, 0x03, 0x00,
  0xE6, 0x00, 0xFF, 0xC3, 0x00, 0x0F, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x40, 0x38, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x70, 0x0E, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x1F, 0xC0, 0x0C, 0x60, 0x01, 0xF7, 0xC0, 0x31, 0x80, 0x0C,
  0x03, 0x00, 0xC4, 0x00, 0x60, 0x08, 0x03, 0x30, 0x03, 0x00, 0x20, 0x0C,
  0x80, 0x18, 0x01, 0x80, 0x36, 0x00, 0xC0, 0x06, 0x00, 0xD8, 0x02, 0x00,
  0x10, 0x03, 0x40, 0x18, 0x00, 0x40, 0x09, 0x00, 0x40, 0x03, 0x00, 0x2C,
  0x03, 0x00, 0x0C, 0x01, 0xB0, 0x0C, 0x00, 0x20, 0x06, 0xC0, 0x20, 0x01,
  0x80, 0x13, 0x00, 0x80, 0x06, 0x00, 0xC8, 0x06, 0x00, 0x18, 0x03, 0x20,
  0x18, 0x00, 0xC0, 0x08, 0x80, 0x60, 0x03, 0x00, 0x62, 0x01, 0x80, 0x1C,
  0x01, 0x08, 0x06, 0x00, 0x50, 0x0C, 0x20, 0x08, 0x03, 0x40, 0x60, 0x80,
  0x30, 0x19, 0x03, 0x02, 0x00, 0x61, 0xC6, 0x18, 0x0C, 0x00, 0xFE, 0x0F,
  0xC0, 0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFC,
  0x00, 0x04, 0x01, 0xF8, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70,
  0x06, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xC0,
  0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x30, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0xFC, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x02,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x00,
  0x00, 0xE0, 0x04, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x60, 0x00, 0x7F, 0xF8, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x80, 0x0E, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x08, 0x38, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x0E, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00, 0x23,
  0x40, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x03, 0xC1,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xA0,
  0x0B, 0x00, 0x00, 0x00, 0xF0, 0x05, 0x80, 0x00, 0x00, 0xD8, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x03, 0x20, 0x00, 0x00, 0x64, 0x01, 0x90, 0x00, 0x00,
  0x22, 0x00, 0x88, 0x00, 0x00, 0x33, 0x00, 0x44, 0x00, 0x00, 0x11, 0x80,
  0x63, 0x00, 0x00, 0x18, 0x80, 0x31, 0x80, 0x00, 0x18, 0x40, 0x18, 0xC0,
  0x00, 0x0C, 0x60, 0x08, 0x20, 0x00, 0x0C, 0x30, 0x04, 0x10, 0x00, 0x06,
  0x18, 0x06, 0x08, 0x00, 0x06, 0x08, 0x03, 0x04, 0x00, 0x02, 0x04, 0x01,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x01, 0x80, 0x80, 0x30, 0x10, 0x00, 0xC0,
  0x40, 0x10, 0x08, 0x00, 0xC0, 0x60, 0x08, 0x04, 0x00, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x10, 0x06, 0x00, 0x80, 0x30, 0x18, 0x03,
  0x00, 0xC0, 0x08, 0x18, 0x01, 0x00, 0x60, 0x04, 0x0C, 0x00, 0x80, 0x30,
  0x02, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x86, 0x00, 0x60, 0x18, 0x00, 0xC6,
  0x00, 0x30, 0x0C, 0x00, 0x62, 0x00, 0x10, 0x06, 0x00, 0x33, 0x00, 0x08,
  0x02, 0x00, 0x09, 0x00, 0x0C, 0x01, 0x00, 0x05, 0x80, 0x06, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x30, 0x0B, 0x00, 0x00, 0x10,
  0x04, 0x80, 0x00, 0x08, 0x06, 0x60, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x06,
  0x01, 0x88, 0x00, 0x02, 0x00, 0x86, 0x00, 0x01, 0x00, 0x43, 0x00, 0x01,
  0x80, 0x60, 0x80, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x60, 0x18, 0x30, 0x00,
  0x20, 0x08, 0x08, 0x00, 0x10, 0x04, 0x06, 0x00, 0x18, 0x06, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x80, 0x06, 0x01, 0x00, 0x60, 0x02, 0x00, 0x80, 0x30,
  0x01, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x10, 0x00, 0x80, 0x20, 0x08, 0x00, 0x60, 0x30, 0x0C, 0x00,
  0x30, 0x18, 0x06, 0x00, 0x08, 0x0C, 0x03, 0x00, 0x06, 0x04, 0x01, 0x00,
  0x03, 0x02, 0x00, 0x80, 0x00, 0x83, 0x00, 0xC0, 0x00, 0x61, 0x80, 0x60,
  0x00, 0x30, 0xC0, 0x30, 0x00, 0x08, 0x40, 0x10, 0x00, 0x06, 0x20, 0x18,
  0x00, 0x03, 0x30, 0x0C, 0x00, 0x00, 0x98, 0x06, 0x00, 0x00, 0x6C, 0x02,
  0x00, 0x00, 0x34, 0x01, 0x00, 0x00, 0x0A, 0x01, 0x80, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x08, 0x07,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x02, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x03, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x08, 0x07, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x02, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x03,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x40, 0x18, 0x00, 0x08, 0x01, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x30,
  0x00, 0x60, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x81, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x10, 0x00, 0x18, 0x04, 0x00,
  0x06, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x02, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x00, 0x00, 0x64, 0x00, 0x01, 0xC0, 0x00, 0x19, 0x00, 0x00,
  0x50, 0x00, 0x04, 0x40, 0x00, 0x34, 0x00, 0x03, 0x10, 0x00, 0x0D, 0x00,
  0x00, 0x84, 0x00, 0x06, 0x40, 0x00, 0x61, 0x00, 0x01, 0x90, 0x00, 0x10,
  0x40, 0x00, 0x44, 0x00, 0x0C, 0x10, 0x00, 0x31, 0x00, 0x03, 0x04, 0x00,
  0x08, 0x40, 0x00, 0x81, 0x00, 0x06, 0x10, 0x00, 0x60, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x10, 0x00, 0xC1, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x40, 0x02,
  0x01, 0x00, 0x18, 0x10, 0x01, 0x80, 0x40, 0x06, 0x04, 0x00, 0x60, 0x10,
  0x01, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x06, 0x03, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x08, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x06, 0x04,
  0x00, 0x60, 0x40, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x06,
  0x08, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x61, 0x00,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x19,
  0x80, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00,
  0x09, 0x00, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xA0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x86,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x08, 0x00, 0x20, 0x04, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0xC0,
  0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30,
  0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C,
  0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x61, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x10,
  0x04, 0x00, 0x08, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x80, 0x00, 0x09, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x82, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0xE0,
  0x63, 0x03, 0x80, 0x33, 0x07, 0x00, 0x12, 0x06, 0x00, 0x1A, 0x0C, 0x00,
  0x0A, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x70, 0x80, 0x00, 0x60, 0x80, 0x00, 0xE0, 0x80, 0x00, 0xE0, 0xC0, 0x01,
  0x60, 0xC0, 0x03, 0x40, 0x60, 0x06, 0x40, 0x60, 0x0C, 0x40, 0x38, 0x38,
  0x40, 0x1F, 0xE0, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x3C, 0x00, 0x10, 0x7F, 0xC0, 0x04, 0x70, 0x38, 0x03,
  0x30, 0x03, 0x00, 0xD8, 0x00, 0x40, 0x2C, 0x00, 0x18, 0x0B, 0x00, 0x02,
  0x07, 0x80, 0x00, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x60, 0x68, 0x00, 0x30, 0x13, 0x00, 0x1C, 0x04,
  0x60, 0x0E, 0x01, 0x1C, 0x0E, 0x00, 0xC1, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x38, 0x04, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x18, 0x01, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x70, 0x18, 0x00, 0x7F, 0xE1, 0x80, 0x0E, 0x07, 0x10,
  0x03, 0x80, 0x19, 0x00, 0x70, 0x00, 0x90, 0x06, 0x00, 0x0F, 0x00, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x03, 0x80, 0x80, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x70, 0x08, 0x00, 0x0F, 0x00, 0x80, 0x00, 0xF0, 0x0C, 0x00, 0x1A, 0x00,
  0xC0, 0x03, 0x20, 0x04, 0x00, 0x62, 0x00, 0x60, 0x0E, 0x60, 0x03, 0x83,
  0x86, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0x8C,
  0x00, 0x0C, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0x00, 0x3C,
  0x19, 0xFF, 0x00, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x70, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x0C, 0x00, 0xE0, 0x71, 0x80, 0x70, 0x03, 0x20, 0x1C, 0x00, 0x24, 0x03,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x10, 0x00,
  0x03, 0x02, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x3C, 0x04, 0x00, 0x07, 0x80, 0xC0, 0x01,
  0xA0, 0x18, 0x00, 0x64, 0x01, 0x00, 0x1D, 0x80, 0x30, 0x06, 0x30, 0x03,
  0x83, 0x86, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x40, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x07, 0x80, 0x04, 0x1F, 0xF0, 0x02, 0x38, 0x0C, 0x03, 0x30, 0x03, 0x01,
  0xB0, 0x00, 0x80, 0xB0, 0x00, 0x40, 0x50, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x08, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x80, 0x00,
  0x20, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x8E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x03, 0x01, 0x00, 0x06, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x04, 0x06, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x08, 0xF0, 0x00,
  0x09, 0x98, 0x00, 0x1B, 0x18, 0x00, 0x1E, 0x08, 0x00, 0x1C, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x06, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x02, 0x1F, 0xF0, 0x1F, 0xF0,
  0x04, 0x60, 0x70, 0x60, 0x30, 0x19, 0x80, 0x61, 0x80, 0x30, 0x26, 0x00,
  0x66, 0x00, 0x60, 0x58, 0x00, 0xD8, 0x00, 0x40, 0xA0, 0x00, 0xE0, 0x00,
  0x83, 0x80, 0x03, 0x80, 0x01, 0x07, 0x00, 0x07, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x40, 0x00, 0x61, 0x80, 0x00, 0x80, 0x00, 0x83, 0x00,
  0x03, 0x00, 0x01, 0x04, 0x00, 0x06, 0x00, 0x06, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x10, 0x00, 0x18, 0x60, 0x00, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x80, 0x01, 0x82, 0x00, 0x02, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x18, 0x00, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x40, 0x00, 0x60, 0x00, 0x61, 0x80, 0x00, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x00, 0x01, 0x06, 0x00, 0x06, 0x00, 0x02, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x00, 0x18, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x00, 0xF0, 0x01, 0x07, 0xFC, 0x01, 0x1C, 0x06, 0x03,
  0x30, 0x03, 0x02, 0x60, 0x03, 0x02, 0xC0, 0x01, 0x02, 0x80, 0x01, 0x07,
  0x80, 0x01, 0x07, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0xC0, 0x0C,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x82, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x07, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x07, 0xFC, 0x00, 0x08, 0xE0, 0x70,
  0x00, 0xCE, 0x00, 0xC0, 0x06, 0xC0, 0x02, 0x00, 0x26, 0x00, 0x18, 0x01,
  0x60, 0x00, 0x40, 0x0E, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x03,
  0xC0, 0x00, 0xC0, 0x1A, 0x00, 0x0C, 0x00, 0xD8, 0x00, 0xE0, 0x04, 0x60,
  0x0E, 0x00, 0x23, 0x81, 0xC0, 0x03, 0x07, 0xFC, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x38, 0x1C, 0x60, 0x70, 0x03,
  0x20, 0x70, 0x00, 0x90, 0x30, 0x00, 0x68, 0x30, 0x00, 0x3C, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0xF0, 0x40, 0x00, 0x78, 0x30, 0x00, 0x68,
  0x18, 0x00, 0x64, 0x04, 0x00, 0x76, 0x03, 0x00, 0x73, 0x00, 0xE0, 0xE1,
  0x80, 0x3F, 0xE0, 0x80, 0x01, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xE0, 0x10, 0x7F, 0x01, 0x1C, 0x00, 0x33, 0x00, 0x02, 0x60,
  0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0x80, 0x70, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x40, 0x01, 0x83, 0xC0, 0x38, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x3F, 0xFE, 0x8C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xE0,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80,
  0x00, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x40, 0x80, 0x03, 0x40, 0xC0,
  0x06, 0x40, 0xC0, 0x0C, 0xC0, 0x70, 0x38, 0xC0, 0x3F, 0xE0, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01,
  0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x05, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x48, 0x00, 0x28, 0x00, 0x64, 0x00, 0x34, 0x00, 0x22, 0x00, 0x12, 0x00,
  0x31, 0x00, 0x19, 0x00, 0x10, 0x80, 0x08, 0x80, 0x18, 0x40, 0x0C, 0x40,
  0x0C, 0x20, 0x04, 0x20, 0x04, 0x10, 0x06, 0x10, 0x06, 0x08, 0x02, 0x08,
  0x02, 0x04, 0x03, 0x04, 0x03, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x81,
  0x81, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0xC0, 0x60, 0xC0, 0x20, 0x40,
  0x30, 0x60, 0x10, 0x60, 0x18, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30,
  0x02, 0x10, 0x03, 0x18, 0x01, 0x18, 0x01, 0x98, 0x00, 0x88, 0x00, 0xCC,
  0x00, 0x4C, 0x00, 0x64, 0x00, 0x24, 0x00, 0x36, 0x00, 0x16, 0x00, 0x1A,
  0x00, 0x0B, 0x00, 0x0F, 0x00, 0x05, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x30, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x87, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x98, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0xD0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 42, 12, 2, -42 },
  { 59, 12, 15, 17, 6, -42 },
  { 82, 31, 42, 31, 1, -42 },
  { 245, 25, 48, 28, 2, -45 },
  { 395, 33, 44, 40, 4, -43 },
  { 577, 29, 44, 32, 1, -43 },
  { 737, 5, 15, 10, 6, -42 },
  { 747, 16, 51, 14, 2, -42 },
  { 849, 16, 51, 14, -4, -42 },
  { 951, 21, 22, 27, 7, -45 },
  { 1009, 25, 27, 30, 3, -34 },
  { 1094, 8, 14, 10, -3, -6 },
  { 1108, 13, 2, 17, 2, -17 },
  { 1112, 2, 3, 11, 2, -3 },
  { 1113, 25, 42, 18, -3, -42 },
  { 1245, 24, 44, 28, 3, -43 },
  { 1377, 12, 42, 28, 9, -42 },
  { 1440, 26, 43, 28, 0, -43 },
  { 1580, 27, 44, 28, 0, -43 },
  { 1729, 26, 42, 28, 0, -42 },
  { 1866, 27, 43, 28, 1, -42 },
  { 2012, 25, 44, 28, 3, -43 },
  { 2150, 24, 42, 28, 5, -42 },
  { 2276, 26, 44, 28, 1, -43 },
  { 2419, 25, 44, 28, 2, -43 },
  { 2557, 9, 31, 11, 1, -31 },
  { 2592, 13, 39, 11, -3, -31 },
  { 2656, 25, 26, 30, 3, -34 },
  { 2738, 25, 14, 30, 3, -28 },
  { 2782, 25, 26, 30, 3, -34 },
  { 2864, 19, 43, 20, 3, -43 },
  { 2967, 38, 47, 42, 3, -42 },
  { 3191, 27, 42, 28, -3, -42 },
  { 3333, 28, 42, 30, 2, -42 },
  { 3480, 29, 44, 30, 4, -43 },
  { 3640, 30, 42, 34, 2, -42 },
  { 3798, 27, 42, 27, 2, -42 },
  { 3940, 27, 42, 25, 2, -42 },
  { 4082, 31, 44, 36, 4, -43 },
  { 4253, 33, 42, 35, 2, -42 },
  { 4427, 18, 42, 14, -1, -42 },
  { 4522, 22, 52, 12, -9, -42 },
  { 4665, 31, 42, 28, 2, -42 },
  { 4828, 18, 42, 25, 2, -42 },
  { 4923, 41, 42, 43, 2, -42 },
  { 5139, 33, 42, 35, 2, -42 },
  { 5313, 30, 44, 36, 4, -43 },
  { 5478, 27, 42, 28, 2, -42 },
  { 5620, 30, 53, 36, 4, -43 },
  { 5819, 27, 42, 29, 2, -42 },
  { 5961, 27, 44, 26, 0, -43 },
  { 6110, 25, 42, 24, 5, -42 },
  { 6242, 31, 43, 35, 4, -42 },
  { 6409, 26, 42, 27, 6, -42 },
  { 6546, 42, 42, 44, 6, -42 },
  { 6767, 32, 42, 25, -3, -42 },
  { 6935, 25, 42, 24, 5, -42 },
  { 7067, 30, 42, 27, -1, -42 },
  { 7225, 22, 51, 17, -1, -42 },
  { 7366, 8, 42, 18, 6, -42 },
  { 7408, 22, 51, 17, -4, -42 },
  { 7549, 25, 24, 29, 2, -42 },
  { 7624, 20, 2, 20, -5, 6 },
  { 7629, 6, 9, 13, 9, -45 },
  { 7636, 24, 33, 29, 3, -32 },
  { 7735, 26, 46, 29, 1, -45 },
  { 7885, 21, 33, 23, 3, -32 },
  { 7972, 28, 46, 29, 3, -45 },
  { 8133, 21, 33, 25, 3, -32 },
  { 8220, 30, 59, 14, -8, -45 },
  { 8442, 27, 46, 29, 1, -32 },
  { 8598, 25, 45, 28, 1, -45 },
  { 8739, 11, 42, 11, 1, -42 },
  { 8797, 20, 56, 11, -8, -42 },
  { 8937, 24, 45, 23, 1, -45 },
  { 9072, 11, 45, 11, 1, -45 },
  { 9134, 39, 32, 43, 1, -32 },
  { 9290, 24, 32, 28, 1, -32 },
  { 9386, 23, 33, 29, 3, -32 },
  { 9481, 29, 46, 29, -2, -32 },
  { 9648, 25, 46, 29, 3, -32 },
  { 9792, 20, 32, 19, 1, -32 },
  { 9872, 21, 33, 22, 0, -32 },
  { 9959, 15, 40, 15, 2, -39 },
  { 10034, 24, 32, 28, 3, -31 },
  { 10130, 21, 31, 21, 3, -31 },
  { 10212, 33, 31, 34, 3, -31 },
  { 10340, 26, 31, 23, -2, -31 },
  { 10441, 32, 45, 22, -7, -31 },
  { 10621, 23, 31, 21, -1, -31 },
  { 10711, 20, 51, 19, 2, -42 },
  { 10839, 1, 59, 27, 14, -45 },
  { 10847, 20, 51, 19, -3, -42 },
  { 10975, 25, 5, 30, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC59PT7B_H_
