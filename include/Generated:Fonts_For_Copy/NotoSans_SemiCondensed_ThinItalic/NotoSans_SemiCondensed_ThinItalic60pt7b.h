#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x18, 0xC0, 0x86, 0x04, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0x84, 0x04, 0x20, 0x63, 0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x61,
  0x02, 0x10, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00, 0x01, 0x00, 0x20, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xF1, 0x0F, 0x00, 0xC0, 0x80, 0x80, 0xC0, 0x40, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x20, 0x00, 0x01,
  0xD0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x02, 0x70, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x20, 0x10, 0x00, 0x10, 0x08, 0x00, 0x18, 0x04,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x80, 0x41, 0xC0, 0x7C, 0x27,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0x01, 0xC7, 0x00, 0x03, 0x01, 0x81, 0x80, 0x03,
  0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x01,
  0x80, 0x40, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x40, 0x10, 0x01, 0x80, 0x60, 0x18, 0x00, 0x80, 0x60, 0x0C, 0x00, 0x40,
  0x20, 0x06, 0x00, 0x20, 0x30, 0x02, 0x00, 0x30, 0x30, 0x01, 0x00, 0x18,
  0x10, 0x00, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x04, 0x18, 0x00, 0x60, 0x06,
  0x08, 0x3F, 0x30, 0x03, 0x0C, 0x39, 0xD8, 0x01, 0x0C, 0x30, 0x3C, 0x01,
  0x86, 0x30, 0x1E, 0x01, 0x86, 0x10, 0x05, 0x00, 0xC6, 0x18, 0x02, 0xC0,
  0xC3, 0x08, 0x01, 0x30, 0xC3, 0x0C, 0x00, 0x9F, 0xC1, 0x04, 0x00, 0x40,
  0x01, 0x82, 0x00, 0x20, 0x01, 0x83, 0x00, 0x10, 0x00, 0x81, 0x80, 0x18,
  0x00, 0xC0, 0x80, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x00, 0x40, 0x60, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x00, 0x60, 0x18, 0x01, 0x80, 0x20, 0x0C, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x40, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x30, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x10,
  0x18, 0x0C, 0x00, 0x0C, 0x18, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x81, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x30, 0xC0, 0x08, 0x00, 0x86, 0x00, 0x30, 0x06, 0x10,
  0x00, 0x60, 0x18, 0xC0, 0x01, 0x80, 0xC2, 0x00, 0x03, 0x02, 0x18, 0x00,
  0x0C, 0x18, 0x60, 0x00, 0x18, 0x41, 0x00, 0x00, 0x23, 0x04, 0x00, 0x00,
  0xD8, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x06, 0x40, 0x30, 0x00, 0x71, 0x80,
  0xE0, 0x03, 0x03, 0x01, 0xC0, 0x78, 0x0C, 0x01, 0xFF, 0x80, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x21,
  0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x70, 0x08, 0x00, 0xC0, 0x40, 0x03, 0x82, 0x00, 0x06, 0x20, 0x00,
  0x0D, 0x07, 0xC0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x88,
  0x00, 0x18, 0x20, 0x01, 0x81, 0x00, 0x18, 0x0C, 0x03, 0x80, 0x20, 0x08,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20,
  0x40, 0xC0, 0xFF, 0xFC, 0x5F, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x04, 0x40, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x34, 0x07, 0x60, 0x63, 0x0E, 0x18, 0xE0, 0x8C, 0x04,
  0xC0, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x18, 0x10, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x78, 0x08, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x07, 0xFC, 0x00, 0xC7, 0x83, 0x80, 0x23, 0x00, 0x30,
  0x09, 0x80, 0x06, 0x06, 0x80, 0x00, 0x81, 0xE0, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7B, 0x00,
  0x00, 0x3C, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x06, 0x01, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0x60, 0x00, 0x78,
  0x30, 0x00, 0x6C, 0x0C, 0x00, 0xE4, 0x03, 0x81, 0xE2, 0x00, 0xFF, 0xC3,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x40,
  0x38, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0xE0, 0xF0, 0x20, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x00, 0x41, 0x80, 0x07, 0xFF,
  0x00, 0x86, 0x00, 0x1C, 0x0C, 0x01, 0x0C, 0x00, 0xE0, 0x18, 0x02, 0x30,
  0x03, 0x80, 0x30, 0x06, 0x60, 0x06, 0x00, 0x60, 0x08, 0x80, 0x18, 0x00,
  0x80, 0x13, 0x00, 0x60, 0x03, 0x00, 0x26, 0x00, 0x80, 0x06, 0x00, 0x48,
  0x03, 0x00, 0x0C, 0x01, 0x90, 0x06, 0x00, 0x10, 0x03, 0x60, 0x18, 0x00,
  0x60, 0x06, 0xC0, 0x30, 0x00, 0xC0, 0x09, 0x80, 0x60, 0x01, 0x00, 0x33,
  0x00, 0x80, 0x06, 0x00, 0x64, 0x01, 0x00, 0x0C, 0x00, 0x88, 0x02, 0x00,
  0x18, 0x03, 0x10, 0x04, 0x00, 0x70, 0x06, 0x20, 0x08, 0x00, 0xE0, 0x18,
  0x40, 0x10, 0x03, 0xC0, 0x60, 0x80, 0x30, 0x0D, 0x80, 0xC1, 0x00, 0x60,
  0x33, 0x03, 0x03, 0x00, 0x60, 0xC3, 0x1C, 0x06, 0x00, 0x7F, 0x07, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x20,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x60, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x18, 0x00,
  0x80, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x40, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x00, 0x60, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x40, 0x0F, 0x80, 0x0C,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x04, 0x00,
  0x03, 0x80, 0x40, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0x80, 0x02,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0E, 0x00,
  0x20, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xF8, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x02, 0x0E, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x08, 0x03,
  0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x01, 0x03, 0x80, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0x4E, 0xC0, 0x00,
  0x01, 0x99, 0x80, 0x00, 0x03, 0x61, 0x00, 0x00, 0x07, 0x83, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x24, 0x00, 0x00, 0x03, 0x60, 0x09,
  0x00, 0x00, 0x00, 0x90, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x01, 0x90, 0x00,
  0x00, 0x13, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x11, 0x80, 0x00, 0x06,
  0x20, 0x04, 0x60, 0x00, 0x01, 0x88, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0xC2, 0x00, 0x00, 0x31, 0x80, 0x30, 0x80, 0x00, 0x18, 0x60, 0x08, 0x20,
  0x00, 0x04, 0x10, 0x02, 0x08, 0x00, 0x03, 0x04, 0x01, 0x83, 0x00, 0x00,
  0x83, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x00, 0x30, 0x30,
  0x04, 0x0C, 0x00, 0x0C, 0x08, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0xC0,
  0x40, 0x01, 0x81, 0x80, 0x30, 0x10, 0x00, 0xC0, 0x60, 0x08, 0x06, 0x00,
  0x20, 0x18, 0x02, 0x01, 0x80, 0x18, 0x04, 0x01, 0x80, 0x60, 0x04, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x60, 0x08, 0x01, 0x00, 0x20, 0x30, 0x02, 0x00, 0xC0, 0x08,
  0x08, 0x01, 0x80, 0x30, 0x03, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC1, 0x00,
  0x18, 0x02, 0x00, 0x30, 0xC0, 0x04, 0x00, 0x80, 0x0C, 0x20, 0x01, 0x00,
  0x60, 0x01, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x4C, 0x00, 0x30, 0x06, 0x00,
  0x13, 0x00, 0x0C, 0x01, 0x00, 0x05, 0x80, 0x02, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x80, 0x30, 0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x08, 0x03, 0xC0, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x24,
  0x00, 0x00, 0x60, 0x09, 0x80, 0x00, 0x18, 0x06, 0x60, 0x00, 0x04, 0x01,
  0x88, 0x00, 0x01, 0x00, 0x63, 0x00, 0x00, 0xC0, 0x10, 0xC0, 0x00, 0x30,
  0x04, 0x10, 0x00, 0x08, 0x03, 0x06, 0x00, 0x02, 0x00, 0xC1, 0x80, 0x01,
  0x80, 0x30, 0x20, 0x00, 0x60, 0x08, 0x0C, 0x00, 0x18, 0x02, 0x03, 0x00,
  0x04, 0x01, 0x80, 0x40, 0x01, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x02, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x30, 0x01, 0x00, 0x60, 0x08, 0x00, 0x60, 0x18, 0x02,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x02, 0x01, 0x00, 0x60, 0x00, 0xC0, 0xC0,
  0x18, 0x00, 0x30, 0x30, 0x04, 0x00, 0x04, 0x0C, 0x01, 0x00, 0x01, 0x82,
  0x00, 0xC0, 0x00, 0x60, 0x80, 0x30, 0x00, 0x08, 0x60, 0x0C, 0x00, 0x03,
  0x18, 0x02, 0x00, 0x00, 0xC6, 0x00, 0x80, 0x00, 0x19, 0x00, 0x60, 0x00,
  0x06, 0x40, 0x18, 0x00, 0x01, 0xB0, 0x06, 0x00, 0x00, 0x3C, 0x01, 0x00,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x70, 0x08, 0x00,
  0x18, 0x03, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00,
  0x06, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0x40, 0x00, 0xE0, 0x08, 0x00, 0x78, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xC0, 0x7C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x20, 0x04, 0x00, 0x08, 0x03,
  0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x68, 0x00, 0x01, 0xC0, 0x00,
  0x1A, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x20,
  0x00, 0x0B, 0x00, 0x00, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x62, 0x00, 0x01,
  0x30, 0x00, 0x10, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x20, 0x00, 0x23, 0x00,
  0x03, 0x08, 0x00, 0x18, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x30, 0x00, 0x60,
  0x80, 0x03, 0x0C, 0x00, 0x10, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0xC0, 0x02, 0x02, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x0C,
  0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x40, 0x0C,
  0x03, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80,
  0x10, 0x08, 0x00, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x30, 0x10, 0x01, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00,
  0xC1, 0x80, 0x04, 0x08, 0x00, 0x30, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x41, 0x00, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x04,
  0x20, 0x00, 0x31, 0x80, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00,
  0x03, 0x30, 0x00, 0x11, 0x00, 0x00, 0x48, 0x00, 0x04, 0xC0, 0x00, 0x16,
  0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x58, 0x00, 0x01, 0xC0, 0x00,
  0x14, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x30, 0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x00, 0x00, 0x09, 0x80, 0x00, 0x05, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xC0,
  0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x04,
  0x18, 0x20, 0xC1, 0x82, 0x0C, 0x10, 0x00, 0x1F, 0xC1, 0x80, 0x3C, 0x70,
  0x80, 0x70, 0x0C, 0x40, 0x60, 0x03, 0x60, 0x60, 0x00, 0xB0, 0x60, 0x00,
  0x50, 0x30, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x10, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x50, 0x30, 0x00, 0x68, 0x18, 0x00, 0x6C, 0x06, 0x00, 0x66,
  0x03, 0x00, 0x62, 0x00, 0xE0, 0xE1, 0x00, 0x3F, 0xE0, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x3F, 0x80, 0x04, 0x3C, 0x78, 0x01, 0x18, 0x03, 0x00, 0xCC, 0x00,
  0x60, 0x36, 0x00, 0x18, 0x0B, 0x00, 0x02, 0x02, 0xC0, 0x00, 0xC1, 0xE0,
  0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x30,
  0x78, 0x00, 0x18, 0x1A, 0x00, 0x06, 0x04, 0xC0, 0x03, 0x01, 0x18, 0x03,
  0x80, 0x47, 0x01, 0xC0, 0x30, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xC3, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x80, 0x07, 0x8F, 0x18, 0x01, 0xC0,
  0x19, 0x80, 0x30, 0x00, 0x98, 0x06, 0x00, 0x0D, 0x00, 0xC0, 0x00, 0x50,
  0x0C, 0x00, 0x05, 0x01, 0x80, 0x00, 0x70, 0x10, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x38, 0x08,
  0x00, 0x07, 0x00, 0x80, 0x00, 0x70, 0x08, 0x00, 0x0D, 0x00, 0xC0, 0x01,
  0xB0, 0x0C, 0x00, 0x3B, 0x00, 0x60, 0x07, 0x20, 0x06, 0x00, 0xE2, 0x00,
  0x38, 0x38, 0x20, 0x01, 0xFF, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xC7, 0x00, 0x30, 0x0C, 0x07, 0x00, 0x30, 0x70, 0x01,
  0x83, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x01, 0xC1,
  0x00, 0x78, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x70, 0x0E, 0x00, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x20, 0x03, 0xC7, 0x84, 0x01, 0xC0, 0x19, 0x80, 0x60, 0x01,
  0x30, 0x18, 0x00, 0x34, 0x06, 0x00, 0x02, 0x80, 0xC0, 0x00, 0x50, 0x30,
  0x00, 0x0E, 0x04, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x1C, 0x08, 0x00, 0x03, 0x81, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x1C, 0x04,
  0x00, 0x06, 0x80, 0xC0, 0x01, 0xB0, 0x18, 0x00, 0x76, 0x01, 0x80, 0x1C,
  0x80, 0x30, 0x07, 0x10, 0x03, 0x83, 0x86, 0x00, 0x3F, 0xE0, 0xC0, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x02, 0x1E,
  0x3C, 0x01, 0x18, 0x03, 0x01, 0x98, 0x00, 0x80, 0xD8, 0x00, 0x60, 0x58,
  0x00, 0x30, 0x28, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x10,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x01, 0x00, 0x06, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x04, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x08, 0xD8, 0x00, 0x09,
  0x98, 0x00, 0x1B, 0x08, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x10, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x03, 0x00, 0x20, 0x01, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0x0E, 0x3C, 0x0E, 0x1C, 0x01, 0x38, 0x0C, 0x18, 0x06, 0x03,
  0x20, 0x06, 0x30, 0x03, 0x03, 0x40, 0x02, 0x60, 0x03, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0x03, 0x80, 0x02, 0x80, 0x03, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x00, 0x10, 0x60, 0x00, 0x30, 0x00, 0x10, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x60, 0x00, 0x20, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x03, 0xFC, 0x00, 0x87, 0x8F, 0x00, 0x46, 0x00, 0xC0, 0x66, 0x00,
  0x20, 0x36, 0x00, 0x18, 0x16, 0x00, 0x0C, 0x0A, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0xF0, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x01,
  0x0F, 0x1E, 0x00, 0x08, 0xE0, 0x18, 0x00, 0xCC, 0x00, 0x60, 0x06, 0xC0,
  0x03, 0x00, 0x2C, 0x00, 0x08, 0x01, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x40, 0x1A, 0x00, 0x06,
  0x00, 0xD8, 0x00, 0x60, 0x04, 0x60, 0x0E, 0x00, 0x23, 0x81, 0xE0, 0x03,
  0x07, 0xFC, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x7C, 0x78,
  0x40, 0x70, 0x0E, 0x20, 0x60, 0x01, 0x30, 0x60, 0x00, 0xD0, 0x60, 0x00,
  0x28, 0x30, 0x00, 0x14, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0xE1, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x70,
  0x40, 0x00, 0x68, 0x30, 0x00, 0x6C, 0x18, 0x00, 0x36, 0x06, 0x00, 0x32,
  0x03, 0x00, 0x71, 0x00, 0xE0, 0x71, 0x80, 0x3F, 0xE0, 0xC0, 0x01, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x01, 0x03, 0xF0, 0x10, 0xF1, 0x01,
  0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x87, 0xC0, 0xE0, 0x02, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x40, 0x01, 0x83, 0xC0, 0x38, 0x07,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x10, 0x0F, 0xE0, 0x06, 0x00, 0x04, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0x80, 0x00, 0x60, 0x80, 0x00, 0xE0, 0x80,
  0x00, 0xA0, 0x80, 0x01, 0xE0, 0x80, 0x03, 0x40, 0xC0, 0x06, 0x40, 0xC0,
  0x0C, 0x40, 0x70, 0x38, 0x40, 0x3F, 0xE0, 0xC0, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x64, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x10, 0x03, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x18, 0x01, 0x00, 0x80, 0x08, 0x0C,
  0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x02,
  0x10, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00,
  0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x19,
  0x00, 0x07, 0x00, 0x06, 0x40, 0x01, 0x40, 0x01, 0x10, 0x00, 0xD0, 0x00,
  0xC4, 0x00, 0x24, 0x00, 0x21, 0x00, 0x19, 0x00, 0x18, 0x40, 0x04, 0x40,
  0x04, 0x10, 0x03, 0x18, 0x03, 0x04, 0x00, 0x86, 0x00, 0x81, 0x00, 0x61,
  0x80, 0x60, 0x40, 0x10, 0x60, 0x18, 0x10, 0x0C, 0x18, 0x04, 0x04, 0x02,
  0x06, 0x03, 0x01, 0x01, 0x81, 0x80, 0x80, 0x60, 0x60, 0x20, 0x60, 0x18,
  0x30, 0x08, 0x10, 0x06, 0x0C, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x82, 0x00,
  0x61, 0x80, 0x21, 0x80, 0x18, 0x40, 0x08, 0x60, 0x06, 0x30, 0x02, 0x10,
  0x01, 0x88, 0x00, 0x8C, 0x00, 0x66, 0x00, 0x22, 0x00, 0x19, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x02, 0x00,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x04, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x08, 0x00, 0x20, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x38, 0x01, 0x80, 0x0F, 0x06,
  0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 43, 12, 2, -43 },
  { 61, 13, 16, 17, 6, -43 },
  { 87, 31, 43, 31, 1, -43 },
  { 254, 25, 49, 28, 2, -46 },
  { 408, 33, 44, 40, 4, -43 },
  { 590, 30, 45, 33, 1, -44 },
  { 759, 5, 16, 10, 6, -43 },
  { 769, 16, 52, 15, 2, -43 },
  { 873, 17, 52, 15, -4, -43 },
  { 984, 21, 21, 27, 7, -45 },
  { 1040, 25, 28, 30, 3, -35 },
  { 1128, 8, 14, 10, -3, -6 },
  { 1142, 14, 1, 18, 2, -17 },
  { 1144, 3, 4, 11, 2, -4 },
  { 1146, 26, 43, 18, -3, -43 },
  { 1286, 25, 45, 28, 3, -44 },
  { 1427, 13, 43, 28, 9, -43 },
  { 1497, 27, 43, 28, 0, -43 },
  { 1643, 28, 44, 28, 0, -43 },
  { 1797, 27, 43, 28, 0, -43 },
  { 1943, 27, 44, 28, 1, -43 },
  { 2092, 26, 45, 28, 3, -44 },
  { 2239, 25, 43, 28, 5, -43 },
  { 2374, 27, 44, 28, 1, -43 },
  { 2523, 25, 44, 28, 2, -43 },
  { 2661, 9, 32, 11, 1, -32 },
  { 2697, 13, 40, 11, -3, -32 },
  { 2762, 24, 26, 30, 4, -35 },
  { 2840, 25, 14, 30, 3, -28 },
  { 2884, 24, 26, 30, 4, -35 },
  { 2962, 19, 43, 21, 3, -43 },
  { 3065, 39, 48, 43, 3, -43 },
  { 3299, 28, 43, 28, -3, -43 },
  { 3450, 28, 43, 31, 2, -43 },
  { 3601, 29, 44, 30, 4, -43 },
  { 3761, 31, 43, 35, 2, -43 },
  { 3928, 28, 43, 28, 2, -43 },
  { 4079, 28, 43, 25, 2, -43 },
  { 4230, 32, 44, 36, 4, -43 },
  { 4406, 34, 43, 36, 2, -43 },
  { 4589, 18, 43, 14, -1, -43 },
  { 4686, 23, 53, 12, -10, -43 },
  { 4839, 31, 43, 28, 2, -43 },
  { 5006, 18, 43, 25, 2, -43 },
  { 5103, 42, 43, 44, 2, -43 },
  { 5329, 34, 43, 36, 2, -43 },
  { 5512, 31, 45, 37, 4, -44 },
  { 5687, 27, 43, 29, 2, -43 },
  { 5833, 31, 54, 37, 4, -44 },
  { 6043, 27, 43, 29, 2, -43 },
  { 6189, 27, 44, 26, 0, -43 },
  { 6338, 25, 43, 25, 5, -43 },
  { 6473, 32, 44, 36, 4, -43 },
  { 6649, 26, 43, 28, 6, -43 },
  { 6789, 42, 43, 45, 7, -43 },
  { 7015, 34, 43, 25, -4, -43 },
  { 7198, 25, 43, 25, 5, -43 },
  { 7333, 31, 43, 27, -1, -43 },
  { 7500, 22, 52, 18, -1, -43 },
  { 7643, 9, 43, 19, 6, -43 },
  { 7692, 22, 52, 18, -4, -43 },
  { 7835, 26, 24, 30, 2, -43 },
  { 7913, 20, 2, 20, -5, 6 },
  { 7918, 6, 10, 13, 9, -46 },
  { 7926, 25, 33, 29, 3, -32 },
  { 8030, 26, 47, 30, 1, -46 },
  { 8183, 21, 33, 23, 3, -32 },
  { 8270, 28, 47, 30, 3, -46 },
  { 8435, 21, 33, 26, 3, -32 },
  { 8522, 30, 60, 14, -8, -46 },
  { 8747, 27, 46, 30, 1, -32 },
  { 8903, 25, 46, 29, 1, -46 },
  { 9047, 11, 43, 11, 1, -43 },
  { 9107, 21, 57, 11, -8, -43 },
  { 9257, 24, 46, 23, 1, -46 },
  { 9395, 12, 46, 11, 1, -46 },
  { 9464, 40, 32, 44, 1, -32 },
  { 9624, 25, 32, 29, 1, -32 },
  { 9724, 24, 33, 29, 3, -32 },
  { 9823, 29, 46, 30, -2, -32 },
  { 9990, 25, 46, 30, 3, -32 },
  { 10134, 20, 32, 19, 1, -32 },
  { 10214, 21, 33, 22, 0, -32 },
  { 10301, 15, 40, 16, 2, -39 },
  { 10376, 24, 33, 29, 3, -32 },
  { 10475, 21, 32, 22, 3, -32 },
  { 10559, 34, 32, 35, 3, -32 },
  { 10695, 27, 32, 24, -2, -32 },
  { 10803, 32, 47, 22, -7, -32 },
  { 10991, 23, 32, 22, -1, -32 },
  { 11083, 21, 52, 19, 2, -43 },
  { 11220, 2, 61, 28, 14, -46 },
  { 11236, 21, 53, 19, -3, -43 },
  { 11376, 24, 5, 30, 4, -24 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC60PT7B_H_
