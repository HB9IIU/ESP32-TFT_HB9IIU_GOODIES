#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x30, 0x13, 0x03, 0x30, 0x33, 0x03, 0x20, 0x26, 0x02, 0x60,
  0x66, 0x06, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x0C, 0x80, 0x88, 0x08, 0x80,
  0x88, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xC1, 0x07,
  0x00, 0xE0, 0xC0, 0x40, 0x60, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x02,
  0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x5C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x30,
  0x18, 0x70, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x30, 0x0C, 0x18, 0x00, 0x0C, 0x03, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00,
  0x40, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x30, 0x06,
  0x00, 0x20, 0x0C, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x10, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0xC0, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x06, 0x06, 0x00, 0x08, 0x00,
  0xC1, 0x80, 0x03, 0x00, 0x18, 0x20, 0x7C, 0x60, 0x02, 0x0C, 0x3F, 0xCC,
  0x00, 0xC3, 0x0C, 0x0D, 0x80, 0x10, 0x43, 0x01, 0x90, 0x06, 0x18, 0x40,
  0x12, 0x00, 0x86, 0x18, 0x03, 0x60, 0x30, 0x82, 0x00, 0x6E, 0x0C, 0x30,
  0xC0, 0x0C, 0xFF, 0x0C, 0x18, 0x01, 0x87, 0x81, 0x86, 0x00, 0x30, 0x00,
  0x60, 0xC0, 0x04, 0x00, 0x18, 0x18, 0x00, 0x80, 0x03, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x60, 0x02, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x00, 0x18, 0x03, 0x00, 0x20, 0x03, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18,
  0x00, 0x80, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x80, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x06, 0x0C, 0x03, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x01,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0x00, 0xC6,
  0x00, 0x20, 0x06, 0x30, 0x00, 0xC0, 0x19, 0x80, 0x01, 0x00, 0x46, 0x00,
  0x06, 0x03, 0x30, 0x00, 0x0C, 0x18, 0xC0, 0x00, 0x30, 0x63, 0x00, 0x00,
  0x63, 0x08, 0x00, 0x01, 0x98, 0x20, 0x00, 0x03, 0x60, 0x80, 0x00, 0x0F,
  0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0xC0,
  0xC0, 0x00, 0x31, 0x01, 0x80, 0x01, 0x86, 0x07, 0x00, 0x1C, 0x08, 0x0F,
  0x01, 0xC0, 0x30, 0x0F, 0xFE, 0x00, 0x60, 0x07, 0x80, 0x00, 0x00, 0x33,
  0x33, 0x26, 0x66, 0x44, 0x4C, 0x88, 0x88, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x40, 0x08,
  0x03, 0x00, 0xC0, 0x0E, 0x04, 0x00, 0x1C, 0x20, 0x00, 0x31, 0x00, 0x40,
  0x68, 0x7E, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0x40,
  0x00, 0xC2, 0x00, 0x0C, 0x08, 0x01, 0x80, 0x40, 0x18, 0x03, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x5F, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0E,
  0x03, 0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04,
  0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x18, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x36, 0x07, 0x30, 0x71,
  0x06, 0x08, 0xE0, 0xCC, 0x06, 0xC0, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1C, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x1C, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0x00, 0x18, 0x7C, 0xF8, 0x03, 0x38, 0x03, 0x80, 0x4C, 0x00, 0x38, 0x0B,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x70,
  0x00, 0x18, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x00, 0x60, 0x1C, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x01,
  0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x07, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30,
  0x00, 0x36, 0x06, 0x00, 0x19, 0x00, 0xE0, 0x1C, 0x40, 0x1F, 0xFC, 0x30,
  0x01, 0xF8, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x02, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0E,
  0x01, 0xC0, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x00, 0x03, 0x0C, 0x00, 0x1F, 0xFC, 0x03, 0x08, 0x00, 0x78,
  0x18, 0x03, 0x18, 0x00, 0xE0, 0x18, 0x03, 0x10, 0x01, 0x80, 0x18, 0x03,
  0x30, 0x03, 0x00, 0x18, 0x03, 0x30, 0x03, 0x00, 0x10, 0x03, 0x20, 0x06,
  0x00, 0x30, 0x03, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x60, 0x0C, 0x00, 0x30,
  0x02, 0x60, 0x18, 0x00, 0x20, 0x02, 0x40, 0x18, 0x00, 0x60, 0x06, 0xC0,
  0x10, 0x00, 0x60, 0x06, 0xC0, 0x30, 0x00, 0x40, 0x06, 0xC0, 0x30, 0x00,
  0xC0, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x08,
  0xC0, 0x30, 0x01, 0xC0, 0x18, 0x80, 0x30, 0x01, 0x80, 0x18, 0x80, 0x30,
  0x03, 0x80, 0x30, 0x80, 0x30, 0x06, 0x80, 0x60, 0xC0, 0x30, 0x06, 0xC0,
  0x60, 0xC0, 0x18, 0x0C, 0xC1, 0xC0, 0xC0, 0x0E, 0x78, 0x77, 0x80, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x40,
  0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x38,
  0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x18, 0x02, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x60, 0x1F, 0x80, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x20, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x40, 0x00, 0x70, 0x00, 0x40, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x06, 0x6C, 0x00,
  0x00, 0x04, 0xC4, 0x00, 0x00, 0x05, 0x86, 0x00, 0x00, 0x0F, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x40, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x40, 0x00, 0x00, 0x07, 0x80, 0x28,
  0x00, 0x00, 0x01, 0xA0, 0x0D, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x04, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x98, 0x00, 0x00, 0x08, 0x80, 0x33, 0x00, 0x00, 0x03, 0x30,
  0x06, 0x20, 0x00, 0x00, 0x46, 0x00, 0xC4, 0x00, 0x00, 0x18, 0xC0, 0x10,
  0x80, 0x00, 0x06, 0x10, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x18, 0x60, 0x00, 0x06, 0x18, 0x02, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x40, 0x80, 0x00, 0x20, 0x40, 0x18, 0x10, 0x00, 0x0C, 0x18,
  0x03, 0x02, 0x00, 0x01, 0x03, 0x00, 0x60, 0x40, 0x00, 0x60, 0x60, 0x08,
  0x0C, 0x00, 0x18, 0x0C, 0x01, 0x01, 0x80, 0x03, 0x01, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x06,
  0x01, 0x80, 0x20, 0x08, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x30, 0x03,
  0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x60, 0x06, 0x00, 0xC0, 0x04, 0x18,
  0x00, 0xC0, 0x10, 0x00, 0x82, 0x00, 0x18, 0x02, 0x00, 0x18, 0xC0, 0x02,
  0x00, 0xC0, 0x03, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x66, 0x00, 0x18, 0x03,
  0x00, 0x0D, 0x80, 0x03, 0x00, 0x40, 0x00, 0xB0, 0x00, 0x40, 0x08, 0x00,
  0x1C, 0x00, 0x08, 0x03, 0x00, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x28, 0x00, 0x00, 0x20, 0x0D, 0x80, 0x00,
  0x0C, 0x01, 0xB0, 0x00, 0x01, 0x80, 0x32, 0x00, 0x00, 0x30, 0x04, 0x60,
  0x00, 0x04, 0x00, 0x8C, 0x00, 0x00, 0x80, 0x30, 0x80, 0x00, 0x30, 0x06,
  0x18, 0x00, 0x06, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x10, 0x20, 0x00, 0x10,
  0x06, 0x06, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x18, 0x08, 0x00,
  0x18, 0x03, 0x01, 0x80, 0x03, 0x00, 0x40, 0x30, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x18, 0x01, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x20, 0x00, 0xC0,
  0x20, 0x0C, 0x00, 0x08, 0x0C, 0x01, 0x80, 0x01, 0x81, 0x80, 0x30, 0x00,
  0x30, 0x30, 0x06, 0x00, 0x02, 0x06, 0x00, 0x80, 0x00, 0x60, 0x80, 0x30,
  0x00, 0x0C, 0x30, 0x06, 0x00, 0x00, 0x86, 0x00, 0xC0, 0x00, 0x18, 0xC0,
  0x10, 0x00, 0x03, 0x18, 0x02, 0x00, 0x00, 0x22, 0x00, 0xC0, 0x00, 0x06,
  0xC0, 0x18, 0x00, 0x00, 0xD8, 0x03, 0x00, 0x00, 0x0B, 0x00, 0x40, 0x00,
  0x01, 0xC0, 0x08, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x06, 0x01, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x40, 0x00,
  0x70, 0x04, 0x00, 0x1C, 0x00, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x60, 0x01,
  0xC0, 0x04, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x07, 0x00, 0x40, 0x01, 0xE0, 0x04, 0x01, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x02,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x03,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00,
  0x68, 0x00, 0x01, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x30,
  0x00, 0x0D, 0x80, 0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x66, 0x00, 0x02, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC1, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06,
  0x00, 0x10, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00,
  0xC0, 0x20, 0x02, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x03, 0x01,
  0x80, 0x08, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00,
  0x20, 0x60, 0x00, 0x83, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0x83,
  0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x98, 0x00,
  0x04, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x10, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0x40, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0x81,
  0x83, 0x03, 0x02, 0x06, 0x06, 0x00, 0x1F, 0xE0, 0x80, 0x3C, 0x38, 0x40,
  0x30, 0x06, 0x20, 0x70, 0x01, 0x30, 0x30, 0x00, 0xD8, 0x30, 0x00, 0x28,
  0x30, 0x00, 0x14, 0x10, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x08, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x08, 0x00, 0x01, 0x84, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x70, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x38, 0x30, 0x00, 0x3C, 0x18, 0x00, 0x16, 0x04, 0x00, 0x1A, 0x03,
  0x00, 0x19, 0x00, 0xC0, 0x38, 0x80, 0x70, 0x38, 0xC0, 0x1F, 0xF0, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x0C, 0x38, 0x78, 0x01, 0x1C,
  0x03, 0x80, 0x27, 0x00, 0x30, 0x0D, 0xC0, 0x03, 0x01, 0xB0, 0x00, 0x20,
  0x3C, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x05, 0x00,
  0x01, 0x81, 0xB0, 0x00, 0x60, 0x36, 0x00, 0x18, 0x04, 0x60, 0x06, 0x00,
  0x87, 0x03, 0x80, 0x30, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0xF0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0x81, 0x00, 0x0F, 0x0F, 0x18, 0x00, 0xC0, 0x18, 0xC0, 0x1C, 0x00,
  0x66, 0x00, 0xC0, 0x01, 0xA0, 0x0C, 0x00, 0x0D, 0x00, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x38, 0x08, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x1C, 0x02, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xF8,
  0x06, 0x00, 0x06, 0xC0, 0x10, 0x00, 0x64, 0x00, 0xC0, 0x06, 0x20, 0x03,
  0x00, 0x63, 0x00, 0x1C, 0x0E, 0x18, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xF1, 0xC0, 0x0E, 0x01, 0x80, 0x60,
  0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x61, 0x80, 0x07, 0x06, 0x00, 0x78, 0x10, 0x3F, 0x80, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x08, 0x03, 0x80, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x10, 0x01, 0xE1, 0xC1, 0x00, 0x30, 0x06, 0x30,
  0x0E, 0x00, 0x33, 0x00, 0xC0, 0x01, 0xA0, 0x18, 0x00, 0x0A, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x70, 0x20, 0x00, 0x07, 0x02, 0x00, 0x00,
  0xE0, 0x20, 0x00, 0x0E, 0x02, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x3E, 0x03,
  0x00, 0x03, 0x40, 0x10, 0x00, 0x64, 0x01, 0x80, 0x0C, 0xC0, 0x0C, 0x01,
  0x8C, 0x00, 0xE0, 0x70, 0xC0, 0x03, 0xFC, 0x08, 0x00, 0x07, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x1F, 0xE0, 0x06, 0x1E, 0x3C, 0x01, 0x1C, 0x01, 0x80, 0x4C, 0x00, 0x60,
  0x36, 0x00, 0x0C, 0x0D, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x20, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x20,
  0x00, 0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x08, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x00, 0x06, 0x00, 0x80, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x08, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0xC0,
  0x00, 0x23, 0x60, 0x00, 0x13, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x0F, 0x02,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x80, 0x10,
  0x00, 0x40, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x04, 0x02,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0x87,
  0x8F, 0x03, 0x87, 0x80, 0x46, 0x01, 0x83, 0x00, 0xC0, 0x26, 0x00, 0x63,
  0x00, 0x30, 0x36, 0x00, 0x33, 0x00, 0x18, 0x1E, 0x00, 0x0B, 0x00, 0x04,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x07, 0x00, 0x03, 0x80, 0x01, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x83, 0x80, 0x01, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x00, 0x00, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x06, 0x00, 0x03, 0x00, 0x00, 0x83, 0x00, 0x01,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x01, 0x81, 0xFE, 0x00, 0x41,
  0xE3, 0xC0, 0x11, 0xC0, 0x38, 0x04, 0xC0, 0x06, 0x03, 0x60, 0x00, 0xC0,
  0xD0, 0x00, 0x30, 0x2C, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x0C,
  0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x08,
  0x18, 0x00, 0x02, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x18, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x08, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x83,
  0xC7, 0x80, 0x02, 0x38, 0x07, 0x00, 0x09, 0xC0, 0x0C, 0x00, 0x66, 0x00,
  0x18, 0x01, 0xB0, 0x00, 0x20, 0x07, 0x80, 0x00, 0xC0, 0x14, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x08,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x01,
  0x40, 0x00, 0x60, 0x0D, 0x00, 0x03, 0x00, 0x36, 0x00, 0x1C, 0x00, 0xCC,
  0x00, 0xE0, 0x02, 0x1C, 0x0E, 0x00, 0x08, 0x3F, 0xF0, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x40, 0x1E, 0x1C, 0x10, 0x0C, 0x01,
  0x8C, 0x0E, 0x00, 0x33, 0x03, 0x00, 0x06, 0x81, 0x80, 0x01, 0xA0, 0xC0,
  0x00, 0x28, 0x20, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x84, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x07, 0x08, 0x00, 0x01, 0xC2, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x38,
  0x20, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x03, 0x60, 0x40, 0x01,
  0x90, 0x18, 0x00, 0xC4, 0x03, 0x00, 0x63, 0x00, 0xE0, 0x70, 0xC0, 0x0F,
  0xF0, 0x20, 0x00, 0x60, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x83, 0xF8, 0x08, 0x38, 0x40, 0x47, 0x00, 0x02, 0x60, 0x00, 0x36,
  0x00, 0x01, 0xA0, 0x00, 0x0B, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xC1, 0xF0, 0x18, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x08, 0x00, 0x30, 0x3C, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x20, 0x3F, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10,
  0x40, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x40, 0x00, 0x38, 0x20, 0x00, 0x3C, 0x10, 0x00, 0x34, 0x0C,
  0x00, 0x12, 0x06, 0x00, 0x19, 0x01, 0x80, 0x39, 0x80, 0xE0, 0x70, 0xC0,
  0x3F, 0xF0, 0x40, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x00, 0xC4,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x20, 0x03, 0x00, 0x80, 0x08, 0x02, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x06, 0x00, 0x04, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x06, 0xC0, 0x00,
  0x1A, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x22, 0x00, 0x19, 0x00, 0x18,
  0x80, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00,
  0xC2, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x30, 0x40, 0x18, 0x30, 0x0C, 0x18,
  0x04, 0x0C, 0x02, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x04, 0x03, 0x06,
  0x01, 0x83, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x0C,
  0x20, 0x02, 0x10, 0x03, 0x18, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x22, 0x00,
  0x33, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x60, 0x01, 0x60, 0x00, 0x90,
  0x00, 0x50, 0x00, 0x2C, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x08, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x5C, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x78, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 44, 13, 2, -44 },
  { 62, 12, 16, 18, 7, -44 },
  { 86, 32, 44, 32, 1, -44 },
  { 262, 26, 51, 29, 2, -47 },
  { 428, 35, 46, 42, 4, -45 },
  { 630, 30, 46, 34, 2, -45 },
  { 803, 4, 16, 10, 7, -44 },
  { 811, 17, 54, 15, 2, -44 },
  { 926, 17, 54, 15, -4, -44 },
  { 1041, 21, 23, 28, 8, -47 },
  { 1102, 25, 28, 31, 4, -36 },
  { 1190, 8, 15, 11, -3, -7 },
  { 1205, 14, 2, 18, 2, -18 },
  { 1209, 3, 4, 12, 2, -4 },
  { 1211, 27, 44, 19, -3, -44 },
  { 1360, 25, 46, 29, 3, -45 },
  { 1504, 13, 44, 29, 9, -44 },
  { 1576, 28, 45, 29, 0, -45 },
  { 1734, 29, 46, 29, 0, -45 },
  { 1901, 28, 45, 29, 0, -45 },
  { 2059, 28, 45, 29, 1, -44 },
  { 2217, 27, 46, 29, 3, -45 },
  { 2373, 26, 44, 29, 5, -44 },
  { 2516, 27, 46, 29, 2, -45 },
  { 2672, 26, 46, 29, 2, -45 },
  { 2822, 10, 33, 12, 1, -33 },
  { 2864, 14, 41, 12, -3, -33 },
  { 2936, 25, 27, 31, 4, -36 },
  { 3021, 25, 14, 31, 4, -29 },
  { 3065, 25, 27, 31, 4, -36 },
  { 3150, 20, 45, 21, 3, -45 },
  { 3263, 40, 50, 44, 3, -44 },
  { 3513, 29, 44, 29, -4, -44 },
  { 3673, 29, 44, 32, 2, -44 },
  { 3833, 30, 46, 31, 4, -45 },
  { 4006, 32, 44, 36, 2, -44 },
  { 4182, 29, 44, 29, 2, -44 },
  { 4342, 29, 44, 26, 2, -44 },
  { 4502, 33, 46, 37, 4, -45 },
  { 4692, 35, 44, 37, 2, -44 },
  { 4885, 19, 44, 15, -1, -44 },
  { 4990, 23, 55, 13, -10, -44 },
  { 5149, 32, 44, 29, 2, -44 },
  { 5325, 19, 44, 26, 2, -44 },
  { 5430, 43, 44, 45, 2, -44 },
  { 5667, 35, 44, 37, 2, -44 },
  { 5860, 32, 46, 38, 4, -45 },
  { 6044, 28, 44, 30, 2, -44 },
  { 6198, 32, 56, 38, 4, -45 },
  { 6422, 28, 44, 30, 2, -44 },
  { 6576, 28, 46, 27, 0, -45 },
  { 6737, 25, 44, 26, 6, -44 },
  { 6875, 33, 45, 37, 4, -44 },
  { 7061, 28, 44, 29, 6, -44 },
  { 7215, 43, 44, 46, 7, -44 },
  { 7452, 35, 44, 26, -4, -44 },
  { 7645, 25, 44, 26, 6, -44 },
  { 7783, 32, 44, 28, -1, -44 },
  { 7959, 23, 54, 18, -1, -44 },
  { 8115, 9, 44, 19, 6, -44 },
  { 8165, 23, 54, 18, -4, -44 },
  { 8321, 26, 25, 31, 3, -44 },
  { 8403, 21, 2, 21, -5, 6 },
  { 8409, 7, 9, 14, 9, -47 },
  { 8417, 25, 34, 30, 3, -33 },
  { 8524, 27, 48, 31, 1, -47 },
  { 8686, 22, 34, 24, 3, -33 },
  { 8780, 29, 48, 31, 3, -47 },
  { 8954, 22, 34, 27, 3, -33 },
  { 9048, 31, 62, 15, -8, -47 },
  { 9289, 28, 48, 31, 1, -33 },
  { 9457, 26, 47, 30, 1, -47 },
  { 9610, 12, 45, 12, 1, -45 },
  { 9678, 22, 60, 12, -9, -45 },
  { 9843, 25, 47, 24, 1, -47 },
  { 9990, 12, 47, 11, 1, -47 },
  { 10061, 41, 33, 45, 1, -33 },
  { 10231, 26, 33, 30, 1, -33 },
  { 10339, 25, 34, 30, 3, -33 },
  { 10446, 30, 47, 31, -2, -33 },
  { 10623, 26, 47, 31, 3, -33 },
  { 10776, 21, 33, 20, 1, -33 },
  { 10863, 22, 34, 23, 0, -33 },
  { 10957, 15, 42, 16, 2, -41 },
  { 11036, 25, 34, 30, 3, -33 },
  { 11143, 22, 33, 22, 3, -33 },
  { 11234, 34, 33, 36, 4, -33 },
  { 11375, 28, 33, 24, -2, -33 },
  { 11491, 33, 48, 23, -7, -33 },
  { 11689, 24, 33, 22, -1, -33 },
  { 11788, 21, 54, 20, 2, -44 },
  { 11930, 1, 62, 29, 15, -47 },
  { 11938, 21, 54, 20, -3, -44 },
  { 12080, 25, 6, 31, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC62PT7B_H_
