#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x22, 0x45, 0x0A, 0x24, 0x48,
  0x91, 0x44, 0x00, 0x82, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x3F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40,
  0x10, 0x40, 0x20, 0x80, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x41, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x1C, 0x01, 0xA7, 0x08, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x11, 0x00, 0x44, 0x00, 0x90, 0x01, 0x40, 0x03, 0x00, 0x0A,
  0x00, 0x26, 0x00, 0x88, 0x02, 0x10, 0x08, 0x40, 0x42, 0x01, 0x08, 0x04,
  0x43, 0x96, 0x00, 0xE0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0x00,
  0x84, 0x40, 0x42, 0x08, 0x10, 0x82, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x04, 0x40, 0x81, 0x10, 0x20, 0x48, 0xE8, 0x24, 0xC6, 0x09,
  0x21, 0x44, 0x90, 0x5E, 0x44, 0x10, 0x12, 0x04, 0x08, 0x81, 0x04, 0x20,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x10, 0x21, 0x08, 0x08, 0x46,
  0x01, 0xE0, 0x01, 0xF0, 0x02, 0x10, 0x04, 0x08, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x80, 0x03, 0x00,
  0x0D, 0x00, 0x11, 0x01, 0x20, 0x82, 0x40, 0x82, 0x80, 0x44, 0x80, 0x44,
  0x80, 0x28, 0x80, 0x10, 0x80, 0x10, 0x80, 0x28, 0x40, 0x88, 0x3F, 0x04,
  0x25, 0x24, 0x94, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x00, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x00, 0x02, 0x00, 0x42, 0x10, 0x22,
  0x03, 0x40, 0x1F, 0xC3, 0x00, 0x90, 0x22, 0x18, 0x20, 0x04, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x12, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x60, 0x82,
  0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x20, 0x80, 0xF8, 0x00, 0x06, 0x18,
  0xD2, 0x28, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x00, 0x01, 0xF0, 0x18, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x08, 0x08, 0x20, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x03, 0x80, 0x3E, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x10, 0x08, 0x1F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x01, 0x40, 0x09, 0x00, 0x24, 0x01, 0x20, 0x08, 0x80, 0x42, 0x02, 0x08,
  0x08, 0x40, 0x41, 0x02, 0x04, 0x10, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08,
  0xFF, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x2E, 0x00, 0x61, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x10, 0x08, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x7C, 0x24, 0x11, 0x40, 0x4C, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x20, 0xC0, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x82, 0x02, 0x08, 0x10, 0x11, 0x80, 0x28, 0x01, 0xE0, 0x18, 0x40,
  0x80, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x21, 0x01, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84,
  0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x06, 0x10, 0x68, 0x3E, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x0F, 0xC0, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x80, 0x06, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x00, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x3F, 0x10, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x06, 0x00,
  0x40, 0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x40, 0x00,
  0x22, 0x07, 0xE1, 0x20, 0x41, 0x09, 0x04, 0x10, 0x50, 0x40, 0x82, 0x82,
  0x04, 0x14, 0x20, 0x20, 0xA1, 0x02, 0x0A, 0x08, 0x10, 0x50, 0x40, 0x82,
  0x82, 0x0C, 0x24, 0x10, 0xA3, 0x20, 0xC9, 0xB0, 0x81, 0x82, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02,
  0x80, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10,
  0x10, 0x20, 0x20, 0x40, 0xFF, 0x81, 0x01, 0x04, 0x01, 0x08, 0x02, 0x20,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0x80, 0x07,
  0xF0, 0x08, 0x18, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x04, 0x20, 0x10, 0x7D, 0xC1, 0x07, 0x02, 0x01, 0x04,
  0x01, 0x08, 0x02, 0x10, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0xC4, 0x01, 0x10, 0x0C, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0x01, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x02, 0x06, 0x02, 0x01, 0x81,
  0x00, 0x40, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x02, 0x08, 0x03, 0x04,
  0x02, 0x04, 0x06, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x7F, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x03, 0xFF, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0x80, 0x41, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x07, 0xE4, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x08, 0x00, 0x86, 0x00, 0x41, 0x80, 0x40, 0x3F, 0xC0, 0x04,
  0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41, 0xFF, 0xF0,
  0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x40,
  0x02, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x80, 0x07, 0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x09, 0x80, 0x20, 0x00, 0x04, 0x01, 0x82, 0x01, 0x02, 0x01, 0x01, 0x01,
  0x00, 0x81, 0x00, 0x41, 0x00, 0x41, 0x00, 0x21, 0x00, 0x11, 0x00, 0x09,
  0x00, 0x05, 0x80, 0x05, 0x20, 0x03, 0x10, 0x01, 0x08, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x00, 0x40, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x04, 0x00,
  0x04, 0x10, 0x00, 0x30, 0xA0, 0x00, 0xC2, 0x80, 0x05, 0x0A, 0x00, 0x18,
  0x28, 0x00, 0xA1, 0x20, 0x04, 0x84, 0x80, 0x12, 0x12, 0x00, 0x88, 0x48,
  0x02, 0x41, 0x10, 0x11, 0x08, 0x40, 0x44, 0x21, 0x02, 0x10, 0x84, 0x08,
  0x42, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x08, 0x21, 0x04, 0x40, 0x84,
  0x09, 0x04, 0x10, 0x28, 0x10, 0x80, 0xA0, 0x42, 0x03, 0x01, 0x08, 0x08,
  0x04, 0x00, 0x04, 0x00, 0x41, 0x00, 0x10, 0xA0, 0x04, 0x28, 0x02, 0x0A,
  0x00, 0x82, 0x40, 0x21, 0x10, 0x08, 0x44, 0x02, 0x10, 0x81, 0x04, 0x20,
  0x41, 0x08, 0x10, 0x81, 0x04, 0x20, 0x41, 0x08, 0x10, 0x82, 0x02, 0x20,
  0x80, 0x88, 0x40, 0x22, 0x10, 0x04, 0x84, 0x01, 0x41, 0x00, 0x50, 0x80,
  0x0C, 0x20, 0x03, 0x08, 0x00, 0x80, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00,
  0xC1, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x08, 0x01,
  0x04, 0x01, 0x81, 0x01, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x08, 0x30, 0x20,
  0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x21, 0x00, 0x83, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00, 0xC1, 0x00, 0x21,
  0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x08, 0x01, 0x04, 0x01, 0x81,
  0x01, 0x80, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x07, 0xE0, 0x08, 0x30, 0x20, 0x10, 0x40, 0x20, 0x80,
  0x21, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x61,
  0x01, 0x83, 0xFC, 0x04, 0x10, 0x08, 0x20, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x81, 0x01, 0x02, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x04, 0x00, 0x01,
  0xFC, 0x0C, 0x04, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x10, 0x08, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x08, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x03, 0x04, 0x01, 0x03, 0x01, 0x00, 0xFF, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x41, 0x01, 0x04, 0x08, 0x10, 0x20, 0x41, 0x01, 0x04, 0x04, 0x20,
  0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x80, 0x20, 0x06, 0x00, 0x80, 0x28, 0x06, 0x00, 0xA0,
  0x18, 0x02, 0x80, 0xA0, 0x12, 0x02, 0x80, 0x48, 0x12, 0x02, 0x20, 0x44,
  0x08, 0x81, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x02, 0x00, 0x40, 0x80, 0x20,
  0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x02,
  0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x10, 0x02, 0x04, 0x01,
  0x01, 0x00, 0x40, 0x40, 0x20, 0x08, 0x10, 0x02, 0x08, 0x00, 0x80, 0x80,
  0x0C, 0x00, 0xA0, 0x04, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x04, 0x20,
  0x21, 0x01, 0x10, 0x09, 0x00, 0x48, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x7E, 0x00, 0x84, 0x20, 0x84, 0x21, 0x08, 0x41, 0x08,
  0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x84, 0x20, 0x03, 0xF0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x0F, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0x88, 0x02, 0x20, 0x10,
  0x80, 0x41, 0x02, 0x04, 0x10, 0x10, 0x40, 0x22, 0x00, 0x90, 0x02, 0xC0,
  0x04, 0xFF, 0xE0, 0x89, 0x12, 0x03, 0xE4, 0x30, 0x91, 0x01, 0x84, 0x06,
  0x20, 0x08, 0x80, 0x24, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x80, 0x22, 0x01, 0x84, 0x0A, 0x10, 0x48, 0x3E, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x7C,
  0x14, 0x10, 0xC0, 0x4A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x2C, 0x02, 0x60, 0x12, 0x81,
  0x13, 0xF0, 0x03, 0xF0, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x03, 0xE4, 0x0C, 0x14, 0x10, 0x14,
  0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0x40, 0xE0,
  0x41, 0xA0, 0x3E, 0x20, 0x07, 0xC3, 0x0C, 0xC0, 0x90, 0x14, 0x02, 0x80,
  0xA0, 0x34, 0x18, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x04, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0xF2, 0x0C, 0x14,
  0x20, 0x28, 0x40, 0x21, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x08, 0x1C,
  0x10, 0x68, 0x1F, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x60, 0x80, 0x3E, 0x00, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x7E, 0x14, 0x10, 0xC0, 0x44,
  0x02, 0x60, 0x12, 0x00, 0x90, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x0C, 0x20,
  0x00, 0x00, 0x01, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x60, 0x30, 0x00, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x03,
  0x10, 0x20, 0x82, 0x08, 0x20, 0x42, 0x02, 0x20, 0x12, 0x00, 0xB0, 0x0A,
  0x80, 0x52, 0x03, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x42, 0x02,
  0x10, 0x18, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x13, 0xE1, 0xF0, 0xA0,
  0x90, 0x86, 0x05, 0x02, 0x20, 0x30, 0x13, 0x01, 0x00, 0x90, 0x08, 0x04,
  0x80, 0x40, 0x44, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x90, 0x08,
  0x04, 0x80, 0x40, 0x44, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x90,
  0x08, 0x04, 0x80, 0x40, 0x40, 0x13, 0xF0, 0xA0, 0x86, 0x02, 0x20, 0x13,
  0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x40, 0x03, 0xE0, 0x60,
  0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x20, 0x11, 0x01, 0x8C, 0x18, 0x3F,
  0x00, 0x04, 0x7C, 0x0B, 0x08, 0x18, 0x08, 0x50, 0x10, 0xC0, 0x21, 0x00,
  0x42, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21,
  0x00, 0x46, 0x01, 0x0C, 0x02, 0x14, 0x08, 0x27, 0xE0, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x03, 0xE4,
  0x30, 0x51, 0x01, 0x44, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02,
  0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x32, 0x01, 0x84, 0x0E,
  0x10, 0x68, 0x3E, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x13, 0xC5, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x0F, 0xE2, 0x04, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x24, 0x0C,
  0xFF, 0x00, 0x08, 0x08, 0x10, 0x10, 0x7F, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x78, 0x10,
  0x04, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x80, 0x22, 0x01, 0x88,
  0x0A, 0x10, 0x50, 0x3E, 0x40, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x09,
  0x02, 0x20, 0x44, 0x10, 0x82, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0,
  0x14, 0x03, 0x00, 0x40, 0x00, 0x80, 0x80, 0x60, 0x20, 0x28, 0x18, 0x0A,
  0x05, 0x04, 0x82, 0x41, 0x20, 0x90, 0x88, 0x44, 0x22, 0x11, 0x08, 0x88,
  0x44, 0x22, 0x11, 0x09, 0x04, 0x82, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x08, 0x04, 0x20, 0x20,
  0x81, 0x01, 0x04, 0x04, 0x20, 0x09, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x41, 0x02, 0x04, 0x10, 0x10,
  0x80, 0x20, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xC0,
  0x00, 0xE0, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x38, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x18, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x38, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x60, 0x70, 0x00, 0x10, 0x06,
  0x30, 0x60, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 8, 9, 3, -23 },
  { 26, 16, 23, 17, 1, -23 },
  { 72, 14, 26, 15, 1, -24 },
  { 118, 18, 23, 22, 2, -23 },
  { 170, 16, 23, 18, 1, -23 },
  { 216, 3, 8, 5, 3, -23 },
  { 219, 9, 28, 8, 1, -23 },
  { 251, 9, 28, 8, -2, -23 },
  { 283, 11, 11, 15, 4, -24 },
  { 299, 13, 15, 16, 2, -19 },
  { 324, 4, 7, 6, -1, -3 },
  { 328, 7, 1, 9, 1, -9 },
  { 329, 1, 2, 6, 1, -2 },
  { 330, 13, 23, 10, -1, -23 },
  { 368, 13, 23, 15, 2, -23 },
  { 406, 7, 23, 15, 5, -23 },
  { 427, 14, 23, 15, 0, -23 },
  { 468, 15, 23, 15, 0, -23 },
  { 512, 14, 23, 15, 0, -23 },
  { 553, 15, 23, 15, 0, -23 },
  { 597, 13, 23, 15, 2, -23 },
  { 635, 13, 23, 15, 3, -23 },
  { 673, 14, 23, 15, 1, -23 },
  { 714, 14, 23, 15, 1, -23 },
  { 755, 5, 17, 6, 1, -17 },
  { 766, 7, 21, 6, -1, -17 },
  { 785, 13, 13, 16, 2, -18 },
  { 807, 13, 7, 16, 2, -15 },
  { 819, 13, 13, 16, 2, -18 },
  { 841, 10, 23, 11, 2, -23 },
  { 870, 21, 26, 23, 1, -23 },
  { 939, 15, 23, 15, -2, -23 },
  { 983, 15, 23, 17, 1, -23 },
  { 1027, 16, 23, 16, 2, -23 },
  { 1073, 17, 23, 19, 1, -23 },
  { 1122, 15, 23, 15, 1, -23 },
  { 1166, 15, 23, 14, 1, -23 },
  { 1210, 17, 23, 19, 2, -23 },
  { 1259, 18, 23, 19, 1, -23 },
  { 1311, 10, 23, 8, -1, -23 },
  { 1340, 12, 29, 7, -5, -23 },
  { 1384, 17, 23, 15, 1, -23 },
  { 1433, 10, 23, 14, 1, -23 },
  { 1462, 22, 23, 23, 1, -23 },
  { 1526, 18, 23, 19, 1, -23 },
  { 1578, 17, 23, 20, 2, -23 },
  { 1627, 15, 23, 15, 1, -23 },
  { 1671, 17, 28, 20, 2, -23 },
  { 1731, 15, 23, 16, 1, -23 },
  { 1775, 15, 23, 14, 0, -23 },
  { 1819, 13, 23, 13, 3, -23 },
  { 1857, 17, 23, 19, 2, -23 },
  { 1906, 14, 23, 15, 3, -23 },
  { 1947, 22, 23, 24, 4, -23 },
  { 2011, 18, 23, 13, -2, -23 },
  { 2063, 13, 23, 13, 3, -23 },
  { 2101, 17, 23, 15, -1, -23 },
  { 2150, 11, 28, 9, 0, -23 },
  { 2189, 5, 23, 10, 3, -23 },
  { 2204, 12, 28, 9, -2, -23 },
  { 2246, 14, 13, 16, 1, -23 },
  { 2269, 11, 1, 11, -3, 3 },
  { 2271, 3, 5, 7, 5, -24 },
  { 2273, 14, 17, 16, 1, -17 },
  { 2303, 13, 24, 16, 1, -24 },
  { 2342, 12, 17, 12, 1, -17 },
  { 2368, 16, 24, 16, 1, -24 },
  { 2416, 11, 17, 14, 2, -17 },
  { 2440, 16, 32, 8, -4, -24 },
  { 2504, 15, 25, 16, 0, -17 },
  { 2551, 13, 24, 15, 1, -24 },
  { 2590, 6, 23, 6, 1, -23 },
  { 2608, 11, 31, 6, -4, -23 },
  { 2651, 13, 24, 12, 1, -24 },
  { 2690, 6, 24, 6, 1, -24 },
  { 2708, 21, 17, 23, 1, -17 },
  { 2753, 13, 17, 15, 1, -17 },
  { 2781, 13, 17, 16, 1, -17 },
  { 2809, 15, 24, 16, -1, -17 },
  { 2854, 14, 24, 16, 1, -17 },
  { 2896, 10, 17, 10, 1, -17 },
  { 2918, 11, 17, 12, 0, -17 },
  { 2942, 8, 21, 8, 1, -21 },
  { 2963, 14, 17, 15, 1, -17 },
  { 2993, 11, 17, 11, 2, -17 },
  { 3017, 18, 17, 19, 2, -17 },
  { 3056, 14, 17, 13, -1, -17 },
  { 3086, 17, 25, 12, -4, -17 },
  { 3140, 13, 17, 12, -1, -17 },
  { 3168, 11, 28, 10, 1, -23 },
  { 3207, 1, 32, 15, 7, -24 },
  { 3211, 11, 28, 10, -2, -23 },
  { 3250, 13, 3, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC32PT7B_H_
