#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x00, 0x08, 0x4A, 0x52, 0xA9,
  0x48, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x43, 0xFF, 0x08, 0x80,
  0x88, 0x10, 0x81, 0x10, 0xFF, 0xC1, 0x10, 0x22, 0x02, 0x20, 0x22, 0x04,
  0x40, 0x02, 0x01, 0x07, 0xE4, 0x82, 0x42, 0x21, 0x10, 0x50, 0x18, 0x06,
  0x02, 0x81, 0x21, 0x10, 0x88, 0x49, 0xF8, 0x20, 0x10, 0x00, 0x38, 0x24,
  0x84, 0x88, 0x48, 0x88, 0x88, 0x88, 0x90, 0x8A, 0x69, 0x29, 0x95, 0x1E,
  0x91, 0x0A, 0x11, 0x21, 0x22, 0x22, 0x22, 0x42, 0x28, 0x3C, 0x0F, 0x04,
  0x21, 0x08, 0x42, 0x11, 0x04, 0x81, 0x40, 0x60, 0x28, 0x11, 0x18, 0x46,
  0x0A, 0x81, 0xA0, 0x48, 0x29, 0xF2, 0x55, 0xA0, 0x04, 0x21, 0x08, 0x21,
  0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x00, 0x08,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21,
  0x08, 0x00, 0x08, 0x22, 0x43, 0x81, 0xE6, 0x12, 0x44, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x29, 0x48, 0xF8,
  0x80, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14,
  0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x12, 0x10,
  0xF0, 0x09, 0xD3, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x0F,
  0x84, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFC, 0x0F, 0x84, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x7C, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x13, 0xF8, 0x00, 0x40, 0x30, 0x14, 0x0A, 0x04, 0x81, 0x20, 0x88,
  0x42, 0x21, 0x08, 0x44, 0x13, 0xFF, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0F,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0xC0, 0xCC, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x13, 0xF8, 0x07, 0xC2, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x05, 0xE1, 0x84, 0x41, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x21, 0xF0, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0F, 0x08, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x4C, 0x18, 0x34, 0x21, 0x20, 0x50, 0x28, 0x14,
  0x0A, 0x08, 0xF8, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x43, 0x1E, 0x80, 0x40, 0x20, 0x20, 0x20, 0x31, 0xE0, 0x11, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x42,
  0x00, 0x00, 0x80, 0x81, 0x83, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, 0x7C, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x04, 0x10, 0x41, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xE0, 0x18,
  0x41, 0x80, 0x88, 0x01, 0x20, 0x05, 0x0F, 0x94, 0x44, 0x62, 0x11, 0x88,
  0x46, 0x21, 0x19, 0x08, 0x64, 0x22, 0x89, 0x92, 0x19, 0x88, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81,
  0x20, 0x88, 0x22, 0x10, 0x47, 0xE2, 0x04, 0x81, 0x40, 0x50, 0x18, 0x06,
  0x01, 0x1F, 0x04, 0x32, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0xFC, 0x41,
  0x10, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x33, 0xF0, 0x03, 0xE1, 0x80,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0xF8, 0x1F, 0x02, 0x10, 0x81, 0x10,
  0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x40, 0x28,
  0x09, 0x02, 0x20, 0x87, 0xE0, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xF8, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x7F,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xE0, 0xC1,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x81, 0xE8, 0x02,
  0x80, 0x28, 0x04, 0x80, 0x44, 0x04, 0x40, 0x43, 0xF8, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x23, 0xFE, 0x40, 0x24, 0x04,
  0x40, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x1C, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x38, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x1E, 0x00, 0x10, 0x22, 0x08, 0x82,
  0x10, 0x82, 0x20, 0x48, 0x0A, 0x02, 0xC0, 0x68, 0x08, 0x81, 0x10, 0x42,
  0x08, 0x21, 0x04, 0x20, 0x44, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x10, 0x02, 0x20, 0x0C,
  0xC0, 0x19, 0x40, 0x52, 0x80, 0xC5, 0x02, 0x8A, 0x09, 0x24, 0x12, 0x48,
  0x48, 0x90, 0x91, 0x22, 0x24, 0x24, 0x48, 0x50, 0x90, 0xA2, 0x21, 0x84,
  0x42, 0x08, 0x10, 0x11, 0x01, 0x28, 0x12, 0x81, 0x28, 0x22, 0x42, 0x24,
  0x24, 0x42, 0x42, 0x24, 0x24, 0x42, 0x48, 0x14, 0x81, 0x48, 0x14, 0x80,
  0x88, 0x08, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40,
  0x83, 0xF0, 0x1F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x48, 0x12, 0x09, 0x02,
  0x47, 0x1E, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07, 0xC0,
  0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40, 0x83, 0xB0, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x1F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x09, 0x04, 0x7E, 0x11, 0x04, 0x42, 0x08, 0x82, 0x20, 0x88, 0x12, 0x04,
  0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x13, 0xF8, 0xFF, 0x84, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41,
  0x03, 0xE0, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10,
  0x44, 0x12, 0x04, 0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x00, 0x80, 0x81,
  0x81, 0x02, 0x81, 0x02, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88,
  0x88, 0x88, 0x88, 0x90, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0,
  0x60, 0xC0, 0x40, 0xC0, 0x40, 0x80, 0x10, 0x10, 0x82, 0x08, 0x40, 0x84,
  0x04, 0x80, 0x50, 0x05, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x10,
  0x21, 0x04, 0x10, 0x40, 0x88, 0x08, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x42,
  0x21, 0x20, 0x90, 0x30, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x1F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x07, 0xF8, 0x0F, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0xF0, 0x92, 0x24, 0x92, 0x44, 0x92, 0x49, 0x0F,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x3E, 0x00, 0x04, 0x03, 0x02,
  0x82, 0x41, 0x11, 0x09, 0x04, 0x81, 0x80, 0x80, 0xFF, 0x89, 0x10, 0x1E,
  0x90, 0xD0, 0x28, 0x18, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x8F,
  0x40, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05, 0xC2, 0x88, 0xC1, 0x20,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0xBE, 0x00, 0x0F,
  0x30, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0x92, 0x19, 0x02, 0x40, 0xA0, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x48, 0x22, 0x18, 0x7A, 0x00, 0x0E, 0x31, 0x21,
  0x41, 0x82, 0x9C, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0xE0, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x1F, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x01, 0xC0, 0x00, 0x0F, 0x44, 0x32, 0x04, 0x81, 0x40, 0x50, 0x14,
  0x09, 0x02, 0x40, 0x90, 0x44, 0x30, 0xF4, 0x01, 0x00, 0x40, 0x20, 0x08,
  0xFC, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05, 0xC2, 0x88, 0x41,
  0x20, 0x48, 0x22, 0x09, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x81, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x01, 0x02,
  0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x84, 0x84, 0x44, 0x24, 0x12, 0x0A, 0x0B, 0x06, 0x42, 0x21, 0x10,
  0x84, 0x82, 0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x08, 0x80, 0x17, 0x1C, 0x51, 0x44, 0x43, 0x09, 0x04, 0x12, 0x08, 0x24,
  0x10, 0x50, 0x20, 0xA0, 0x82, 0x41, 0x04, 0x82, 0x09, 0x04, 0x14, 0x10,
  0x20, 0x17, 0x0A, 0x21, 0x04, 0x81, 0x20, 0x88, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x44, 0x12, 0x04, 0x0E, 0x18, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03,
  0x02, 0x81, 0x40, 0xA0, 0x8F, 0x80, 0x0B, 0x82, 0x88, 0x20, 0x88, 0x11,
  0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x2F, 0x84, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x18, 0x0C,
  0x06, 0x05, 0x02, 0x81, 0x41, 0x21, 0x8F, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x00, 0x17, 0x28, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x1E, 0x21, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x04, 0xF8, 0x21, 0x3E, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x70, 0x20,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x8F,
  0x40, 0x81, 0x81, 0x82, 0x82, 0x84, 0x88, 0x48, 0x50, 0x50, 0x60, 0x60,
  0x40, 0x82, 0x0C, 0x10, 0xA1, 0x85, 0x0C, 0x48, 0xA2, 0x45, 0x22, 0x49,
  0x12, 0x48, 0xA2, 0x85, 0x14, 0x10, 0x40, 0x82, 0x00, 0x10, 0x44, 0x21,
  0x08, 0x24, 0x0A, 0x01, 0x00, 0xC0, 0x30, 0x12, 0x08, 0x84, 0x22, 0x04,
  0x08, 0x10, 0x81, 0x08, 0x20, 0x82, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48,
  0x05, 0x00, 0x50, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0xF0, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x80, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x21, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x0C, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x21, 0x84, 0x00, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 6, 2, -16 },
  { 13, 12, 16, 12, 0, -16 },
  { 37, 9, 18, 10, 1, -17 },
  { 58, 12, 16, 15, 2, -16 },
  { 82, 10, 16, 12, 1, -16 },
  { 102, 2, 6, 4, 2, -16 },
  { 104, 6, 19, 5, 1, -16 },
  { 119, 6, 19, 5, -1, -16 },
  { 134, 7, 8, 10, 3, -17 },
  { 141, 9, 10, 11, 1, -13 },
  { 153, 3, 5, 4, -1, -2 },
  { 155, 5, 1, 6, 1, -6 },
  { 156, 1, 1, 4, 1, -1 },
  { 157, 9, 16, 7, -1, -16 },
  { 175, 9, 16, 10, 1, -16 },
  { 193, 5, 16, 10, 3, -16 },
  { 203, 10, 16, 10, 0, -16 },
  { 223, 10, 16, 10, 0, -16 },
  { 243, 10, 16, 10, 0, -16 },
  { 263, 10, 16, 10, 0, -16 },
  { 283, 10, 16, 10, 1, -16 },
  { 303, 9, 16, 10, 2, -16 },
  { 321, 9, 16, 10, 1, -16 },
  { 339, 9, 16, 10, 1, -16 },
  { 357, 4, 12, 4, 0, -12 },
  { 363, 5, 15, 4, -1, -12 },
  { 373, 9, 10, 11, 1, -13 },
  { 385, 9, 5, 11, 1, -10 },
  { 391, 9, 10, 11, 1, -13 },
  { 403, 7, 16, 8, 1, -16 },
  { 417, 14, 18, 16, 1, -16 },
  { 449, 10, 16, 10, -1, -16 },
  { 469, 10, 16, 11, 1, -16 },
  { 489, 11, 16, 11, 1, -16 },
  { 511, 11, 16, 13, 1, -16 },
  { 533, 10, 16, 10, 1, -16 },
  { 553, 10, 16, 9, 1, -16 },
  { 573, 12, 16, 13, 1, -16 },
  { 597, 12, 16, 13, 1, -16 },
  { 621, 6, 16, 5, 0, -16 },
  { 633, 9, 20, 4, -4, -16 },
  { 656, 11, 16, 10, 1, -16 },
  { 678, 7, 16, 9, 1, -16 },
  { 692, 15, 16, 16, 1, -16 },
  { 722, 12, 16, 13, 1, -16 },
  { 746, 12, 16, 14, 1, -16 },
  { 770, 10, 16, 11, 1, -16 },
  { 790, 12, 20, 14, 1, -16 },
  { 820, 10, 16, 11, 1, -16 },
  { 840, 10, 16, 10, 0, -16 },
  { 860, 9, 16, 9, 2, -16 },
  { 878, 12, 16, 13, 1, -16 },
  { 902, 10, 16, 10, 2, -16 },
  { 922, 16, 16, 16, 2, -16 },
  { 954, 12, 16, 9, -1, -16 },
  { 978, 9, 16, 9, 2, -16 },
  { 996, 11, 16, 10, 0, -16 },
  { 1018, 8, 19, 6, 0, -16 },
  { 1037, 3, 16, 7, 2, -16 },
  { 1043, 9, 19, 6, -2, -16 },
  { 1065, 9, 9, 11, 1, -16 },
  { 1076, 8, 1, 7, -2, 2 },
  { 1077, 3, 4, 5, 3, -17 },
  { 1079, 9, 12, 11, 1, -12 },
  { 1093, 10, 17, 11, 0, -17 },
  { 1115, 8, 12, 8, 1, -12 },
  { 1127, 10, 17, 11, 1, -17 },
  { 1149, 8, 12, 9, 1, -12 },
  { 1161, 11, 22, 5, -3, -17 },
  { 1192, 10, 17, 11, 0, -12 },
  { 1214, 10, 17, 11, 0, -17 },
  { 1236, 5, 16, 4, 0, -16 },
  { 1246, 8, 21, 4, -3, -16 },
  { 1267, 9, 17, 9, 0, -17 },
  { 1287, 5, 17, 4, 0, -17 },
  { 1298, 15, 12, 16, 0, -12 },
  { 1321, 10, 12, 11, 0, -12 },
  { 1336, 9, 12, 11, 1, -12 },
  { 1350, 11, 17, 11, -1, -12 },
  { 1374, 9, 17, 11, 1, -12 },
  { 1394, 8, 12, 7, 0, -12 },
  { 1406, 8, 12, 8, 0, -12 },
  { 1418, 5, 14, 6, 1, -14 },
  { 1427, 9, 12, 11, 1, -12 },
  { 1441, 8, 12, 8, 1, -12 },
  { 1453, 13, 12, 13, 1, -12 },
  { 1473, 10, 12, 9, -1, -12 },
  { 1488, 12, 17, 8, -3, -12 },
  { 1514, 8, 12, 8, 0, -12 },
  { 1526, 7, 19, 7, 1, -16 },
  { 1543, 1, 22, 10, 5, -17 },
  { 1546, 7, 20, 7, -1, -16 },
  { 1564, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC22PT7B_H_
