#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x22, 0x44, 0x8A, 0x14, 0x48,
  0x91, 0x22, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x80,
  0x10, 0x40, 0x08, 0x20, 0x08, 0x20, 0x04, 0x10, 0x3F, 0xFF, 0x82, 0x04,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10,
  0x44, 0xF7, 0xDC, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x82, 0x00, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0xFE, 0x0C, 0x44, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01,
  0x10, 0x03, 0x40, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x88, 0x02, 0x10,
  0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x20, 0x11, 0x0E, 0x78, 0x07, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x42, 0x20, 0x10, 0x82,
  0x04, 0x10, 0x40, 0x84, 0x08, 0x20, 0x81, 0x08, 0x10, 0x21, 0x02, 0x04,
  0x40, 0x81, 0x10, 0x10, 0x22, 0x02, 0x04, 0x9F, 0x41, 0x26, 0x28, 0x24,
  0x82, 0x89, 0x20, 0x4E, 0x24, 0x08, 0x08, 0x82, 0x02, 0x20, 0x40, 0x44,
  0x08, 0x10, 0x81, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x41, 0x08, 0x08,
  0x43, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x18, 0x06, 0x08, 0x04, 0x08, 0x04,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40, 0x03,
  0x80, 0x03, 0x00, 0x0D, 0x00, 0x10, 0x80, 0x20, 0x81, 0x40, 0x42, 0x80,
  0x42, 0x80, 0x24, 0x80, 0x2C, 0x80, 0x18, 0x80, 0x10, 0x80, 0x28, 0x40,
  0xC4, 0x3F, 0x04, 0x24, 0xA4, 0x92, 0x80, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x0C,
  0x00, 0x02, 0x00, 0x20, 0x02, 0x0C, 0x20, 0x24, 0x01, 0xDF, 0x06, 0x00,
  0xA0, 0x32, 0x04, 0x10, 0x41, 0x00, 0x08, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x11, 0x22,
  0x44, 0x88, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xE0,
  0x20, 0x82, 0x04, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07,
  0xC0, 0x02, 0x0C, 0x69, 0x2C, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x00, 0xF0,
  0x06, 0x18, 0x10, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x0C, 0x18, 0x20,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x40, 0x3E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x20, 0x18, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xA0,
  0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10, 0x08,
  0x20, 0x20, 0x40, 0x81, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x21,
  0xFF, 0xFC, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x20, 0x18, 0x3F, 0xC0, 0x00, 0xFC,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x0C, 0x04, 0xCC, 0x2C, 0x08, 0xC0, 0x13, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01,
  0x04, 0x08, 0x0F, 0xC0, 0x7F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x18, 0x20, 0xC0,
  0x42, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x42, 0x01, 0x08, 0x08, 0x10,
  0x40, 0x66, 0x00, 0x60, 0x0E, 0x80, 0x41, 0x82, 0x02, 0x10, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x84, 0x04, 0x0F,
  0xE0, 0x01, 0xE0, 0x18, 0x40, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x20, 0x18,
  0x41, 0xA0, 0xF8, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x3F, 0x00, 0x10, 0xC4, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0x00, 0x02, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x18, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1F, 0x08, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x7F, 0xC0, 0x06, 0x00, 0x80, 0x20, 0x01, 0x01, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x60, 0x00, 0x11, 0x01, 0xE0, 0x48, 0x08, 0x41, 0x20, 0x41,
  0x04, 0x82, 0x04, 0x14, 0x10, 0x20, 0x50, 0x40, 0x81, 0x42, 0x02, 0x09,
  0x08, 0x08, 0x28, 0x20, 0x40, 0xA0, 0x81, 0x04, 0x82, 0x0C, 0x12, 0x08,
  0x50, 0x84, 0x1F, 0x3C, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x14, 0x00, 0x14, 0x00, 0x24, 0x00, 0x24,
  0x00, 0x44, 0x00, 0x44, 0x00, 0x84, 0x00, 0x84, 0x01, 0x04, 0x01, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x07, 0xFE, 0x04, 0x02, 0x08, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01,
  0x07, 0xF0, 0x04, 0x0C, 0x04, 0x02, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x18, 0x1F, 0xE0,
  0x20, 0x30, 0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x80, 0x60, 0xFF, 0x80,
  0x00, 0x7E, 0x01, 0x81, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x0F, 0xF0,
  0x07, 0xC0, 0x02, 0x1E, 0x01, 0x01, 0x81, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x04, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02,
  0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x03,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xFF, 0x82, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFF,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00,
  0x60, 0x70, 0x20, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x3F, 0x20, 0x10, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x08, 0x01, 0x03, 0x00,
  0x40, 0x3F, 0xE0, 0x04, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00,
  0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x02, 0x0F, 0xFF, 0x82, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20,
  0x07, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x03, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x88, 0x0E, 0x00, 0x04, 0x00, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80,
  0x04, 0x80, 0x02, 0xA0, 0x02, 0x90, 0x01, 0x88, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x02, 0x00, 0x41, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x03, 0xFF,
  0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x28, 0x50, 0x00, 0x60,
  0xA0, 0x01, 0x41, 0x40, 0x02, 0x82, 0x80, 0x09, 0x05, 0x00, 0x12, 0x12,
  0x00, 0x48, 0x22, 0x00, 0x90, 0x44, 0x02, 0x20, 0x88, 0x08, 0x42, 0x10,
  0x10, 0x84, 0x20, 0x42, 0x08, 0x40, 0x84, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x81, 0x10, 0x41, 0x02, 0x20, 0x82, 0x04, 0x81, 0x04, 0x0A, 0x02,
  0x08, 0x14, 0x04, 0x20, 0x30, 0x10, 0x40, 0x60, 0x20, 0x04, 0x00, 0x20,
  0x80, 0x04, 0x18, 0x01, 0x05, 0x00, 0x20, 0xA0, 0x04, 0x12, 0x00, 0x82,
  0x40, 0x10, 0x48, 0x04, 0x10, 0x80, 0x82, 0x10, 0x10, 0x42, 0x02, 0x08,
  0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x08, 0x41, 0x01, 0x08, 0x20,
  0x22, 0x08, 0x02, 0x41, 0x00, 0x48, 0x20, 0x09, 0x04, 0x00, 0xA0, 0x80,
  0x18, 0x20, 0x03, 0x04, 0x00, 0x20, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x43, 0x00, 0x40, 0xC0, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x08,
  0x30, 0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01,
  0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x42, 0x03, 0x07, 0xF8, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x43, 0x00, 0x40, 0xC0, 0xC0, 0x3F, 0x80, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x07, 0xE0,
  0x08, 0x30, 0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84,
  0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x30, 0x80, 0xC2, 0x0E, 0x07, 0xF0,
  0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x00, 0x82, 0x01, 0x04,
  0x02, 0x08, 0x04, 0x20, 0x04, 0x40, 0x08, 0x01, 0xF8, 0x04, 0x0C, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x20, 0x18, 0x3F, 0xC0, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x10, 0x04, 0x06,
  0x02, 0x00, 0x7F, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48,
  0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x81, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00,
  0x88, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x14, 0x02, 0x80,
  0x48, 0x05, 0x00, 0x90, 0x12, 0x01, 0x20, 0x24, 0x04, 0x40, 0x48, 0x08,
  0x81, 0x10, 0x21, 0x02, 0x20, 0x42, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x82, 0x10, 0x22, 0x04, 0x20, 0x44, 0x08, 0x80, 0x88,
  0x11, 0x01, 0x20, 0x24, 0x02, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x0A, 0x01,
  0x40, 0x18, 0x02, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x08, 0x04, 0x04, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x08, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x24, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x10,
  0x01, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x10, 0x08, 0x08, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x06, 0x00, 0x28, 0x01, 0x10, 0x04, 0x40,
  0x21, 0x01, 0x04, 0x04, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x20, 0x09,
  0x00, 0x14, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFC, 0x00, 0x84, 0x10, 0x84,
  0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x84, 0x21,
  0x03, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x0A, 0x00, 0x48, 0x02, 0x20, 0x08, 0x40, 0x41, 0x02, 0x04, 0x08, 0x08,
  0x40, 0x22, 0x00, 0x88, 0x01, 0x40, 0x07, 0x00, 0x10, 0xFF, 0xE0, 0x89,
  0x12, 0x01, 0xC0, 0x18, 0x90, 0x81, 0x44, 0x03, 0x20, 0x08, 0x80, 0x24,
  0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32,
  0x00, 0x84, 0x06, 0x10, 0x28, 0x41, 0xA0, 0xF8, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x38, 0x13,
  0x10, 0x50, 0x21, 0x80, 0x44, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x13, 0x00, 0x4C,
  0x02, 0x28, 0x10, 0x9F, 0x80, 0x03, 0xC1, 0x84, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x01, 0xC2, 0x06, 0x34,
  0x08, 0x0C, 0x10, 0x0C, 0x20, 0x0C, 0x20, 0x0C, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30,
  0x40, 0x70, 0x40, 0x50, 0x40, 0xA0, 0x3F, 0x20, 0x03, 0x81, 0x8C, 0x40,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x14, 0x04, 0x87, 0x1D, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x03, 0xB8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x19, 0x04, 0x06, 0x08, 0x06, 0x10,
  0x06, 0x10, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0x20, 0x38, 0x20, 0x30, 0x20,
  0x50, 0x1F, 0x90, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0xC1, 0x80, 0x3E, 0x00, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x1C, 0x13, 0x18, 0xA0, 0x46,
  0x02, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x20,
  0x04, 0x30, 0x00, 0x00, 0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x0F, 0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x01, 0x10, 0x10, 0x81, 0x04, 0x10,
  0x21, 0x02, 0x10, 0x11, 0x00, 0x90, 0x05, 0x80, 0x52, 0x03, 0x10, 0x10,
  0x80, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x40, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x01, 0xC0, 0xE0, 0x48, 0xC4, 0x61,
  0x41, 0x20, 0x86, 0x05, 0x01, 0x10, 0x08, 0x04, 0xC0, 0x60, 0x22, 0x01,
  0x00, 0x88, 0x04, 0x02, 0x20, 0x10, 0x09, 0x00, 0x40, 0x24, 0x02, 0x01,
  0x10, 0x08, 0x04, 0x40, 0x20, 0x11, 0x00, 0x80, 0x48, 0x02, 0x01, 0x20,
  0x10, 0x08, 0x80, 0x40, 0x22, 0x01, 0x00, 0x80, 0x00, 0xE0, 0x98, 0xC5,
  0x02, 0x30, 0x11, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x01, 0x00, 0x01, 0xC0, 0x18, 0xC0, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x44, 0x01, 0x10, 0x08, 0x20, 0x40, 0x7E, 0x00, 0x00, 0x38,
  0x04, 0xC4, 0x05, 0x02, 0x06, 0x01, 0x06, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x30, 0x04, 0x30, 0x08, 0x28, 0x10, 0x27, 0xE0, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x0C, 0x64, 0x20, 0x50, 0x80, 0x62, 0x00, 0xC4,
  0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x06, 0x10, 0x1C, 0x20, 0x28, 0x40, 0xA0, 0x7E, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x00, 0xE2, 0x60, 0x50, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x03, 0x80, 0xC3, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x80, 0x87, 0xF0, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x7F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x78, 0x10, 0x04, 0x40, 0x11, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01,
  0x10, 0x08, 0x80, 0x22, 0x01, 0x88, 0x0A, 0x10, 0x68, 0x3E, 0x20, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x10, 0x42, 0x08,
  0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90,
  0x48, 0x44, 0x22, 0x11, 0x08, 0x88, 0x44, 0x22, 0x11, 0x08, 0x84, 0x42,
  0x41, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x03, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x00, 0x08, 0x06, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00,
  0x48, 0x00, 0xA0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x12, 0x00, 0x44,
  0x01, 0x04, 0x06, 0x08, 0x08, 0x10, 0x20, 0x10, 0x80, 0x20, 0x02, 0x00,
  0xC0, 0x80, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x40, 0x80,
  0x10, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x38, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x03, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x70, 0x0C, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0xF0, 0x00, 0x7C, 0x06, 0x0C, 0x28, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 10, 3, -24 },
  { 27, 17, 24, 17, 1, -24 },
  { 78, 14, 27, 16, 1, -25 },
  { 126, 19, 24, 22, 2, -24 },
  { 183, 16, 24, 18, 1, -24 },
  { 231, 3, 9, 5, 3, -24 },
  { 235, 9, 29, 8, 1, -24 },
  { 268, 9, 29, 8, -2, -24 },
  { 301, 12, 12, 15, 4, -25 },
  { 319, 14, 15, 17, 2, -19 },
  { 346, 4, 8, 6, -1, -4 },
  { 350, 8, 1, 10, 1, -9 },
  { 351, 2, 2, 6, 1, -2 },
  { 352, 14, 24, 10, -1, -24 },
  { 394, 13, 24, 16, 2, -24 },
  { 433, 7, 24, 16, 5, -24 },
  { 454, 15, 24, 16, 0, -24 },
  { 499, 15, 24, 16, 0, -24 },
  { 544, 15, 24, 16, 0, -24 },
  { 589, 15, 24, 16, 0, -24 },
  { 634, 14, 24, 16, 2, -24 },
  { 676, 13, 24, 16, 3, -24 },
  { 715, 14, 24, 16, 1, -24 },
  { 757, 14, 24, 16, 1, -24 },
  { 799, 5, 18, 6, 1, -18 },
  { 811, 7, 22, 6, -1, -18 },
  { 831, 14, 14, 17, 2, -19 },
  { 856, 14, 7, 17, 2, -15 },
  { 869, 14, 14, 17, 2, -19 },
  { 894, 10, 24, 11, 2, -24 },
  { 924, 22, 26, 24, 1, -23 },
  { 996, 16, 24, 15, -2, -24 },
  { 1044, 16, 24, 17, 1, -24 },
  { 1092, 16, 24, 17, 2, -24 },
  { 1140, 17, 24, 19, 1, -24 },
  { 1191, 15, 24, 15, 1, -24 },
  { 1236, 15, 24, 14, 1, -24 },
  { 1281, 18, 24, 20, 2, -24 },
  { 1335, 19, 24, 20, 1, -24 },
  { 1392, 10, 24, 8, -1, -24 },
  { 1422, 12, 30, 7, -5, -24 },
  { 1467, 17, 24, 16, 1, -24 },
  { 1518, 10, 24, 14, 1, -24 },
  { 1548, 23, 24, 24, 1, -24 },
  { 1617, 19, 24, 20, 1, -24 },
  { 1674, 17, 24, 20, 2, -24 },
  { 1725, 15, 24, 16, 1, -24 },
  { 1770, 17, 30, 20, 2, -24 },
  { 1834, 15, 24, 16, 1, -24 },
  { 1879, 15, 24, 15, 0, -24 },
  { 1924, 14, 24, 14, 3, -24 },
  { 1966, 18, 24, 20, 2, -24 },
  { 2020, 15, 24, 15, 3, -24 },
  { 2065, 23, 24, 24, 4, -24 },
  { 2134, 18, 24, 14, -2, -24 },
  { 2188, 14, 24, 14, 3, -24 },
  { 2230, 17, 24, 15, -1, -24 },
  { 2281, 12, 29, 10, 0, -24 },
  { 2325, 5, 24, 10, 3, -24 },
  { 2340, 12, 29, 10, -2, -24 },
  { 2384, 14, 14, 16, 1, -24 },
  { 2409, 11, 1, 11, -3, 3 },
  { 2411, 3, 5, 7, 5, -25 },
  { 2413, 14, 18, 16, 1, -18 },
  { 2445, 14, 25, 16, 1, -25 },
  { 2489, 11, 18, 13, 2, -18 },
  { 2514, 16, 25, 16, 1, -25 },
  { 2564, 11, 18, 14, 2, -18 },
  { 2589, 16, 33, 8, -4, -25 },
  { 2655, 16, 26, 16, 0, -18 },
  { 2707, 13, 25, 16, 1, -25 },
  { 2748, 6, 24, 6, 1, -24 },
  { 2766, 12, 32, 6, -5, -24 },
  { 2814, 13, 25, 13, 1, -25 },
  { 2855, 6, 25, 6, 1, -25 },
  { 2874, 22, 18, 24, 1, -18 },
  { 2924, 13, 18, 16, 1, -18 },
  { 2954, 14, 18, 16, 1, -18 },
  { 2986, 16, 26, 16, -1, -18 },
  { 3038, 15, 26, 16, 1, -18 },
  { 3087, 11, 18, 11, 1, -18 },
  { 3112, 12, 18, 12, 0, -18 },
  { 3139, 8, 22, 9, 1, -22 },
  { 3161, 14, 17, 16, 1, -17 },
  { 3191, 11, 17, 12, 2, -17 },
  { 3215, 18, 17, 19, 2, -17 },
  { 3254, 15, 17, 13, -1, -17 },
  { 3286, 18, 25, 12, -4, -17 },
  { 3343, 13, 17, 12, -1, -17 },
  { 3371, 11, 29, 11, 1, -24 },
  { 3411, 1, 33, 15, 8, -25 },
  { 3416, 12, 29, 11, -2, -24 },
  { 3460, 14, 3, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC33PT7B_H_
