#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x22, 0x89, 0x12, 0x24, 0x48, 0xA2,
  0x44, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x3D, 0xFF, 0x04, 0x10, 0x04, 0x20, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0x80, 0x20,
  0x80, 0x20, 0x80, 0x21, 0x00, 0x41, 0x00, 0x41, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x07, 0xE0, 0xC8, 0x88, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x12, 0x00, 0x60, 0x01, 0xC0, 0x09, 0x00, 0x44, 0x02,
  0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x64, 0xC0, 0xB8, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x1F, 0x01, 0x10, 0x81, 0x08, 0x40, 0x88, 0x20,
  0x84, 0x10, 0x82, 0x08, 0x42, 0x04, 0x41, 0x02, 0x20, 0x82, 0x22, 0x41,
  0x26, 0xE0, 0x94, 0x30, 0x92, 0x14, 0x92, 0x09, 0x89, 0x04, 0x08, 0x82,
  0x08, 0x41, 0x04, 0x40, 0x84, 0x20, 0x44, 0x10, 0x42, 0x08, 0x22, 0x02,
  0x22, 0x01, 0xE0, 0x03, 0xE0, 0x08, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81,
  0x01, 0x02, 0x02, 0x08, 0x02, 0x30, 0x04, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC8, 0x02, 0x10, 0x28, 0x10, 0x50, 0x21, 0x40, 0x24, 0x80, 0x49, 0x00,
  0x62, 0x00, 0xC4, 0x02, 0x8C, 0x08, 0x8F, 0xE1, 0x00, 0x29, 0x24, 0xA4,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x00, 0x02, 0x00,
  0x82, 0x10, 0x32, 0x01, 0x4E, 0x1E, 0x05, 0x01, 0x10, 0x42, 0x10, 0x40,
  0x04, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x82, 0x10, 0x12,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88,
  0x10, 0xC3, 0x07, 0xC0, 0x0C, 0x52, 0x71, 0x88, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x00, 0x03, 0xF0, 0x10,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x80,
  0x03, 0xF8, 0x30, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x80, 0x7C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x80,
  0x41, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x80, 0x0A, 0x00, 0x48,
  0x02, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x10, 0x40, 0x81, 0x04, 0x04,
  0x10, 0x20, 0x80, 0x84, 0x02, 0x3F, 0xEF, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x3F,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x08, 0x04, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x47, 0x04, 0xC6, 0x28, 0x11, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x04, 0x10, 0x1F, 0x00,
  0x7F, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF0, 0x40,
  0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x21, 0x02, 0x08, 0x20,
  0x26, 0x01, 0xC0, 0x31, 0x02, 0x04, 0x20, 0x12, 0x00, 0x90, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x09, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x07, 0xE0, 0x40,
  0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x09,
  0x00, 0xC8, 0x06, 0x40, 0x61, 0x9D, 0x03, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x7E, 0x00, 0x11, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x88, 0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x18,
  0x0C, 0x02, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x3C, 0x12, 0x04, 0x21, 0x20, 0x82, 0x14, 0x10, 0x21, 0x41, 0x04, 0x14,
  0x20, 0x41, 0x42, 0x04, 0x18, 0x20, 0x41, 0x84, 0x08, 0x28, 0x40, 0x82,
  0x82, 0x18, 0x48, 0x22, 0x48, 0x40, 0xC3, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22,
  0x00, 0x44, 0x01, 0x04, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40,
  0xFF, 0x82, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00,
  0x14, 0x00, 0x30, 0x00, 0x40, 0x07, 0xF8, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x10, 0x80, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x60,
  0xFF, 0x01, 0x01, 0x82, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x44, 0x01, 0x08, 0x04, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x08, 0x0C, 0x08, 0x06, 0x08,
  0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x80, 0x20, 0x80, 0xC0, 0xFF,
  0x00, 0x07, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F,
  0xF8, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x06, 0x01, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x7E, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40, 0x08, 0x40, 0x08, 0x20,
  0x08, 0x1F, 0xF0, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x0F, 0xFF, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x80,
  0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x40, 0x07, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x3E, 0x00, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0xF8, 0x00, 0x0C,
  0x03, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20, 0x10, 0x40, 0x10,
  0x80, 0x11, 0x00, 0x12, 0x00, 0x16, 0x00, 0x2A, 0x00, 0x31, 0x00, 0x21,
  0x00, 0x21, 0x00, 0x40, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0A, 0x0A, 0x00,
  0x28, 0x48, 0x01, 0x41, 0x20, 0x05, 0x04, 0x80, 0x24, 0x12, 0x01, 0x10,
  0x48, 0x04, 0x42, 0x20, 0x22, 0x08, 0x40, 0x88, 0x21, 0x04, 0x20, 0x84,
  0x10, 0x84, 0x10, 0x82, 0x10, 0x42, 0x10, 0x41, 0x10, 0x41, 0x04, 0x81,
  0x04, 0x12, 0x04, 0x20, 0x30, 0x20, 0x80, 0xC0, 0x82, 0x02, 0x02, 0x00,
  0x04, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x08, 0x28, 0x02, 0x0A, 0x00, 0x84,
  0x80, 0x41, 0x10, 0x10, 0x44, 0x04, 0x11, 0x01, 0x04, 0x20, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x42, 0x08, 0x10, 0x84, 0x04, 0x21, 0x00, 0x90,
  0x40, 0x24, 0x10, 0x09, 0x04, 0x01, 0x42, 0x00, 0x60, 0x80, 0x08, 0x20,
  0x02, 0x00, 0x03, 0xF8, 0x04, 0x06, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0, 0x07, 0xF0,
  0x20, 0x20, 0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01,
  0x10, 0x08, 0x40, 0x22, 0x01, 0x08, 0x38, 0x3F, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x00, 0x03, 0xF8, 0x04, 0x06, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x07, 0xF0, 0x20, 0x20, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40,
  0x22, 0x03, 0x0F, 0xF0, 0x20, 0x80, 0x82, 0x02, 0x08, 0x10, 0x10, 0x40,
  0x41, 0x01, 0x04, 0x04, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x03, 0xFC,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x80, 0x43, 0xFE,
  0x00, 0xFF, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x04, 0x20, 0x04, 0x08, 0x04, 0x04, 0x06, 0x01, 0xFC, 0x00,
  0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02,
  0x10, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x40, 0x42, 0x01, 0x08,
  0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x28, 0x03, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44,
  0x08, 0x41, 0x10, 0x41, 0x04, 0x41, 0x04, 0x21, 0x04, 0x10, 0x84, 0x20,
  0x44, 0x10, 0x81, 0x10, 0x44, 0x04, 0x81, 0x10, 0x12, 0x04, 0x80, 0x50,
  0x12, 0x01, 0x40, 0x50, 0x06, 0x01, 0x40, 0x18, 0x05, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x00, 0x02, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x20,
  0x40, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x01, 0x20, 0x00, 0xA0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x14, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x08, 0x40, 0x08, 0x20, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x04, 0x00,
  0x86, 0x00, 0x40, 0x80, 0x1C, 0x00, 0xA0, 0x08, 0x80, 0x84, 0x04, 0x20,
  0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x00, 0x07, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x07,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xE0,
  0x00, 0x84, 0x20, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x04, 0x07, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x83, 0xF0, 0x00, 0x00, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x80,
  0x42, 0x02, 0x10, 0x20, 0x82, 0x02, 0x10, 0x11, 0x00, 0x90, 0x03, 0x80,
  0x10, 0xFF, 0xE0, 0x92, 0x22, 0x03, 0x80, 0x23, 0x46, 0x0A, 0x20, 0x32,
  0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x14, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x06, 0x40, 0x31, 0x03, 0x08, 0x28, 0x3E, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x38, 0x12, 0x30,
  0xE0, 0x8A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x90, 0x04, 0x80, 0x2C, 0x02, 0x60, 0x22, 0x82, 0x13, 0xE0,
  0x01, 0xC0, 0xC4, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x1F, 0x80,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x01, 0xE2, 0x04, 0x24, 0x30, 0x30, 0x40, 0x61, 0x00, 0x42, 0x00,
  0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84,
  0x01, 0x08, 0x06, 0x08, 0x14, 0x10, 0x48, 0x1F, 0x20, 0x03, 0x01, 0x98,
  0x41, 0x10, 0x14, 0x04, 0x80, 0xA0, 0x24, 0x18, 0xFC, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x03, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x04, 0x24, 0x30, 0x30, 0x40, 0x61, 0x00, 0x42, 0x00, 0x88, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01, 0x08,
  0x06, 0x08, 0x14, 0x10, 0x48, 0x1F, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x7F, 0x80, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x1C, 0x16, 0x31, 0x81, 0x28,
  0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x08, 0x40, 0x00, 0x00,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xF0, 0x00, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x01, 0x10,
  0x21, 0x04, 0x20, 0x82, 0x10, 0x23, 0x02, 0x20, 0x24, 0x04, 0xC0, 0x54,
  0x06, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x88, 0x08, 0x08,
  0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x01, 0xC1, 0xC1, 0x62, 0x22, 0x18, 0x24, 0x13, 0x01, 0x81,
  0x30, 0x10, 0x12, 0x01, 0x01, 0x20, 0x20, 0x12, 0x02, 0x01, 0x40, 0x20,
  0x24, 0x02, 0x02, 0x40, 0x20, 0x24, 0x04, 0x02, 0x40, 0x40, 0x28, 0x04,
  0x04, 0x80, 0x40, 0x48, 0x08, 0x04, 0x80, 0x80, 0x40, 0x01, 0xC1, 0x63,
  0x18, 0x12, 0x81, 0x30, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x40, 0x01,
  0xC0, 0x31, 0x02, 0x04, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01,
  0x40, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01, 0x08,
  0x10, 0x3F, 0x00, 0x00, 0x70, 0x09, 0x18, 0x1C, 0x10, 0x50, 0x10, 0xC0,
  0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10,
  0x80, 0x21, 0x00, 0x46, 0x01, 0x0C, 0x04, 0x14, 0x10, 0x27, 0xC0, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x03, 0x80, 0x11, 0x91, 0x81, 0x84, 0x06, 0x20, 0x08, 0x80, 0x24, 0x01,
  0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01,
  0x84, 0x0A, 0x10, 0x48, 0x3E, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC5, 0x81, 0x80, 0xA0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x07, 0x01, 0x0C, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x24, 0x08, 0xFE, 0x00, 0x08, 0x10, 0x10, 0x10, 0x7F, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x78,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48,
  0x02, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x61, 0x05,
  0x0F, 0xC8, 0x80, 0x70, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84,
  0x10, 0x84, 0x08, 0x81, 0x20, 0x28, 0x05, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x80, 0x80, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24,
  0x12, 0x12, 0x11, 0x11, 0x08, 0x88, 0x48, 0x48, 0x24, 0x24, 0x14, 0x14,
  0x0A, 0x0A, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x00, 0x80, 0x08, 0x0C,
  0x20, 0x40, 0x41, 0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x14, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x04, 0x04,
  0x20, 0x08, 0x02, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x40, 0x10, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x02, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x03, 0x80, 0x00, 0x7C, 0x0C, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 6, 1, -22 },
  { 18, 7, 8, 9, 3, -22 },
  { 25, 16, 22, 16, 1, -22 },
  { 69, 13, 26, 15, 1, -24 },
  { 112, 17, 22, 21, 2, -22 },
  { 159, 15, 22, 17, 1, -22 },
  { 201, 3, 8, 5, 3, -22 },
  { 204, 8, 27, 8, 1, -22 },
  { 231, 9, 27, 8, -2, -22 },
  { 262, 11, 11, 14, 4, -23 },
  { 278, 13, 14, 16, 2, -18 },
  { 301, 4, 7, 5, -1, -3 },
  { 305, 7, 1, 9, 1, -9 },
  { 306, 1, 2, 6, 1, -2 },
  { 307, 13, 22, 9, -1, -22 },
  { 343, 12, 22, 15, 2, -22 },
  { 376, 6, 22, 15, 5, -22 },
  { 393, 14, 22, 15, 0, -22 },
  { 432, 14, 22, 15, 0, -22 },
  { 471, 14, 22, 15, 0, -22 },
  { 510, 15, 22, 15, 0, -22 },
  { 552, 13, 22, 15, 2, -22 },
  { 588, 12, 22, 15, 3, -22 },
  { 621, 13, 22, 15, 1, -22 },
  { 657, 13, 22, 15, 1, -22 },
  { 693, 4, 16, 6, 1, -16 },
  { 701, 6, 20, 6, -1, -16 },
  { 716, 13, 14, 16, 2, -18 },
  { 739, 13, 8, 16, 2, -15 },
  { 752, 13, 14, 16, 2, -18 },
  { 775, 9, 22, 11, 2, -22 },
  { 800, 20, 25, 22, 1, -22 },
  { 863, 15, 22, 14, -2, -22 },
  { 905, 15, 22, 16, 1, -22 },
  { 947, 15, 22, 16, 2, -22 },
  { 989, 16, 22, 18, 1, -22 },
  { 1033, 14, 22, 14, 1, -22 },
  { 1072, 14, 22, 13, 1, -22 },
  { 1111, 16, 22, 19, 2, -22 },
  { 1155, 17, 22, 18, 1, -22 },
  { 1202, 10, 22, 7, -1, -22 },
  { 1230, 12, 27, 6, -5, -22 },
  { 1271, 16, 22, 15, 1, -22 },
  { 1315, 10, 22, 13, 1, -22 },
  { 1343, 22, 22, 23, 1, -22 },
  { 1404, 18, 22, 18, 1, -22 },
  { 1454, 16, 22, 19, 2, -22 },
  { 1498, 14, 22, 15, 1, -22 },
  { 1537, 16, 27, 19, 2, -22 },
  { 1591, 14, 22, 15, 1, -22 },
  { 1630, 14, 22, 14, 0, -22 },
  { 1669, 13, 22, 13, 3, -22 },
  { 1705, 17, 22, 18, 2, -22 },
  { 1752, 14, 22, 14, 3, -22 },
  { 1791, 22, 22, 23, 3, -22 },
  { 1852, 17, 22, 13, -2, -22 },
  { 1899, 13, 22, 13, 3, -22 },
  { 1935, 16, 22, 14, -1, -22 },
  { 1979, 11, 27, 9, 0, -22 },
  { 2017, 5, 22, 10, 3, -22 },
  { 2031, 11, 27, 9, -2, -22 },
  { 2069, 13, 12, 15, 1, -22 },
  { 2089, 11, 1, 10, -3, 3 },
  { 2091, 3, 5, 7, 5, -24 },
  { 2093, 13, 17, 15, 1, -17 },
  { 2121, 13, 24, 15, 1, -24 },
  { 2160, 11, 17, 12, 1, -17 },
  { 2184, 15, 24, 15, 1, -24 },
  { 2229, 11, 17, 13, 2, -17 },
  { 2253, 16, 31, 7, -4, -24 },
  { 2315, 15, 24, 15, 0, -17 },
  { 2360, 12, 24, 15, 1, -24 },
  { 2396, 5, 22, 6, 1, -22 },
  { 2410, 10, 29, 6, -4, -22 },
  { 2447, 12, 24, 12, 1, -24 },
  { 2483, 5, 24, 6, 1, -24 },
  { 2498, 20, 17, 23, 1, -17 },
  { 2541, 12, 17, 15, 1, -17 },
  { 2567, 13, 17, 15, 1, -17 },
  { 2595, 15, 24, 15, -1, -17 },
  { 2640, 14, 24, 15, 1, -17 },
  { 2682, 10, 17, 10, 1, -17 },
  { 2704, 11, 17, 11, 0, -17 },
  { 2728, 8, 20, 8, 1, -20 },
  { 2748, 13, 16, 15, 1, -16 },
  { 2774, 11, 16, 11, 2, -16 },
  { 2796, 17, 16, 18, 2, -16 },
  { 2830, 14, 16, 12, -1, -16 },
  { 2858, 17, 24, 11, -4, -16 },
  { 2909, 13, 16, 11, -1, -16 },
  { 2935, 11, 27, 10, 1, -22 },
  { 2973, 1, 32, 14, 7, -24 },
  { 2977, 11, 27, 10, -2, -22 },
  { 3015, 13, 2, 16, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC31PT7B_H_
