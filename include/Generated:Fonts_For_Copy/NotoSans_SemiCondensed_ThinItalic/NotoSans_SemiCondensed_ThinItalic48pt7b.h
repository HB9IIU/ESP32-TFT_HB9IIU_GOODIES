#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0xE0, 0x60, 0x00, 0x30, 0x48, 0x32, 0x08, 0x82, 0x20, 0x98, 0x24,
  0x11, 0x04, 0x41, 0x10, 0x48, 0x12, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x10, 0x00,
  0x10, 0x18, 0x07, 0xFF, 0xFF, 0xE0, 0x08, 0x04, 0x00, 0x04, 0x06, 0x00,
  0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00, 0x30, 0x10,
  0x00, 0x10, 0x08, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x04, 0x00, 0x04, 0x02,
  0x00, 0x02, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x00, 0x10,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0x62, 0x0C, 0x0C, 0x10,
  0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x18, 0x60, 0x00, 0x62, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x02,
  0x60, 0x00, 0x11, 0x80, 0x00, 0x86, 0x00, 0x04, 0x10, 0x00, 0x40, 0xC0,
  0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40,
  0xC0, 0x02, 0x0C, 0x10, 0x10, 0xC0, 0xFC, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x40, 0xEE, 0x00, 0x10, 0x30, 0x40, 0x04, 0x04,
  0x0C, 0x01, 0x81, 0x01, 0x80, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x03,
  0x01, 0x00, 0xC0, 0x40, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x00,
  0x40, 0x80, 0x20, 0x08, 0x30, 0x04, 0x01, 0x04, 0x00, 0x80, 0x61, 0x00,
  0x30, 0x08, 0x61, 0xE6, 0x01, 0x08, 0xC6, 0xC0, 0x62, 0x30, 0x48, 0x08,
  0xC4, 0x0D, 0x03, 0x11, 0x80, 0xB0, 0xC4, 0x20, 0x13, 0xF1, 0x8C, 0x02,
  0x38, 0x21, 0x00, 0x40, 0x08, 0x20, 0x18, 0x03, 0x0C, 0x03, 0x00, 0x41,
  0x00, 0x40, 0x18, 0x20, 0x08, 0x06, 0x04, 0x01, 0x00, 0x80, 0x80, 0x60,
  0x30, 0x10, 0x0C, 0x0C, 0x02, 0x01, 0x01, 0x00, 0x40, 0x60, 0x60, 0x08,
  0x08, 0x08, 0x01, 0x03, 0x02, 0x00, 0x30, 0xC0, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x20, 0x00, 0x80, 0x30, 0x00, 0x80, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x80, 0x40,
  0x00, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x4E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x10, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x08, 0x03, 0x10, 0x04, 0x02, 0x20, 0x06, 0x06,
  0x60, 0x02, 0x04, 0x40, 0x03, 0x0C, 0x40, 0x01, 0x08, 0xC0, 0x01, 0x90,
  0xC0, 0x00, 0xB0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xA0,
  0x40, 0x03, 0x20, 0x60, 0x06, 0x10, 0x30, 0x1C, 0x18, 0x1F, 0xF0, 0x08,
  0x32, 0x22, 0x26, 0x44, 0x44, 0x88, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x0C, 0x08, 0x03, 0x04, 0x00, 0x62, 0x00, 0x0D, 0x0F, 0x01, 0xF8,
  0x01, 0xC0, 0x01, 0xA0, 0x01, 0x08, 0x01, 0x04, 0x01, 0x01, 0x01, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x04, 0x30, 0x86, 0x10, 0x43, 0x08, 0x61, 0x08, 0x00, 0xFF, 0xFF,
  0xF0, 0x5F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xB8, 0x00, 0xC0, 0x40,
  0x18, 0x06, 0x03, 0x00, 0x20, 0x20, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00,
  0x12, 0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0xC0,
  0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x8C,
  0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0xC0,
  0x20, 0x18, 0x03, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x50, 0x64,
  0x33, 0x30, 0x98, 0x28, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x00, 0x30, 0x0C, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x01, 0xF7, 0x80, 0x1C, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x80, 0x03, 0x03, 0x80, 0x38, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x58, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x06,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x80, 0x04, 0x06, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x60, 0x02,
  0x03, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x01, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x10, 0x00,
  0xC0, 0xC0, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x79,
  0xC0, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC3, 0xF0, 0x04, 0x70,
  0xE0, 0x24, 0x01, 0x81, 0x40, 0x04, 0x14, 0x00, 0x30, 0xC0, 0x00, 0x86,
  0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00,
  0x46, 0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x81, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x30, 0x04, 0x00, 0xC0, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x0C,
  0x03, 0x00, 0x20, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0,
  0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20,
  0x30, 0x02, 0x00, 0x80, 0x20, 0x02, 0x06, 0x00, 0x08, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x63, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x40, 0x80, 0x03, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02,
  0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x60, 0x00, 0x61, 0x00,
  0x02, 0x0C, 0x00, 0x30, 0x20, 0x03, 0x00, 0xC0, 0x70, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xDE, 0x00, 0x30, 0x18, 0x02, 0x00, 0x40, 0x20,
  0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0x40, 0x00, 0x42, 0x00, 0x06, 0x18, 0x00, 0x30, 0x40, 0x02, 0x83,
  0x00, 0x2C, 0x0C, 0x06, 0x40, 0x3F, 0xE2, 0x00, 0x78, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x04, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x60, 0xC0, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xC0, 0x60, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x04, 0x60, 0x07,
  0xF8, 0x08, 0x80, 0x38, 0x10, 0x11, 0x00, 0xC0, 0x60, 0x24, 0x03, 0x00,
  0x80, 0x48, 0x04, 0x01, 0x00, 0xB0, 0x18, 0x02, 0x01, 0x40, 0x20, 0x0C,
  0x02, 0x80, 0x80, 0x10, 0x0D, 0x01, 0x00, 0x20, 0x16, 0x06, 0x00, 0x40,
  0x2C, 0x0C, 0x01, 0x80, 0x58, 0x10, 0x02, 0x01, 0xB0, 0x20, 0x0C, 0x02,
  0x40, 0x40, 0x18, 0x0C, 0x80, 0x80, 0x70, 0x11, 0x01, 0x80, 0xA0, 0x43,
  0x01, 0x02, 0x41, 0x86, 0x03, 0xB8, 0x7E, 0x0C, 0x01, 0xC0, 0x70, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x02,
  0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x81,
  0x80, 0x02, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x04, 0x00, 0x60, 0x08,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x1F, 0xFF, 0x80,
  0x20, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x30, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x01, 0xFF, 0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x80, 0x03,
  0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC3, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x20, 0x00, 0xC0, 0x80, 0x0C, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x40, 0x07, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00,
  0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x0C,
  0x00, 0x18, 0x20, 0x00, 0xC0, 0x80, 0x1C, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0x00, 0xF0, 0x03, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x02,
  0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10,
  0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40,
  0x01, 0xC0, 0xC0, 0x03, 0x00, 0x80, 0x0E, 0x00, 0x80, 0x78, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFE, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xE3,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x10, 0x03, 0x80, 0x1C,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x0C,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10,
  0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x08, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x00, 0x01,
  0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0x00, 0x03, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x03, 0x00, 0x20, 0x03, 0x00, 0x10, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x08, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x83, 0x00, 0x00, 0x43, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x1B, 0x60, 0x00, 0x0B, 0x10, 0x00, 0x07, 0x08,
  0x00, 0x02, 0x06, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xA0, 0x00,
  0x01, 0xC0, 0x50, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x00, 0xD0, 0x14, 0x00,
  0x00, 0x58, 0x1B, 0x00, 0x00, 0x6C, 0x09, 0x80, 0x00, 0x24, 0x04, 0x40,
  0x00, 0x22, 0x02, 0x20, 0x00, 0x31, 0x01, 0x10, 0x00, 0x11, 0x81, 0x88,
  0x00, 0x18, 0x80, 0x84, 0x00, 0x08, 0x40, 0x42, 0x00, 0x0C, 0x20, 0x21,
  0x80, 0x04, 0x10, 0x30, 0x40, 0x06, 0x18, 0x18, 0x20, 0x02, 0x08, 0x08,
  0x10, 0x02, 0x04, 0x04, 0x08, 0x03, 0x02, 0x02, 0x04, 0x01, 0x03, 0x03,
  0x02, 0x01, 0x81, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40,
  0x40, 0x20, 0x40, 0x20, 0x20, 0x10, 0x60, 0x30, 0x30, 0x08, 0x20, 0x10,
  0x10, 0x04, 0x20, 0x08, 0x08, 0x02, 0x10, 0x04, 0x04, 0x01, 0x10, 0x02,
  0x06, 0x00, 0xD8, 0x03, 0x03, 0x00, 0x68, 0x01, 0x01, 0x00, 0x1C, 0x00,
  0x80, 0x80, 0x0C, 0x00, 0x40, 0x40, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x08, 0x0A, 0x00, 0x01, 0x01, 0x40, 0x00, 0x20,
  0x2C, 0x00, 0x0C, 0x04, 0x80, 0x01, 0x81, 0x90, 0x00, 0x20, 0x23, 0x00,
  0x04, 0x04, 0x20, 0x00, 0x80, 0x84, 0x00, 0x30, 0x10, 0xC0, 0x04, 0x06,
  0x08, 0x00, 0x80, 0x81, 0x00, 0x10, 0x10, 0x30, 0x06, 0x02, 0x02, 0x00,
  0xC0, 0xC0, 0x40, 0x10, 0x18, 0x0C, 0x02, 0x02, 0x00, 0x80, 0x40, 0x40,
  0x10, 0x18, 0x08, 0x03, 0x03, 0x03, 0x00, 0x20, 0x40, 0x40, 0x04, 0x08,
  0x08, 0x00, 0xC1, 0x01, 0x00, 0x08, 0x60, 0x20, 0x01, 0x08, 0x0C, 0x00,
  0x31, 0x01, 0x00, 0x02, 0x20, 0x20, 0x00, 0x44, 0x04, 0x00, 0x0D, 0x81,
  0x80, 0x00, 0xA0, 0x30, 0x00, 0x14, 0x04, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x30, 0x10, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x7C, 0x00,
  0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18,
  0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x18, 0x07,
  0x00, 0xC0, 0x0C, 0x04, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x04, 0x18,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x18, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0xC3, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0x80, 0x1C, 0x07, 0xFF, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x38, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04, 0x18,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x44, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x18, 0x07, 0x00, 0xC0, 0x0C,
  0x04, 0x00, 0x30, 0x20, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x30,
  0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0x83, 0x00, 0x18, 0x18, 0x01,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x20, 0x10, 0x03, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x30,
  0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00,
  0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x84, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xF7, 0xE0, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x03, 0x00, 0x30, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x10, 0x00,
  0x10, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x06, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00, 0x10,
  0xC0, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00,
  0x60, 0x20, 0x02, 0x01, 0x00, 0x30, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x40, 0x06, 0x06, 0x00, 0x30, 0x20,
  0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00,
  0x05, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x2C, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x05,
  0x00, 0x04, 0xC0, 0x03, 0x40, 0x03, 0x30, 0x00, 0x90, 0x00, 0x8C, 0x00,
  0x64, 0x00, 0x23, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x04, 0x40, 0x04, 0x10,
  0x03, 0x10, 0x03, 0x04, 0x00, 0x84, 0x00, 0x81, 0x00, 0x61, 0x00, 0x60,
  0x40, 0x10, 0x40, 0x10, 0x10, 0x0C, 0x10, 0x04, 0x04, 0x02, 0x04, 0x02,
  0x01, 0x01, 0x81, 0x00, 0x80, 0x40, 0x40, 0x40, 0x60, 0x10, 0x10, 0x10,
  0x10, 0x04, 0x08, 0x04, 0x0C, 0x01, 0x02, 0x01, 0x02, 0x00, 0x41, 0x80,
  0x41, 0x80, 0x10, 0x40, 0x10, 0x40, 0x04, 0x30, 0x04, 0x10, 0x01, 0x08,
  0x01, 0x0C, 0x00, 0x46, 0x00, 0x62, 0x00, 0x11, 0x00, 0x19, 0x80, 0x04,
  0xC0, 0x06, 0x40, 0x01, 0x20, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x68, 0x00,
  0x16, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x60, 0x08, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x20, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00,
  0x46, 0x00, 0x0C, 0x60, 0x00, 0x82, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00,
  0x20, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x01, 0x80, 0x18,
  0x30, 0x01, 0x82, 0x00, 0x08, 0x60, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x00,
  0xD8, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x03, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x00, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x16, 0x00,
  0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x00, 0x18, 0x10,
  0x01, 0x01, 0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0x40, 0x0C, 0x0C, 0x00,
  0x40, 0x80, 0x04, 0x10, 0x00, 0x63, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00,
  0x03, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0x86, 0x10, 0xC2, 0x08, 0x61, 0x00,
  0x3C, 0x00, 0x1E, 0xF1, 0x03, 0x01, 0x10, 0x60, 0x0A, 0x0C, 0x00, 0xA0,
  0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x60, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x08, 0xC0, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x05, 0x0C, 0x00, 0x70, 0x40, 0x0A, 0x06, 0x01, 0x20, 0x30,
  0x62, 0x01, 0xFC, 0x20, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x83, 0xC0, 0x08, 0x77, 0x80,
  0x4C, 0x06, 0x02, 0xC0, 0x18, 0x14, 0x00, 0x41, 0xC0, 0x02, 0x0E, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x88,
  0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x01,
  0x88, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80,
  0x03, 0x0E, 0x00, 0x30, 0x50, 0x01, 0x02, 0xC0, 0x10, 0x33, 0x03, 0x01,
  0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x08, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0xF0, 0x60, 0x0F, 0x78, 0x80, 0x30, 0x19,
  0x00, 0xC0, 0x1A, 0x03, 0x00, 0x14, 0x0C, 0x00, 0x38, 0x10, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x00,
  0x01, 0x82, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0x60, 0x02, 0x80, 0x40, 0x0D, 0x00, 0xC0, 0x32,
  0x00, 0xC1, 0xCC, 0x00, 0xFE, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x7B, 0x80,
  0xC0, 0x60, 0xC0, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01,
  0x20, 0x01, 0x90, 0x01, 0x98, 0x01, 0x88, 0x03, 0x84, 0x7F, 0x03, 0xF0,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x0C,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF7, 0x8C,
  0x03, 0x01, 0x90, 0x0C, 0x01, 0xA0, 0x30, 0x01, 0x40, 0xC0, 0x02, 0x81,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x28, 0x04, 0x00, 0xD0,
  0x0C, 0x03, 0x20, 0x0C, 0x1C, 0xC0, 0x0F, 0xE1, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x0F, 0x00,
  0x63, 0xDC, 0x04, 0xC0, 0x60, 0x58, 0x02, 0x05, 0x00, 0x30, 0xE0, 0x01,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00,
  0x04, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x08, 0x60,
  0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x10, 0xC0, 0x01, 0x08,
  0x00, 0x30, 0x01, 0x81, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x40, 0x0C, 0x08, 0x03, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x0C, 0x01,
  0x03, 0x00, 0x20, 0xC0, 0x04, 0x30, 0x01, 0x8C, 0x00, 0x23, 0x00, 0x04,
  0xF0, 0x00, 0x92, 0x00, 0x34, 0x40, 0x05, 0x0C, 0x00, 0xC0, 0x80, 0x10,
  0x18, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x02, 0x00, 0x40, 0x40,
  0x08, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x03, 0x00, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x04, 0x7B, 0x83, 0xDC, 0x04, 0xC0,
  0xC6, 0x06, 0x05, 0x80, 0x4C, 0x03, 0x07, 0x00, 0x58, 0x03, 0x0E, 0x00,
  0x50, 0x01, 0x0C, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x60, 0x03, 0x08, 0x00,
  0x60, 0x03, 0x08, 0x00, 0x40, 0x02, 0x18, 0x00, 0x40, 0x02, 0x10, 0x00,
  0xC0, 0x02, 0x10, 0x00, 0x80, 0x06, 0x10, 0x00, 0x80, 0x04, 0x30, 0x00,
  0x80, 0x04, 0x30, 0x00, 0x80, 0x04, 0x20, 0x01, 0x80, 0x04, 0x20, 0x01,
  0x00, 0x0C, 0x20, 0x01, 0x00, 0x08, 0x60, 0x01, 0x00, 0x08, 0x40, 0x03,
  0x00, 0x08, 0x40, 0x03, 0x00, 0x18, 0x40, 0x02, 0x00, 0x18, 0x40, 0x02,
  0x00, 0x10, 0xC0, 0x02, 0x00, 0x10, 0x80, 0x06, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x43, 0xDC, 0x04, 0xC0, 0x60, 0x58, 0x02, 0x05, 0x00, 0x30, 0xE0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00, 0x43,
  0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x08,
  0x60, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x0C, 0x02, 0x03, 0x00,
  0x20, 0xC0, 0x06, 0x10, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02,
  0x60, 0x00, 0x4C, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x81, 0x00, 0x60,
  0x30, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x1D, 0xE0, 0x04,
  0x60, 0x60, 0x09, 0x00, 0x60, 0x14, 0x00, 0x40, 0x78, 0x00, 0x80, 0xA0,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01,
  0x06, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60,
  0xC0, 0x00, 0x81, 0x80, 0x03, 0x03, 0x80, 0x04, 0x05, 0x00, 0x10, 0x0B,
  0x00, 0x40, 0x33, 0x03, 0x00, 0x43, 0xFC, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x78, 0xC0, 0xC0, 0x64,
  0x0C, 0x01, 0xA0, 0xC0, 0x05, 0x0C, 0x00, 0x28, 0x40, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x07, 0x0C, 0x00, 0x70, 0x60,
  0x02, 0x81, 0x00, 0x34, 0x0C, 0x03, 0x20, 0x30, 0x73, 0x00, 0xFE, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x04, 0x3B, 0x04, 0xC0,
  0x05, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x78,
  0x01, 0xE7, 0xC1, 0x80, 0x21, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x31, 0x00,
  0x10, 0xC0, 0x30, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x17, 0xFE, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x07, 0xE0, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08,
  0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0x43,
  0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x08,
  0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0x40, 0x01,
  0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x70, 0x80, 0x0E, 0x0C, 0x00,
  0xA0, 0x40, 0x12, 0x06, 0x06, 0x20, 0x3F, 0xC6, 0x00, 0x80, 0x01, 0xC0,
  0x01, 0xA0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21,
  0x80, 0x20, 0xC0, 0x10, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x0C,
  0x02, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x43, 0x00, 0x31, 0x00, 0x19,
  0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0A, 0x00, 0x70,
  0x02, 0x40, 0x0A, 0x00, 0x48, 0x03, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20,
  0x19, 0x00, 0xC4, 0x02, 0x20, 0x10, 0x80, 0x44, 0x06, 0x10, 0x10, 0x80,
  0x82, 0x02, 0x10, 0x10, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x04,
  0x04, 0x20, 0x20, 0x80, 0x84, 0x06, 0x20, 0x11, 0x80, 0xC4, 0x02, 0x20,
  0x19, 0x00, 0x4C, 0x03, 0x20, 0x09, 0x00, 0x6C, 0x01, 0x20, 0x05, 0x00,
  0x28, 0x00, 0xE0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x40, 0x10, 0x03,
  0x00, 0x60, 0x18, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x04, 0x10, 0x00,
  0x10, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x40, 0x01, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x10, 0x18, 0x00, 0x40, 0xC0, 0x01,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x18,
  0x00, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x20, 0x00,
  0x80, 0x10, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x08, 0x04, 0x00, 0x06, 0x04, 0x00, 0x03, 0x02, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x05, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x16,
  0x1C, 0x01, 0x80, 0x70, 0x68, 0x00, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 12, 14, 5, -34 },
  { 55, 25, 34, 25, 1, -34 },
  { 162, 21, 39, 23, 1, -36 },
  { 265, 27, 36, 32, 3, -35 },
  { 387, 24, 35, 26, 1, -35 },
  { 492, 4, 12, 8, 5, -34 },
  { 498, 14, 42, 12, 1, -34 },
  { 572, 13, 42, 12, -3, -34 },
  { 641, 17, 17, 22, 6, -36 },
  { 678, 20, 22, 24, 3, -28 },
  { 733, 6, 11, 8, -2, -5 },
  { 742, 10, 2, 14, 2, -14 },
  { 745, 3, 3, 9, 1, -3 },
  { 747, 20, 34, 14, -2, -34 },
  { 832, 20, 35, 23, 2, -35 },
  { 920, 10, 34, 23, 7, -34 },
  { 963, 21, 35, 23, 0, -35 },
  { 1055, 22, 35, 23, 0, -35 },
  { 1152, 22, 35, 23, 0, -35 },
  { 1249, 21, 34, 23, 1, -34 },
  { 1339, 21, 35, 23, 2, -35 },
  { 1431, 20, 34, 23, 4, -34 },
  { 1516, 21, 35, 23, 1, -35 },
  { 1608, 21, 35, 23, 1, -35 },
  { 1700, 7, 25, 9, 1, -25 },
  { 1722, 10, 31, 9, -2, -25 },
  { 1761, 20, 21, 24, 3, -28 },
  { 1814, 20, 12, 24, 3, -23 },
  { 1844, 20, 21, 24, 3, -28 },
  { 1897, 15, 35, 17, 3, -35 },
  { 1963, 31, 38, 34, 2, -34 },
  { 2111, 23, 34, 22, -3, -34 },
  { 2209, 22, 34, 25, 2, -34 },
  { 2303, 24, 35, 24, 3, -35 },
  { 2408, 24, 34, 28, 2, -34 },
  { 2510, 22, 34, 22, 2, -34 },
  { 2604, 22, 34, 20, 2, -34 },
  { 2698, 26, 35, 29, 3, -35 },
  { 2812, 27, 34, 28, 2, -34 },
  { 2927, 15, 34, 11, -1, -34 },
  { 2991, 18, 42, 10, -8, -34 },
  { 3086, 25, 34, 23, 2, -34 },
  { 3193, 14, 34, 20, 2, -34 },
  { 3253, 33, 34, 35, 2, -34 },
  { 3394, 27, 34, 29, 2, -34 },
  { 3509, 25, 35, 30, 3, -35 },
  { 3619, 21, 34, 23, 2, -34 },
  { 3709, 25, 43, 30, 3, -35 },
  { 3844, 21, 34, 23, 2, -34 },
  { 3934, 22, 35, 21, 0, -35 },
  { 4031, 20, 34, 20, 4, -34 },
  { 4116, 26, 34, 28, 3, -34 },
  { 4227, 21, 34, 22, 5, -34 },
  { 4317, 34, 34, 36, 5, -34 },
  { 4462, 27, 34, 20, -3, -34 },
  { 4577, 20, 34, 20, 4, -34 },
  { 4662, 25, 34, 22, -1, -34 },
  { 4769, 18, 42, 14, -1, -34 },
  { 4864, 7, 34, 15, 5, -34 },
  { 4894, 17, 42, 14, -3, -34 },
  { 4984, 20, 19, 24, 2, -34 },
  { 5032, 16, 1, 16, -4, 5 },
  { 5034, 5, 8, 10, 7, -37 },
  { 5039, 20, 26, 23, 2, -26 },
  { 5104, 21, 36, 24, 1, -36 },
  { 5199, 17, 26, 18, 2, -26 },
  { 5255, 23, 36, 24, 2, -36 },
  { 5359, 17, 26, 21, 2, -26 },
  { 5415, 24, 49, 11, -6, -37 },
  { 5562, 23, 38, 24, 0, -26 },
  { 5672, 20, 36, 23, 1, -36 },
  { 5762, 9, 34, 9, 1, -34 },
  { 5801, 17, 46, 9, -7, -34 },
  { 5899, 19, 36, 19, 1, -36 },
  { 5985, 9, 36, 9, 1, -36 },
  { 6026, 32, 26, 35, 1, -26 },
  { 6130, 20, 26, 23, 1, -26 },
  { 6195, 19, 26, 23, 2, -26 },
  { 6257, 23, 37, 24, -1, -26 },
  { 6364, 21, 37, 24, 2, -26 },
  { 6462, 16, 26, 15, 1, -26 },
  { 6514, 17, 26, 18, 0, -26 },
  { 6570, 12, 32, 13, 2, -32 },
  { 6618, 20, 25, 23, 2, -25 },
  { 6681, 17, 25, 17, 3, -25 },
  { 6735, 27, 25, 28, 3, -25 },
  { 6820, 22, 25, 19, -2, -25 },
  { 6889, 25, 37, 18, -5, -25 },
  { 7005, 19, 25, 17, -1, -25 },
  { 7065, 17, 42, 15, 1, -34 },
  { 7155, 2, 48, 22, 11, -36 },
  { 7167, 17, 42, 15, -3, -34 },
  { 7257, 20, 4, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC48PT7B_H_
