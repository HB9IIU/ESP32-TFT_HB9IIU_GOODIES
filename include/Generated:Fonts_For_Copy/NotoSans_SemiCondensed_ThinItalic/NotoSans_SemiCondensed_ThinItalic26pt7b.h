#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x00, 0x04,
  0x20, 0x4A, 0x63, 0x19, 0x4A, 0x40, 0x02, 0x10, 0x10, 0x81, 0x08, 0x08,
  0x40, 0x42, 0x02, 0x21, 0xFF, 0xE1, 0x08, 0x08, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x0F, 0xFE, 0x10, 0x80, 0x84, 0x04, 0x40, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x01, 0x00, 0x20, 0x1E, 0x04, 0xB1, 0x20, 0x44, 0x08, 0x81, 0x10,
  0x24, 0x02, 0x80, 0x30, 0x03, 0x80, 0x48, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x91, 0x61, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1C, 0x04, 0x90, 0x24,
  0x21, 0x10, 0x84, 0x82, 0x22, 0x11, 0x08, 0x44, 0x21, 0x20, 0x85, 0x3E,
  0x25, 0x18, 0xA4, 0x5D, 0x21, 0x04, 0x84, 0x22, 0x11, 0x10, 0x44, 0x41,
  0x21, 0x08, 0x82, 0x24, 0x0F, 0x00, 0x03, 0x80, 0xC4, 0x08, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x08, 0x80, 0x90, 0x06, 0x01, 0xC0, 0x22, 0x04, 0x21,
  0x81, 0x18, 0x12, 0x80, 0xA8, 0x0C, 0x80, 0xC8, 0x14, 0x7E, 0x20, 0x5A,
  0xA8, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x30, 0x00, 0x04, 0x02, 0x21, 0x0D, 0x01,
  0xB8, 0x60, 0x50, 0xC8, 0x42, 0x01, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x24, 0xA5,
  0x00, 0xFC, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x07, 0x81, 0x08, 0x40, 0x88, 0x12,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x01, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x24, 0x04, 0x81, 0x08, 0x40, 0xF0, 0x00, 0x08, 0xCB, 0x90,
  0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x03, 0x80, 0xC2,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xFF, 0x80, 0x03, 0xC1, 0xC2, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0xC0, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0xFF, 0x00, 0x00, 0x10, 0x02, 0x00, 0x60,
  0x0A, 0x01, 0x20, 0x12, 0x02, 0x20, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x07, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x1F, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0xFF, 0x00, 0x01, 0xE0, 0xC0, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x30, 0x59, 0x8C, 0x09, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x7F, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x07,
  0x81, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x44, 0x10, 0x84, 0x09, 0x01,
  0xC0, 0xC4, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x21,
  0xF8, 0x00, 0x07, 0x81, 0x08, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x68, 0x08, 0x87, 0x0F, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x83, 0xE0, 0x00, 0x24, 0x00, 0x00, 0x00, 0x09, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x21, 0x04, 0x10, 0x80,
  0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00,
  0x1E, 0x10, 0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0xFC,
  0x02, 0x01, 0x82, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x07, 0xC5, 0x04,
  0x22, 0x84, 0x21, 0x44, 0x10, 0xC2, 0x08, 0x62, 0x08, 0x51, 0x04, 0x28,
  0x82, 0x14, 0x43, 0x12, 0x1E, 0x71, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x14, 0x01,
  0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21, 0xFE, 0x10,
  0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x10, 0x0F, 0x01,
  0x06, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0xC3,
  0xF8, 0x20, 0x44, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x48,
  0x18, 0xFE, 0x00, 0x03, 0xE0, 0x41, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x80, 0x0E, 0x80, 0x83, 0x04,
  0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x90, 0x04, 0x80, 0xC4,
  0x08, 0x3F, 0x80, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x00, 0x0F, 0xF1, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x5F,
  0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x03, 0xF0, 0x20, 0x46, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7D, 0x00, 0x28, 0x01, 0x40, 0x12,
  0x00, 0x90, 0x04, 0x80, 0x22, 0x01, 0x0F, 0xF0, 0x08, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08,
  0xFF, 0xE4, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x88, 0x02, 0x00, 0x1E, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x83, 0xC0, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x03, 0x80, 0x08, 0x08, 0x80, 0x84, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x28, 0x01, 0xA0, 0x09, 0x00, 0x84,
  0x04, 0x20, 0x20, 0x81, 0x04, 0x10, 0x20, 0x80, 0x84, 0x04, 0x20, 0x10,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x08, 0x00, 0x42, 0x00, 0x31,
  0x80, 0x08, 0x60, 0x06, 0x18, 0x02, 0x85, 0x00, 0xA2, 0x40, 0x48, 0x90,
  0x12, 0x24, 0x09, 0x09, 0x02, 0x44, 0x41, 0x11, 0x10, 0x44, 0x42, 0x21,
  0x10, 0x90, 0x84, 0x24, 0x22, 0x0A, 0x08, 0x82, 0x82, 0x20, 0xC1, 0x08,
  0x30, 0x40, 0x08, 0x02, 0x10, 0x08, 0x60, 0x10, 0xA0, 0x21, 0x40, 0x42,
  0x80, 0x88, 0x82, 0x11, 0x04, 0x22, 0x08, 0x42, 0x11, 0x04, 0x22, 0x08,
  0x84, 0x09, 0x08, 0x12, 0x10, 0x24, 0x40, 0x28, 0x80, 0x61, 0x00, 0xC2,
  0x00, 0x80, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0, 0x0F, 0x81, 0x04,
  0x10, 0x21, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x04,
  0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x04, 0x80, 0x42, 0x04, 0x0E, 0xC0, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x0E, 0x81, 0x04, 0x10, 0x21, 0x01, 0x10, 0x11,
  0x01, 0x20, 0x12, 0x02, 0x20, 0x42, 0x08, 0x3F, 0x04, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x80, 0x03, 0xE0, 0xC1,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18,
  0xFE, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x42, 0x02,
  0x07, 0xF0, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x24, 0x02,
  0x80, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08,
  0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x11, 0x08,
  0x84, 0x42, 0x22, 0x11, 0x08, 0x84, 0x42, 0x21, 0x20, 0x90, 0x48, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x00, 0x04, 0x02, 0x08, 0x08, 0x10, 0x20, 0x10, 0x40, 0x21, 0x00, 0x44,
  0x00, 0x48, 0x00, 0xA0, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x14, 0x00,
  0x48, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x20, 0x20, 0x80, 0x43, 0x00,
  0x80, 0x80, 0x30, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x08, 0x81, 0x10,
  0x24, 0x05, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x03, 0xE0, 0x92, 0x49, 0x22, 0x49, 0x24, 0x49, 0x24, 0x80,
  0x07, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x0F, 0x80, 0x01, 0x00, 0x60, 0x14, 0x02, 0x40, 0x88,
  0x21, 0x04, 0x11, 0x02, 0x40, 0x48, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x91,
  0x30, 0x0F, 0x22, 0x14, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02,
  0x80, 0x90, 0x12, 0x02, 0x40, 0xC4, 0x28, 0xFA, 0x00, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x09, 0xE1, 0x42, 0x30, 0x24, 0x04, 0x80,
  0xA0, 0x14, 0x02, 0x80, 0x50, 0x14, 0x02, 0x80, 0x90, 0x13, 0x04, 0x5F,
  0x00, 0x0F, 0x88, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x3E, 0x82, 0x0C, 0x20, 0x61, 0x01, 0x10, 0x10, 0x80,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x0C, 0x10, 0xA0,
  0xF9, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x0A, 0x39, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x04, 0x01, 0xF8, 0x00, 0x78, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x07, 0x00,
  0x00, 0x07, 0xD0, 0x83, 0x10, 0x31, 0x01, 0x20, 0x22, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x0C, 0x21, 0x43, 0xE4, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x0F, 0xE0, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x78, 0xA1, 0x30, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50,
  0x14, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x11, 0x00, 0x02, 0x22,
  0x24, 0x44, 0x44, 0x88, 0x88, 0x80, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0xF0, 0x00, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x04, 0x82, 0x21, 0x08, 0x84,
  0x41, 0x20, 0x58, 0x1A, 0x04, 0x42, 0x10, 0x84, 0x20, 0x88, 0x22, 0x0C,
  0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x88, 0x27, 0x8F,
  0x14, 0x48, 0x4C, 0x18, 0x24, 0x08, 0x12, 0x04, 0x0A, 0x04, 0x05, 0x02,
  0x04, 0x81, 0x02, 0x40, 0x81, 0x40, 0x40, 0xA0, 0x40, 0x90, 0x20, 0x48,
  0x10, 0x24, 0x08, 0x10, 0x27, 0x8A, 0x13, 0x04, 0x81, 0x20, 0x50, 0x14,
  0x05, 0x01, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x40, 0x0F, 0x82,
  0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x0A,
  0x02, 0x40, 0x44, 0x10, 0x7C, 0x00, 0x09, 0xE0, 0x50, 0x83, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x08,
  0x40, 0x43, 0x04, 0x17, 0xC1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x0F, 0xA2, 0x0C, 0x81, 0x90, 0x14, 0x04, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0xC4, 0x28, 0xF9, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x27, 0x28, 0x30, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x98, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x27,
  0xE0, 0x10, 0x42, 0x1F, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x20, 0xF0, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x30, 0xFA, 0x00, 0x80, 0x60,
  0x28, 0x09, 0x04, 0x41, 0x10, 0x84, 0x41, 0x10, 0x48, 0x12, 0x05, 0x01,
  0x40, 0x20, 0x08, 0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x18, 0x28,
  0x48, 0x90, 0x91, 0x12, 0x24, 0x24, 0x48, 0x50, 0x90, 0xA1, 0x41, 0x82,
  0x83, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x00, 0x10, 0x11, 0x02, 0x08, 0x40,
  0x88, 0x04, 0x80, 0x50, 0x06, 0x00, 0x60, 0x0A, 0x01, 0x10, 0x11, 0x02,
  0x10, 0x40, 0x88, 0x08, 0x08, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x04,
  0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x28, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x38, 0x00, 0x0F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFE, 0x00, 0x01,
  0x83, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x18,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x00, 0x80, 0x70, 0x20, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x03, 0x00, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 5, 1, -19 },
  { 13, 5, 7, 8, 3, -19 },
  { 18, 13, 19, 14, 1, -19 },
  { 49, 11, 22, 12, 1, -20 },
  { 80, 14, 19, 18, 2, -19 },
  { 114, 12, 19, 14, 1, -19 },
  { 143, 2, 7, 4, 3, -19 },
  { 145, 7, 23, 6, 1, -19 },
  { 166, 7, 23, 6, -2, -19 },
  { 187, 9, 10, 12, 3, -20 },
  { 199, 10, 12, 13, 2, -15 },
  { 214, 3, 6, 5, -1, -3 },
  { 217, 6, 1, 8, 1, -8 },
  { 218, 1, 2, 5, 1, -2 },
  { 219, 11, 19, 8, -1, -19 },
  { 246, 11, 19, 12, 1, -19 },
  { 273, 5, 19, 12, 4, -19 },
  { 285, 12, 19, 12, 0, -19 },
  { 314, 12, 19, 12, 0, -19 },
  { 343, 12, 19, 12, 0, -19 },
  { 372, 12, 19, 12, 0, -19 },
  { 401, 11, 19, 12, 1, -19 },
  { 428, 11, 19, 12, 2, -19 },
  { 455, 11, 19, 12, 1, -19 },
  { 482, 11, 19, 12, 1, -19 },
  { 509, 3, 14, 5, 1, -14 },
  { 515, 6, 17, 5, -1, -14 },
  { 528, 10, 11, 13, 2, -15 },
  { 542, 10, 6, 13, 2, -12 },
  { 550, 10, 11, 13, 2, -15 },
  { 564, 9, 19, 9, 1, -19 },
  { 586, 17, 20, 19, 1, -18 },
  { 629, 12, 19, 12, -1, -19 },
  { 658, 12, 19, 13, 1, -19 },
  { 687, 12, 19, 13, 2, -19 },
  { 716, 13, 19, 15, 1, -19 },
  { 747, 12, 19, 12, 1, -19 },
  { 776, 12, 19, 11, 1, -19 },
  { 805, 13, 19, 16, 2, -19 },
  { 836, 14, 19, 15, 1, -19 },
  { 870, 7, 19, 6, 0, -19 },
  { 887, 10, 24, 5, -4, -19 },
  { 917, 13, 19, 12, 1, -19 },
  { 948, 8, 19, 11, 1, -19 },
  { 967, 18, 19, 19, 1, -19 },
  { 1010, 15, 19, 16, 1, -19 },
  { 1046, 13, 19, 16, 2, -19 },
  { 1077, 12, 19, 13, 1, -19 },
  { 1106, 13, 23, 16, 2, -19 },
  { 1144, 12, 19, 13, 1, -19 },
  { 1173, 12, 19, 11, 0, -19 },
  { 1202, 11, 19, 11, 2, -19 },
  { 1229, 14, 19, 15, 2, -19 },
  { 1263, 11, 19, 12, 3, -19 },
  { 1290, 18, 19, 19, 3, -19 },
  { 1333, 15, 19, 11, -2, -19 },
  { 1369, 11, 19, 11, 2, -19 },
  { 1396, 14, 19, 12, -1, -19 },
  { 1430, 9, 23, 8, 0, -19 },
  { 1456, 3, 19, 8, 3, -19 },
  { 1464, 10, 23, 8, -2, -19 },
  { 1493, 11, 11, 13, 1, -19 },
  { 1509, 9, 1, 9, -2, 2 },
  { 1511, 3, 4, 6, 4, -20 },
  { 1513, 11, 14, 13, 1, -14 },
  { 1533, 11, 20, 13, 1, -20 },
  { 1561, 9, 14, 10, 1, -14 },
  { 1577, 13, 20, 13, 1, -20 },
  { 1610, 9, 14, 11, 1, -14 },
  { 1626, 13, 26, 6, -3, -20 },
  { 1669, 12, 20, 13, 0, -14 },
  { 1699, 10, 20, 13, 1, -20 },
  { 1724, 4, 19, 5, 1, -19 },
  { 1734, 9, 25, 5, -4, -19 },
  { 1763, 10, 20, 10, 1, -20 },
  { 1788, 4, 20, 5, 1, -20 },
  { 1798, 17, 14, 19, 1, -14 },
  { 1828, 10, 14, 13, 1, -14 },
  { 1846, 11, 14, 13, 1, -14 },
  { 1866, 13, 20, 13, -1, -14 },
  { 1899, 11, 20, 13, 1, -14 },
  { 1927, 8, 14, 8, 1, -14 },
  { 1941, 9, 14, 10, 0, -14 },
  { 1957, 6, 17, 7, 1, -17 },
  { 1970, 11, 14, 13, 1, -14 },
  { 1990, 10, 14, 9, 1, -14 },
  { 2008, 15, 14, 15, 1, -14 },
  { 2035, 12, 14, 10, -1, -14 },
  { 2056, 14, 20, 10, -3, -14 },
  { 2091, 11, 14, 9, -1, -14 },
  { 2111, 9, 23, 8, 1, -19 },
  { 2137, 1, 26, 12, 6, -20 },
  { 2141, 9, 23, 8, -1, -19 },
  { 2167, 10, 2, 13, 2, -10 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC26PT7B_H_
