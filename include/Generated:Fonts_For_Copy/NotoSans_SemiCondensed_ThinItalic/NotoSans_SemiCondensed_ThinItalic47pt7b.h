#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0xE0, 0x60, 0x00, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x60, 0x90, 0x64,
  0x11, 0x04, 0x41, 0x10, 0x48, 0x22, 0x08, 0x82, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x08, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x1F, 0xFF, 0xFF, 0x00, 0x40, 0x40,
  0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x00, 0x02, 0x01, 0x00,
  0x02, 0x01, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x02, 0x00, 0x04, 0x02, 0x00,
  0x04, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x01, 0xF8, 0x00, 0x7A, 0xFC, 0x06, 0x10, 0x40, 0x60, 0x80,
  0x06, 0x04, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0,
  0x80, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00, 0xC2, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x02, 0xC0, 0x00, 0x11,
  0x00, 0x00, 0x84, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00,
  0x10, 0x20, 0x00, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80, 0x02, 0x0C,
  0x10, 0x10, 0xC0, 0xFD, 0xB8, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x81, 0x8C, 0x00, 0x40, 0xC1, 0x00, 0x30, 0x60, 0x40, 0x08, 0x10,
  0x10, 0x04, 0x0C, 0x04, 0x03, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x10, 0x30, 0x10, 0x04, 0x08, 0x04, 0x01, 0x04, 0x01, 0x00, 0xC3,
  0x00, 0x40, 0x20, 0x80, 0x30, 0x08, 0x60, 0x0C, 0x02, 0x31, 0xFB, 0x01,
  0x88, 0xC3, 0xC0, 0x46, 0x60, 0x50, 0x31, 0x10, 0x14, 0x18, 0x8C, 0x05,
  0x8C, 0x62, 0x01, 0x3E, 0x10, 0x80, 0x40, 0x08, 0x60, 0x10, 0x06, 0x10,
  0x04, 0x01, 0x04, 0x01, 0x00, 0x81, 0x00, 0xC0, 0x60, 0xC0, 0x20, 0x10,
  0x30, 0x08, 0x08, 0x0C, 0x02, 0x06, 0x02, 0x01, 0x81, 0x00, 0x80, 0x40,
  0x80, 0x30, 0x30, 0x60, 0x04, 0x08, 0x10, 0x01, 0x04, 0x0C, 0x00, 0x3E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x61, 0x80, 0x01, 0x81,
  0x80, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00, 0x30, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x60, 0x02, 0x00, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x16, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x20, 0x00, 0x18, 0x40, 0x00, 0x60,
  0x40, 0x11, 0x00, 0xC0, 0x66, 0x00, 0x80, 0x98, 0x01, 0x81, 0x20, 0x01,
  0x04, 0x40, 0x03, 0x19, 0x80, 0x02, 0x22, 0x00, 0x06, 0x84, 0x00, 0x07,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x10, 0x00, 0xC8, 0x30, 0x03, 0x18,
  0x30, 0x1C, 0x10, 0x3F, 0xE0, 0x30, 0x32, 0x22, 0x64, 0x44, 0x44, 0x88,
  0x80, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x80,
  0x80, 0xC0, 0x80, 0x30, 0x80, 0x0D, 0x00, 0x03, 0x3F, 0x01, 0xC0, 0x02,
  0x80, 0x0C, 0x80, 0x18, 0x40, 0x30, 0x40, 0x60, 0x20, 0x40, 0x20, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x03, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x0C, 0x30, 0x86, 0x10, 0x43, 0x08, 0x41, 0x08, 0x00,
  0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x18, 0x01, 0x80,
  0x40, 0x30, 0x06, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x02, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x24,
  0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x0C,
  0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x01,
  0x0C, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x02, 0x01,
  0x80, 0x30, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x70, 0x3C, 0x32, 0x18,
  0x88, 0x2C, 0x1A, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC1,
  0x80, 0x18, 0x01, 0x00, 0x80, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x20, 0x00, 0xC0, 0xE0,
  0x0E, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0x40,
  0x00, 0x46, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x60,
  0xC0, 0x02, 0x06, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x30, 0x08, 0x01,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x20, 0x18, 0x01, 0x01, 0x80, 0x08,
  0x08, 0x00, 0xC0, 0x80, 0x04, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x2F, 0xE0, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x10, 0x00, 0x80, 0xC0,
  0x18, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC1, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x03, 0x00, 0x21, 0xFE, 0x02, 0x60, 0x30, 0x28, 0x01, 0x85,
  0x00, 0x08, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x44, 0x00, 0x04,
  0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x30, 0x60, 0x06, 0x02, 0x00,
  0xC0, 0x18, 0x18, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x06, 0x00, 0x60, 0x08, 0x02,
  0x00, 0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x01,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x40, 0x30,
  0x04, 0x00, 0xC0, 0x40, 0x03, 0x0C, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x60, 0x01, 0xC1, 0x80, 0x18, 0x06, 0x01, 0x00, 0x18, 0x10, 0x00,
  0x41, 0x80, 0x03, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x04,
  0x04, 0x00, 0x60, 0x18, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x0E, 0x1C, 0x01, 0x80, 0x60, 0x30, 0x02, 0x06, 0x00, 0x30, 0x40, 0x01,
  0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x18, 0x00, 0x70, 0x80, 0x0A, 0x0C, 0x01, 0x20, 0x70, 0xE2, 0x01,
  0xF8, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x80, 0x60, 0x0F, 0xF8, 0x00, 0x06, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x60, 0xC0, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xE0, 0xE0, 0xC2, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x04, 0x10, 0x01, 0xF0, 0x08, 0x40, 0x0C, 0x38, 0x10, 0x80, 0x60, 0x20,
  0x33, 0x01, 0x80, 0x40, 0x64, 0x02, 0x00, 0x80, 0x98, 0x08, 0x03, 0x01,
  0x30, 0x30, 0x04, 0x02, 0x40, 0x40, 0x08, 0x04, 0x80, 0x80, 0x30, 0x0B,
  0x03, 0x00, 0x40, 0x36, 0x04, 0x00, 0x80, 0x4C, 0x08, 0x01, 0x00, 0x90,
  0x10, 0x06, 0x03, 0x20, 0x20, 0x0C, 0x04, 0x40, 0x40, 0x38, 0x18, 0x80,
  0x80, 0xF0, 0x61, 0x01, 0x83, 0x21, 0x83, 0x01, 0x8C, 0x66, 0x06, 0x01,
  0xE0, 0x70, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x01, 0xFF, 0xF8,
  0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10,
  0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x04, 0x40, 0x00,
  0x13, 0x00, 0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x20, 0x03, 0x00, 0x80, 0x06, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0x83, 0x00, 0x06, 0x08, 0x00, 0x10,
  0x20, 0x00, 0xC0, 0x80, 0x0C, 0x06, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0x40,
  0x0E, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x02, 0x0C, 0x00,
  0x18, 0x20, 0x01, 0x80, 0x80, 0x1C, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x38, 0x1C, 0x01, 0x80, 0x08, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x70, 0x02, 0x00, 0x18,
  0x02, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x06, 0x00, 0x06, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x80, 0x0E, 0x00,
  0x80, 0x78, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x07, 0x80, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x30, 0x01,
  0xFF, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x60, 0x00, 0x04, 0x10,
  0x00, 0x06, 0x08, 0x00, 0x02, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x30, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x18,
  0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x08, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0x01, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60,
  0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x10, 0x18, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x01, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x83, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x01, 0x80, 0x10, 0x01, 0x80, 0x08,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x04, 0x01, 0x80, 0x02, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x41, 0x80, 0x00,
  0x21, 0x80, 0x00, 0x11, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x09, 0xA0, 0x00,
  0x05, 0x98, 0x00, 0x03, 0x84, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04,
  0x00, 0x18, 0x03, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x80, 0x01, 0x00, 0x40,
  0x00, 0xC0, 0x60, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0xFF, 0xFC, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x50, 0x00, 0x00, 0xA0, 0x28,
  0x00, 0x00, 0x70, 0x14, 0x00, 0x00, 0x50, 0x0A, 0x00, 0x00, 0x68, 0x0D,
  0x00, 0x00, 0x24, 0x04, 0x80, 0x00, 0x36, 0x02, 0x40, 0x00, 0x13, 0x01,
  0x30, 0x00, 0x19, 0x01, 0x88, 0x00, 0x08, 0x80, 0xC4, 0x00, 0x08, 0x40,
  0x42, 0x00, 0x04, 0x60, 0x21, 0x00, 0x04, 0x20, 0x10, 0x80, 0x06, 0x10,
  0x18, 0x40, 0x02, 0x08, 0x08, 0x30, 0x03, 0x04, 0x04, 0x18, 0x01, 0x06,
  0x02, 0x04, 0x01, 0x82, 0x01, 0x02, 0x00, 0x81, 0x01, 0x81, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x60,
  0x20, 0x10, 0x18, 0x20, 0x10, 0x18, 0x04, 0x30, 0x08, 0x08, 0x02, 0x10,
  0x0C, 0x04, 0x01, 0x18, 0x04, 0x02, 0x00, 0x88, 0x02, 0x03, 0x00, 0x48,
  0x01, 0x01, 0x80, 0x24, 0x00, 0x80, 0x80, 0x1C, 0x00, 0xC0, 0x40, 0x0E,
  0x00, 0x40, 0x60, 0x02, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x80, 0xA0, 0x00, 0x20, 0x14, 0x00, 0x04,
  0x02, 0x80, 0x00, 0x80, 0xC8, 0x00, 0x10, 0x11, 0x00, 0x06, 0x02, 0x30,
  0x00, 0x80, 0x42, 0x00, 0x10, 0x18, 0x40, 0x02, 0x03, 0x0C, 0x00, 0x40,
  0x40, 0x80, 0x18, 0x08, 0x10, 0x02, 0x01, 0x03, 0x00, 0x40, 0x60, 0x20,
  0x08, 0x0C, 0x04, 0x03, 0x01, 0x00, 0xC0, 0x60, 0x20, 0x08, 0x08, 0x04,
  0x01, 0x01, 0x01, 0x80, 0x30, 0x20, 0x20, 0x02, 0x0C, 0x04, 0x00, 0x41,
  0x00, 0x80, 0x0C, 0x20, 0x10, 0x00, 0x84, 0x06, 0x00, 0x10, 0x80, 0x80,
  0x03, 0x30, 0x10, 0x00, 0x24, 0x02, 0x00, 0x04, 0x80, 0xC0, 0x00, 0xD0,
  0x18, 0x00, 0x0A, 0x02, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x30, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01,
  0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0x40, 0x10,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x60, 0x20, 0x01, 0x01, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x80, 0x1C, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01,
  0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0x40, 0x10,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x60, 0x20, 0x01, 0x01, 0x00, 0x0C,
  0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x01, 0x83,
  0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x38, 0x07, 0xFE, 0x00, 0x20, 0x20,
  0x03, 0x01, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x20,
  0x60, 0x01, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x83, 0xC0, 0x60, 0x02, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0xC0, 0x0C, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20,
  0x00, 0x04, 0x10, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x20, 0x00, 0x08, 0x18, 0x00, 0x04,
  0x0C, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0x40, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0xC0, 0x02, 0x0C,
  0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x08, 0x04, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x40,
  0x04, 0x04, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x30,
  0x00, 0x68, 0x00, 0x38, 0x00, 0x24, 0x00, 0x14, 0x00, 0x12, 0x00, 0x1A,
  0x00, 0x11, 0x80, 0x09, 0x00, 0x08, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x04,
  0x60, 0x04, 0x30, 0x02, 0x30, 0x06, 0x18, 0x02, 0x18, 0x02, 0x0C, 0x01,
  0x0C, 0x03, 0x06, 0x01, 0x82, 0x01, 0x01, 0x00, 0x81, 0x00, 0x80, 0x80,
  0xC0, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x60, 0x20, 0x60, 0x10,
  0x20, 0x10, 0x20, 0x08, 0x10, 0x08, 0x30, 0x04, 0x10, 0x04, 0x10, 0x02,
  0x08, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x08, 0x00, 0x84, 0x00, 0x84, 0x00,
  0x46, 0x00, 0x46, 0x00, 0x22, 0x00, 0x22, 0x00, 0x13, 0x00, 0x13, 0x00,
  0x09, 0x00, 0x09, 0x00, 0x05, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x01, 0x40, 0x01, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00,
  0x20, 0x04, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x08,
  0x01, 0x80, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08, 0x00, 0x10, 0x03,
  0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x34,
  0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x10,
  0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x08,
  0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x82, 0x00, 0x18, 0x60, 0x00, 0x8C,
  0x00, 0x08, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x04, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x30, 0x01, 0x01, 0x00, 0x30, 0x10,
  0x02, 0x01, 0x80, 0x40, 0x08, 0x0C, 0x00, 0x80, 0x80, 0x0C, 0x18, 0x00,
  0x43, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF,
  0xFF, 0x86, 0x10, 0xC2, 0x08, 0x41, 0x00, 0xFE, 0x30, 0x38, 0x32, 0x06,
  0x01, 0x20, 0xC0, 0x0A, 0x08, 0x00, 0xA1, 0x00, 0x0C, 0x10, 0x00, 0xC2,
  0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08,
  0x40, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x60, 0xC0, 0x0E, 0x04, 0x01,
  0xA0, 0x60, 0x32, 0x03, 0x06, 0x20, 0x1F, 0xC4, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x41, 0xF8, 0x04, 0x60, 0xC0, 0x48, 0x06, 0x05, 0x00, 0x20, 0xF0,
  0x03, 0x0A, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18,
  0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x03, 0x30, 0x00, 0x32,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x0C,
  0x60, 0x00, 0x87, 0x00, 0x18, 0x50, 0x03, 0x05, 0x80, 0x60, 0x8C, 0x0C,
  0x08, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xC0, 0x41, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x10, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x3F, 0x84, 0x03, 0x83, 0x10, 0x18, 0x02, 0xC0,
  0xC0, 0x0A, 0x02, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00,
  0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x60, 0x80, 0x03, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x70, 0x30, 0x03,
  0x40, 0x40, 0x09, 0x01, 0x80, 0x48, 0x03, 0x06, 0x20, 0x07, 0xF0, 0x80,
  0x00, 0xFE, 0x00, 0xC1, 0x80, 0x80, 0x60, 0x80, 0x10, 0x80, 0x08, 0xC0,
  0x04, 0x40, 0x06, 0x40, 0x02, 0x20, 0x03, 0x30, 0x03, 0x10, 0x07, 0x08,
  0x1E, 0x07, 0xF8, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x10, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC4,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x84, 0x03, 0x83, 0x10, 0x18, 0x02, 0x40, 0xC0, 0x0B, 0x02, 0x00, 0x18,
  0x10, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0x80, 0x03, 0x82,
  0x00, 0x0C, 0x08, 0x00, 0x70, 0x30, 0x03, 0x40, 0x40, 0x0B, 0x01, 0x80,
  0x48, 0x03, 0x06, 0x20, 0x07, 0xF0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x20, 0x0E, 0x03, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x0F, 0xC0, 0x46, 0x0C, 0x09, 0x00, 0xC1, 0x40,
  0x08, 0x70, 0x01, 0x0E, 0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00,
  0x11, 0x80, 0x06, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0x46, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01,
  0x10, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x23, 0x00, 0x0C,
  0x40, 0x01, 0x80, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x30, 0x40,
  0x0C, 0x08, 0x03, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x0C, 0x01, 0x03,
  0x00, 0x20, 0xC0, 0x04, 0x30, 0x01, 0x8C, 0x00, 0x21, 0x00, 0x04, 0x60,
  0x00, 0x96, 0x00, 0x34, 0x40, 0x05, 0x08, 0x00, 0xC0, 0x80, 0x10, 0x10,
  0x02, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x08,
  0x08, 0x01, 0x03, 0x00, 0x10, 0x40, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x00, 0x04, 0x3F, 0x01, 0xF8, 0x09, 0x83, 0x0C, 0x18, 0x16, 0x03, 0x30,
  0x18, 0x28, 0x02, 0xC0, 0x10, 0xA0, 0x05, 0x00, 0x21, 0x80, 0x0C, 0x00,
  0x43, 0x00, 0x18, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00, 0x40, 0x06,
  0x30, 0x01, 0x80, 0x0C, 0x40, 0x02, 0x00, 0x10, 0x80, 0x04, 0x00, 0x21,
  0x00, 0x08, 0x00, 0x46, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x40, 0x02, 0x10,
  0x00, 0x80, 0x04, 0x20, 0x01, 0x00, 0x08, 0x40, 0x02, 0x00, 0x11, 0x80,
  0x0C, 0x00, 0x62, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00,
  0x40, 0x02, 0x10, 0x00, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x18, 0x80, 0x04,
  0x00, 0x20, 0x04, 0x3F, 0x80, 0x8C, 0x18, 0x12, 0x01, 0x82, 0x80, 0x10,
  0xE0, 0x02, 0x1C, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x23,
  0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x8C,
  0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20,
  0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x18, 0x80,
  0x02, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x70, 0x18, 0x02, 0x06, 0x00, 0x20,
  0x80, 0x04, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x2C,
  0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0,
  0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x06, 0x60,
  0x00, 0x84, 0x00, 0x30, 0x80, 0x0C, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0x07, 0xE0, 0x04, 0x60, 0xC0, 0x13, 0x01, 0x80, 0x58,
  0x02, 0x03, 0xC0, 0x0C, 0x0A, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x01,
  0x02, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00,
  0x18, 0x20, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x50, 0x03, 0x01, 0x40, 0x18, 0x0C, 0xC0, 0xC0, 0x21, 0xFE, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x10, 0x38, 0x31, 0x06, 0x00,
  0x90, 0xC0, 0x0B, 0x08, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00,
  0x06, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0xC0,
  0x00, 0xCC, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x88,
  0x00, 0x38, 0x80, 0x03, 0x08, 0x00, 0x70, 0xC0, 0x05, 0x04, 0x00, 0xB0,
  0x60, 0x12, 0x03, 0x06, 0x20, 0x1F, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x04,
  0x3F, 0x04, 0x60, 0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x01, 0xFE, 0x03, 0x81, 0xC3, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x61, 0x80, 0x60, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x1F, 0xF8, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x1F, 0x80, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x31,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0xC4,
  0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x03, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x18, 0x00, 0x62, 0x00, 0x18, 0x40,
  0x03, 0x08, 0x00, 0xA1, 0x00, 0x34, 0x30, 0x0C, 0x83, 0x03, 0x20, 0x3F,
  0x84, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x60, 0x18, 0x30, 0x08, 0x08,
  0x0C, 0x04, 0x04, 0x02, 0x06, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00,
  0x21, 0x80, 0x10, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x80, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x34, 0x01,
  0x20, 0x09, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC4,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x18, 0x20, 0x81, 0x04, 0x08, 0x20, 0x43, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x20, 0x22, 0x01, 0x90, 0x0C, 0x80, 0x64, 0x03, 0x40, 0x0A,
  0x00, 0xD0, 0x02, 0x80, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0x02, 0x00, 0x08, 0x18, 0x00, 0x80,
  0x40, 0x0C, 0x02, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x40, 0x40, 0x03, 0x04,
  0x00, 0x08, 0x60, 0x00, 0x46, 0x00, 0x03, 0x20, 0x00, 0x0A, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x60, 0x00, 0x11, 0x00,
  0x01, 0x08, 0x00, 0x18, 0x20, 0x01, 0x81, 0x00, 0x08, 0x0C, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80, 0x10, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x20, 0x00, 0x80,
  0x10, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08,
  0x0C, 0x00, 0x04, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x07, 0x01, 0x81, 0xC0,
  0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 13, 14, 5, -34 },
  { 57, 24, 34, 25, 1, -34 },
  { 159, 21, 39, 22, 1, -36 },
  { 262, 26, 35, 32, 3, -34 },
  { 376, 23, 34, 26, 1, -34 },
  { 474, 4, 13, 8, 5, -34 },
  { 481, 13, 41, 11, 1, -34 },
  { 548, 13, 41, 11, -3, -34 },
  { 615, 16, 17, 21, 6, -36 },
  { 649, 19, 21, 24, 3, -27 },
  { 699, 6, 11, 8, -2, -5 },
  { 708, 10, 1, 14, 2, -13 },
  { 710, 3, 3, 9, 1, -3 },
  { 712, 20, 34, 14, -2, -34 },
  { 797, 20, 34, 22, 2, -34 },
  { 882, 10, 34, 22, 7, -34 },
  { 925, 21, 34, 22, 0, -34 },
  { 1015, 22, 34, 22, 0, -34 },
  { 1109, 21, 34, 22, 0, -34 },
  { 1199, 21, 34, 22, 1, -34 },
  { 1289, 20, 34, 22, 2, -34 },
  { 1374, 19, 34, 22, 4, -34 },
  { 1455, 21, 34, 22, 1, -34 },
  { 1545, 20, 34, 22, 1, -34 },
  { 1630, 7, 25, 9, 1, -25 },
  { 1652, 10, 31, 9, -2, -25 },
  { 1691, 19, 20, 24, 3, -27 },
  { 1739, 19, 11, 24, 3, -22 },
  { 1766, 19, 20, 24, 3, -27 },
  { 1814, 14, 34, 16, 3, -34 },
  { 1874, 31, 37, 34, 2, -33 },
  { 2018, 22, 34, 22, -3, -34 },
  { 2112, 22, 34, 24, 2, -34 },
  { 2206, 23, 34, 24, 3, -34 },
  { 2304, 24, 34, 27, 2, -34 },
  { 2406, 22, 34, 22, 1, -34 },
  { 2500, 22, 34, 20, 1, -34 },
  { 2594, 25, 34, 28, 3, -34 },
  { 2701, 27, 34, 28, 1, -34 },
  { 2816, 14, 34, 11, -1, -34 },
  { 2876, 18, 42, 10, -8, -34 },
  { 2971, 25, 34, 22, 1, -34 },
  { 3078, 15, 34, 20, 1, -34 },
  { 3142, 33, 34, 34, 1, -34 },
  { 3283, 27, 34, 28, 1, -34 },
  { 3398, 24, 34, 29, 3, -34 },
  { 3500, 21, 34, 23, 2, -34 },
  { 3590, 24, 42, 29, 3, -34 },
  { 3716, 21, 34, 23, 2, -34 },
  { 3806, 21, 34, 21, 0, -34 },
  { 3896, 20, 34, 20, 4, -34 },
  { 3981, 25, 34, 28, 3, -34 },
  { 4088, 20, 34, 22, 5, -34 },
  { 4173, 33, 34, 35, 5, -34 },
  { 4314, 26, 34, 20, -3, -34 },
  { 4425, 20, 34, 19, 4, -34 },
  { 4510, 24, 34, 21, -1, -34 },
  { 4612, 18, 41, 14, -1, -34 },
  { 4705, 7, 34, 15, 5, -34 },
  { 4735, 17, 41, 14, -3, -34 },
  { 4823, 20, 19, 23, 2, -34 },
  { 4871, 16, 1, 16, -4, 5 },
  { 4873, 5, 8, 10, 7, -36 },
  { 4878, 20, 25, 23, 2, -25 },
  { 4941, 20, 36, 23, 1, -36 },
  { 5031, 17, 25, 18, 2, -25 },
  { 5085, 22, 36, 23, 2, -36 },
  { 5184, 17, 25, 20, 2, -25 },
  { 5238, 23, 47, 11, -6, -36 },
  { 5374, 22, 36, 23, 0, -25 },
  { 5473, 19, 36, 23, 1, -36 },
  { 5559, 9, 34, 9, 1, -34 },
  { 5598, 17, 45, 9, -7, -34 },
  { 5694, 19, 36, 18, 1, -36 },
  { 5780, 9, 36, 9, 1, -36 },
  { 5821, 31, 25, 34, 1, -25 },
  { 5918, 19, 25, 23, 1, -25 },
  { 5978, 19, 25, 23, 2, -25 },
  { 6038, 22, 36, 23, -1, -25 },
  { 6137, 20, 36, 23, 2, -25 },
  { 6227, 16, 25, 15, 1, -25 },
  { 6277, 17, 25, 17, 0, -25 },
  { 6331, 11, 31, 12, 2, -31 },
  { 6374, 19, 25, 23, 2, -25 },
  { 6434, 17, 25, 17, 2, -25 },
  { 6488, 26, 25, 27, 3, -25 },
  { 6570, 21, 25, 18, -2, -25 },
  { 6636, 25, 36, 17, -5, -25 },
  { 6749, 18, 25, 17, -1, -25 },
  { 6806, 17, 41, 15, 1, -34 },
  { 6894, 1, 47, 22, 11, -36 },
  { 6900, 17, 41, 15, -3, -34 },
  { 6988, 19, 4, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC47PT7B_H_
