#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x10, 0x6E, 0xD0, 0x12, 0x24, 0x53, 0xF2, 0x44,
  0xBF, 0xA4, 0x48, 0xA0, 0x08, 0x72, 0x92, 0x50, 0xC1, 0x85, 0x26, 0xA7,
  0x08, 0x72, 0x92, 0x94, 0x98, 0xAF, 0xF9, 0x29, 0x29, 0x4A, 0x8E, 0x1C,
  0x48, 0x91, 0x41, 0x0E, 0x22, 0xC5, 0x84, 0xF4, 0x5A, 0x12, 0x24, 0x48,
  0x88, 0x88, 0x84, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x21, 0x3E, 0x8A,
  0x00, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x56, 0xF0, 0x80, 0x04, 0x10, 0x82,
  0x10, 0x42, 0x10, 0x42, 0x00, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97, 0x00,
  0x3C, 0x94, 0x92, 0x50, 0x3C, 0x10, 0x41, 0x04, 0x21, 0x08, 0x43, 0xE0,
  0x3C, 0x10, 0x41, 0x38, 0x20, 0x41, 0x07, 0xE0, 0x04, 0x31, 0x45, 0x25,
  0x28, 0x9F, 0x08, 0x20, 0x3E, 0x40, 0x82, 0x07, 0x80, 0x81, 0x02, 0x09,
  0xE0, 0x3D, 0x04, 0x20, 0xFA, 0x28, 0xA2, 0x8B, 0xC0, 0x7C, 0x10, 0x84,
  0x10, 0x82, 0x10, 0x42, 0x00, 0x3C, 0x44, 0x89, 0x21, 0x8D, 0x21, 0x42,
  0x84, 0xF0, 0x3D, 0x14, 0x51, 0x45, 0xF0, 0x42, 0x0B, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x92, 0x80, 0x0C, 0xCC, 0x10, 0x30, 0x30, 0xFC, 0x00, 0x3F,
  0xC0, 0xC0, 0xC6, 0x62, 0x00, 0xF1, 0x11, 0x24, 0x88, 0x08, 0x1E, 0x10,
  0x90, 0x33, 0xDA, 0x4D, 0x26, 0x95, 0x52, 0x96, 0x40, 0x1F, 0x00, 0x04,
  0x18, 0x30, 0xA1, 0x27, 0xC8, 0xA1, 0x43, 0x04, 0x3E, 0x44, 0x89, 0x17,
  0xC8, 0x90, 0xA1, 0x85, 0xF0, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0xF0, 0x3C, 0x22, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x84, 0xF8,
  0x3E, 0x40, 0x81, 0x07, 0xC8, 0x10, 0x20, 0x81, 0xF0, 0x3E, 0x40, 0x81,
  0x04, 0x0F, 0x90, 0x20, 0x81, 0x00, 0x3E, 0x81, 0x04, 0x08, 0x11, 0xE0,
  0xC2, 0x84, 0xF8, 0x21, 0x21, 0x21, 0x21, 0x7D, 0x42, 0x42, 0x42, 0x82,
  0x82, 0x32, 0x22, 0x44, 0x44, 0x4C, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21,
  0x09, 0xC0, 0x23, 0x24, 0x28, 0x30, 0x70, 0x50, 0x48, 0x48, 0x88, 0x84,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x87, 0xC0, 0x20, 0x48, 0x12, 0x0C, 0xC5,
  0x51, 0x54, 0xA5, 0x29, 0x52, 0x88, 0xA2, 0x40, 0x21, 0x21, 0x31, 0x31,
  0x49, 0x49, 0x4A, 0x46, 0x86, 0x82, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x84, 0xF0, 0x3C, 0x44, 0x89, 0x14, 0x4F, 0x10, 0x20, 0x81, 0x00,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xD0, 0x40, 0xC0, 0x3C,
  0x44, 0x89, 0x14, 0x4F, 0x12, 0x24, 0x89, 0x08, 0x3D, 0x04, 0x10, 0x20,
  0x60, 0x81, 0x0B, 0xC0, 0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x00,
  0x42, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0xF0, 0x83, 0x0A, 0x14,
  0x48, 0x92, 0x14, 0x30, 0x40, 0x80, 0x88, 0xC4, 0x66, 0x35, 0x2A, 0x95,
  0x53, 0x29, 0x18, 0x84, 0x44, 0x00, 0x21, 0x12, 0x14, 0x14, 0x08, 0x18,
  0x28, 0x24, 0x44, 0x84, 0x86, 0x24, 0x94, 0x61, 0x04, 0x10, 0x41, 0x00,
  0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xF0, 0x39, 0x08, 0x84,
  0x21, 0x08, 0x84, 0x21, 0x80, 0xA9, 0x55, 0x50, 0x18, 0x42, 0x10, 0x88,
  0x42, 0x11, 0x09, 0xC0, 0x11, 0x92, 0x98, 0xC4, 0xF8, 0xA4, 0x32, 0x63,
  0x18, 0xC6, 0x5E, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x46, 0x1F, 0x80,
  0x3A, 0x21, 0x08, 0x42, 0x1E, 0x04, 0x10, 0x4D, 0x4A, 0x28, 0xA2, 0x8A,
  0x4F, 0x00, 0x32, 0x63, 0x2E, 0x42, 0x1E, 0x06, 0x10, 0x20, 0xE0, 0x82,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x18, 0x00, 0x1A, 0x49, 0x12, 0x28,
  0x50, 0xA2, 0x3C, 0x08, 0x13, 0xC0, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x51,
  0x46, 0x18, 0x80, 0x20, 0x24, 0x92, 0x90, 0x08, 0x00, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x4C, 0x00, 0x20, 0x82, 0x09, 0x49, 0x46, 0x14, 0x52, 0x48,
  0x80, 0x24, 0x94, 0x92, 0x52, 0x00, 0x19, 0x89, 0x94, 0x45, 0x11, 0x44,
  0x92, 0x28, 0x8A, 0x22, 0x18, 0x94, 0x51, 0x45, 0x18, 0x62, 0x32, 0x63,
  0x18, 0xC6, 0x3E, 0x18, 0x94, 0x51, 0x45, 0x18, 0x7E, 0x82, 0x08, 0x00,
  0x35, 0x28, 0xA2, 0x8A, 0x29, 0x3C, 0x10, 0x41, 0x00, 0x19, 0x10, 0x84,
  0x22, 0x10, 0x3A, 0x10, 0x82, 0x08, 0x5E, 0x4E, 0x49, 0x24, 0xC0, 0x8C,
  0x63, 0x18, 0xCB, 0xC0, 0x8C, 0xA9, 0x4C, 0x62, 0x00, 0x91, 0xB2, 0xB2,
  0xD4, 0xC8, 0x88, 0x88, 0x26, 0x28, 0x60, 0x82, 0x89, 0x32, 0x00, 0x11,
  0x12, 0x12, 0x14, 0x14, 0x08, 0x10, 0x10, 0x10, 0xE0, 0x78, 0x84, 0x44,
  0x43, 0xC0, 0x18, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC,
  0x10, 0x42, 0x21, 0x08, 0x62, 0x21, 0x09, 0x80, 0x66, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 1, -10 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 6, 12, 7, 0, -11 },
  { 25, 8, 10, 9, 1, -10 },
  { 35, 7, 10, 8, 0, -10 },
  { 44, 2, 4, 2, 1, -10 },
  { 45, 4, 12, 3, 0, -10 },
  { 51, 4, 12, 3, -1, -10 },
  { 57, 5, 5, 6, 2, -11 },
  { 61, 6, 6, 7, 1, -8 },
  { 66, 2, 4, 2, -1, -2 },
  { 67, 4, 1, 4, 0, -4 },
  { 68, 1, 1, 3, 0, -1 },
  { 69, 6, 10, 4, -1, -10 },
  { 77, 5, 10, 7, 1, -10 },
  { 84, 3, 10, 7, 2, -10 },
  { 88, 6, 10, 7, 0, -10 },
  { 96, 6, 10, 7, 0, -10 },
  { 104, 6, 10, 7, 0, -10 },
  { 112, 7, 10, 7, 0, -10 },
  { 121, 6, 10, 7, 1, -10 },
  { 129, 6, 10, 7, 1, -10 },
  { 137, 7, 10, 7, 0, -10 },
  { 146, 6, 10, 7, 0, -10 },
  { 154, 2, 7, 3, 0, -7 },
  { 156, 3, 9, 3, -1, -7 },
  { 160, 6, 6, 7, 1, -8 },
  { 165, 6, 4, 7, 1, -7 },
  { 168, 6, 6, 7, 1, -8 },
  { 173, 4, 10, 5, 1, -10 },
  { 178, 9, 11, 10, 1, -10 },
  { 191, 7, 10, 7, -1, -10 },
  { 200, 7, 10, 7, 0, -10 },
  { 209, 7, 10, 7, 1, -10 },
  { 218, 8, 10, 8, 0, -10 },
  { 228, 7, 10, 6, 0, -10 },
  { 237, 7, 10, 6, 0, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 8, 10, 8, 0, -10 },
  { 265, 4, 10, 3, 0, -10 },
  { 270, 5, 12, 3, -2, -10 },
  { 278, 8, 10, 7, 0, -10 },
  { 288, 5, 10, 6, 0, -10 },
  { 295, 10, 10, 10, 0, -10 },
  { 308, 8, 10, 8, 0, -10 },
  { 318, 7, 10, 9, 1, -10 },
  { 327, 7, 10, 7, 0, -10 },
  { 336, 7, 12, 9, 1, -10 },
  { 347, 7, 10, 7, 0, -10 },
  { 356, 6, 10, 6, 0, -10 },
  { 364, 6, 10, 6, 1, -10 },
  { 372, 7, 10, 8, 1, -10 },
  { 381, 7, 10, 7, 1, -10 },
  { 390, 9, 10, 10, 2, -10 },
  { 402, 8, 10, 6, -1, -10 },
  { 412, 6, 10, 6, 1, -10 },
  { 420, 7, 10, 6, 0, -10 },
  { 429, 5, 12, 4, 0, -10 },
  { 437, 2, 10, 4, 1, -10 },
  { 440, 5, 12, 4, -1, -10 },
  { 448, 5, 6, 7, 1, -10 },
  { 452, 5, 1, 5, -1, 1 },
  { 453, 2, 3, 3, 2, -11 },
  { 454, 5, 8, 7, 1, -8 },
  { 459, 6, 11, 7, 0, -11 },
  { 468, 5, 8, 5, 1, -8 },
  { 473, 6, 11, 7, 1, -11 },
  { 482, 5, 8, 6, 1, -8 },
  { 487, 7, 14, 3, -2, -11 },
  { 500, 7, 11, 7, 0, -8 },
  { 510, 6, 11, 7, 0, -11 },
  { 519, 3, 10, 3, 0, -10 },
  { 523, 5, 13, 3, -2, -10 },
  { 532, 6, 11, 5, 0, -11 },
  { 541, 3, 11, 3, 0, -11 },
  { 546, 10, 8, 10, 0, -8 },
  { 556, 6, 8, 7, 0, -8 },
  { 562, 5, 8, 7, 1, -8 },
  { 567, 6, 11, 7, 0, -8 },
  { 576, 6, 11, 7, 1, -8 },
  { 585, 5, 8, 4, 0, -8 },
  { 590, 5, 8, 5, 0, -8 },
  { 595, 3, 9, 4, 1, -9 },
  { 599, 5, 7, 7, 1, -7 },
  { 604, 5, 7, 5, 1, -7 },
  { 609, 8, 7, 8, 1, -7 },
  { 616, 7, 7, 5, -1, -7 },
  { 623, 8, 10, 5, -2, -7 },
  { 633, 5, 7, 5, 0, -7 },
  { 638, 5, 12, 5, 0, -10 },
  { 646, 1, 14, 7, 3, -11 },
  { 648, 5, 12, 4, -1, -10 },
  { 656, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC14PT7B_H_
