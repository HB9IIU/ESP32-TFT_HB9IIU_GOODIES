#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x45, 0x14, 0x52, 0x4A, 0x28, 0xA2, 0x01, 0x08, 0x02,
  0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x08, 0x9F, 0xFE,
  0x04, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x01, 0x04, 0x1F, 0xFF, 0x04,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x20,
  0x00, 0x00, 0x80, 0x08, 0x03, 0xC0, 0xCB, 0x11, 0x01, 0x10, 0x21, 0x02,
  0x10, 0x22, 0x01, 0x20, 0x0A, 0x00, 0x60, 0x03, 0x80, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x40, 0x44, 0x08, 0x88, 0x90, 0x7E, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x1E, 0x02, 0x22, 0x02, 0x21, 0x04, 0x41, 0x08, 0x41, 0x08, 0x82,
  0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x4E, 0x84, 0x91, 0x84, 0xA1, 0x89,
  0x21, 0x72, 0x41, 0x02, 0x41, 0x04, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x42, 0x10, 0x42, 0x20, 0x44, 0x40, 0x78, 0x03, 0xC0, 0x10, 0x80, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x80, 0x82, 0x02, 0x10, 0x05, 0x80, 0x18,
  0x00, 0xA0, 0x04, 0x80, 0x21, 0x05, 0x04, 0x28, 0x08, 0xA0, 0x14, 0x80,
  0x52, 0x00, 0x88, 0x06, 0x20, 0x64, 0x7E, 0x10, 0x55, 0x6A, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x80, 0x04, 0x01, 0x08, 0x43, 0x20, 0x38, 0xC3, 0xC1, 0x80, 0x90,
  0xC4, 0x00, 0x80, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x24, 0xA5, 0x20, 0xFE, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x03, 0xC0, 0x42, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x04, 0x33, 0x51,
  0x84, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x03, 0xE0, 0x60, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFC, 0x00,
  0x03, 0xE0, 0x60, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x06, 0x03, 0xE0, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x11, 0x01, 0x87, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x0A, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x40, 0x42,
  0x04, 0x20, 0x21, 0x02, 0x08, 0x20, 0x42, 0x02, 0x20, 0x21, 0x01, 0x1F,
  0xFF, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x20, 0x20, 0x7F, 0x00, 0x00,
  0xF8, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x27, 0x82, 0xC2, 0x18, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x81, 0x03, 0xF0, 0x00, 0x7F, 0xF0,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0xC3, 0x10, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x10, 0x11, 0x02, 0x08, 0x40, 0x58, 0x0F, 0x01, 0x08,
  0x60, 0x44, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08,
  0x3F, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x20, 0x32, 0x0E, 0x1F, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x04, 0x00, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00,
  0x3E, 0x20, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x60, 0x08, 0x02, 0x02, 0x00, 0x20, 0x80, 0x02,
  0x20, 0x00, 0x48, 0x0E, 0x09, 0x06, 0x21, 0x41, 0x04, 0x28, 0x40, 0x85,
  0x08, 0x20, 0xA2, 0x04, 0x18, 0x40, 0x85, 0x08, 0x10, 0xA1, 0x04, 0x14,
  0x21, 0x84, 0x84, 0x29, 0x10, 0x79, 0xC1, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x14, 0x00, 0x50, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01,
  0x08, 0x08, 0x20, 0x20, 0x81, 0x02, 0x07, 0xF8, 0x20, 0x20, 0x80, 0x84,
  0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0xC0, 0x04, 0x0F, 0xE0,
  0x20, 0x60, 0x80, 0x82, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02,
  0x20, 0x10, 0x81, 0x83, 0xFC, 0x08, 0x08, 0x20, 0x11, 0x00, 0x44, 0x01,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x88, 0x02, 0x20, 0x30, 0xFF, 0x00, 0x01,
  0xF8, 0x18, 0x10, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0x10, 0x60, 0x20, 0x20, 0x40, 0x21, 0x00, 0x42, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x62, 0x01, 0x84,
  0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xF8, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xC2, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x0C, 0x04, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07,
  0xE8, 0x00, 0x50, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x21,
  0x00, 0x41, 0x00, 0x81, 0xFE, 0x00, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10,
  0x0F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x1F, 0x00, 0x08, 0x02, 0x10,
  0x08, 0x20, 0x20, 0x40, 0x81, 0x02, 0x02, 0x08, 0x04, 0x20, 0x08, 0x80,
  0x22, 0x00, 0x48, 0x00, 0xA8, 0x01, 0x90, 0x02, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x20, 0x40, 0x40, 0x80, 0x80, 0x82, 0x01, 0x04, 0x02, 0x08, 0x02,
  0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x0F,
  0xF8, 0x08, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x05, 0x14,
  0x00, 0xA1, 0x40, 0x0A, 0x14, 0x01, 0x21, 0x20, 0x12, 0x22, 0x02, 0x42,
  0x20, 0x24, 0x22, 0x04, 0x42, 0x20, 0x44, 0x22, 0x08, 0x44, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x12, 0x08, 0x41, 0x20, 0x84, 0x14, 0x08, 0x81, 0x41,
  0x08, 0x18, 0x10, 0x81, 0x81, 0x00, 0x08, 0x01, 0x08, 0x01, 0x0C, 0x01,
  0x0C, 0x01, 0x12, 0x01, 0x12, 0x02, 0x12, 0x02, 0x11, 0x02, 0x21, 0x02,
  0x21, 0x02, 0x20, 0x84, 0x20, 0x84, 0x20, 0x84, 0x40, 0x44, 0x40, 0x48,
  0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0x80, 0x28, 0x80, 0x10, 0x80, 0x10,
  0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x21, 0x00, 0x83,
  0x02, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x41, 0x82, 0x02, 0x10, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x88, 0x08, 0x7F, 0x82,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x21, 0x00, 0x83, 0x02, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x0F, 0x80, 0x41, 0x82, 0x02, 0x10, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x20, 0x11, 0x00, 0x88, 0x18, 0x7F, 0x02,
  0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x06, 0x00, 0x03, 0xF0, 0x20, 0x42, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x0F,
  0xF0, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x10, 0x02,
  0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x82, 0x02, 0x03,
  0xF8, 0x00, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x40, 0x22,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x22,
  0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88,
  0x22, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x22, 0x08, 0x82, 0x20,
  0x88, 0x24, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x04, 0x01, 0x02, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x20, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x08, 0x20, 0x08, 0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10,
  0x80, 0x18, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x44, 0x02, 0x40, 0x28, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x07, 0xFE, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3E, 0x00, 0x88, 0x88, 0x84,
  0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11, 0x10, 0x07, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x00, 0x00, 0x80, 0x18, 0x02,
  0x80, 0x24, 0x04, 0x40, 0x84, 0x08, 0x21, 0x02, 0x20, 0x22, 0x01, 0x40,
  0x18, 0x01, 0xFF, 0x80, 0x89, 0x10, 0x03, 0x80, 0xC5, 0x10, 0x32, 0x03,
  0x20, 0x34, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04,
  0x80, 0xC8, 0x0C, 0x41, 0x43, 0xE8, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x81, 0x66, 0x28, 0x13, 0x01, 0x30, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0xC0, 0x4C, 0x04,
  0xA0, 0x8B, 0xF0, 0x03, 0x01, 0x8C, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0xF8, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x38, 0x83, 0x12, 0x10, 0x30, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x0C, 0x20, 0x30,
  0x41, 0x40, 0xF9, 0x00, 0x03, 0x81, 0x88, 0x40, 0x90, 0x12, 0x02, 0x80,
  0x90, 0x22, 0x38, 0x78, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x90, 0x81, 0x84, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x40,
  0x11, 0x00, 0x44, 0x03, 0x10, 0x08, 0x40, 0x61, 0x01, 0x82, 0x0A, 0x07,
  0xC8, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x82, 0x04, 0x07,
  0xE0, 0x00, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x81, 0x66, 0x28, 0x23, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x08,
  0x40, 0x00, 0x00, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x81, 0x20,
  0x44, 0x10, 0x84, 0x11, 0x02, 0x40, 0x90, 0x15, 0x03, 0x20, 0x42, 0x10,
  0x42, 0x08, 0x40, 0x88, 0x11, 0x03, 0x00, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x40, 0x03, 0x03, 0x82,
  0x88, 0x88, 0xA0, 0xA0, 0x98, 0x18, 0x12, 0x02, 0x02, 0x40, 0x40, 0x48,
  0x08, 0x0A, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x40,
  0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x20, 0x20, 0x24, 0x04, 0x04, 0x01,
  0x81, 0x66, 0x28, 0x23, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x03,
  0x80, 0xC4, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40, 0x83, 0xF0, 0x00,
  0x20, 0x16, 0x60, 0xA0, 0x43, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x30, 0x10, 0xC0, 0x43,
  0x02, 0x0B, 0xF0, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x62, 0x44, 0x0C, 0x40, 0x22, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88,
  0x0C, 0x40, 0x61, 0x05, 0x07, 0xC8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x01, 0x8B, 0x0A, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x06, 0x06, 0x32, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x80, 0x48, 0x13, 0xF8, 0x10, 0x20, 0x40, 0x86,
  0xE4, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x01,
  0xC0, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x48, 0x38, 0x7C, 0x80,
  0x80, 0x60, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x88, 0x22,
  0x09, 0x01, 0x40, 0x60, 0x18, 0x04, 0x00, 0x81, 0x01, 0x83, 0x02, 0x83,
  0x02, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88, 0x88, 0x90,
  0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x18, 0x18, 0x40, 0x82, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x0C,
  0x00, 0x40, 0x05, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08, 0x20, 0x22,
  0x01, 0x00, 0x04, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x82, 0x01, 0x04, 0x02, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x40, 0xC0, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x18,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x0E, 0x03, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x10, 0x00, 0xFC, 0x18, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 8, 8, 3, -21 },
  { 21, 15, 21, 15, 1, -21 },
  { 61, 12, 24, 14, 1, -22 },
  { 97, 16, 21, 20, 2, -21 },
  { 139, 14, 21, 16, 1, -21 },
  { 176, 2, 8, 5, 3, -21 },
  { 178, 8, 26, 7, 1, -21 },
  { 204, 8, 26, 7, -2, -21 },
  { 230, 10, 11, 13, 4, -22 },
  { 244, 12, 13, 15, 2, -17 },
  { 264, 3, 7, 5, -1, -3 },
  { 267, 7, 1, 9, 1, -8 },
  { 268, 1, 2, 5, 1, -2 },
  { 269, 12, 21, 9, -1, -21 },
  { 301, 12, 21, 14, 1, -21 },
  { 333, 6, 21, 14, 4, -21 },
  { 349, 13, 21, 14, 0, -21 },
  { 384, 13, 21, 14, 0, -21 },
  { 419, 13, 21, 14, 0, -21 },
  { 454, 14, 21, 14, 0, -21 },
  { 491, 13, 21, 14, 1, -21 },
  { 526, 12, 21, 14, 2, -21 },
  { 558, 12, 21, 14, 1, -21 },
  { 590, 12, 21, 14, 1, -21 },
  { 622, 4, 15, 5, 1, -15 },
  { 630, 6, 19, 6, -1, -15 },
  { 645, 12, 13, 15, 2, -17 },
  { 665, 12, 7, 15, 2, -14 },
  { 676, 12, 13, 15, 2, -17 },
  { 696, 9, 21, 10, 2, -21 },
  { 720, 19, 24, 21, 1, -21 },
  { 777, 14, 21, 14, -2, -21 },
  { 814, 14, 21, 15, 1, -21 },
  { 851, 14, 21, 15, 2, -21 },
  { 888, 15, 21, 17, 1, -21 },
  { 928, 13, 21, 13, 1, -21 },
  { 963, 13, 21, 12, 1, -21 },
  { 998, 15, 21, 17, 2, -21 },
  { 1038, 16, 21, 17, 1, -21 },
  { 1080, 8, 21, 7, 0, -21 },
  { 1101, 11, 26, 6, -5, -21 },
  { 1137, 15, 21, 14, 1, -21 },
  { 1177, 9, 21, 12, 1, -21 },
  { 1201, 20, 21, 21, 1, -21 },
  { 1254, 16, 21, 17, 1, -21 },
  { 1296, 15, 21, 18, 2, -21 },
  { 1336, 13, 21, 14, 1, -21 },
  { 1371, 15, 26, 18, 2, -21 },
  { 1420, 13, 21, 14, 1, -21 },
  { 1455, 13, 21, 13, 0, -21 },
  { 1490, 12, 21, 12, 3, -21 },
  { 1522, 15, 21, 17, 2, -21 },
  { 1562, 13, 21, 13, 3, -21 },
  { 1597, 20, 21, 22, 3, -21 },
  { 1650, 16, 21, 12, -2, -21 },
  { 1692, 12, 21, 12, 3, -21 },
  { 1724, 15, 21, 13, -1, -21 },
  { 1764, 10, 26, 8, 0, -21 },
  { 1797, 4, 21, 9, 3, -21 },
  { 1808, 11, 26, 8, -2, -21 },
  { 1844, 12, 12, 14, 1, -21 },
  { 1862, 9, 1, 10, -2, 3 },
  { 1864, 3, 4, 6, 4, -22 },
  { 1866, 12, 16, 14, 1, -16 },
  { 1890, 12, 22, 14, 1, -22 },
  { 1923, 11, 16, 11, 1, -16 },
  { 1945, 14, 22, 14, 1, -22 },
  { 1984, 11, 16, 13, 1, -16 },
  { 2006, 15, 29, 7, -4, -22 },
  { 2061, 14, 23, 14, 0, -16 },
  { 2102, 12, 22, 14, 1, -22 },
  { 2135, 5, 21, 5, 1, -21 },
  { 2149, 10, 28, 6, -4, -21 },
  { 2184, 11, 22, 11, 1, -22 },
  { 2215, 5, 22, 5, 1, -22 },
  { 2229, 19, 16, 21, 1, -16 },
  { 2267, 12, 16, 14, 1, -16 },
  { 2291, 12, 16, 14, 1, -16 },
  { 2315, 14, 23, 14, -1, -16 },
  { 2356, 13, 23, 14, 1, -16 },
  { 2394, 9, 16, 9, 1, -16 },
  { 2412, 10, 16, 11, 0, -16 },
  { 2432, 7, 19, 8, 1, -19 },
  { 2449, 12, 15, 14, 1, -15 },
  { 2472, 10, 15, 10, 2, -15 },
  { 2491, 16, 15, 17, 2, -15 },
  { 2521, 13, 15, 11, -1, -15 },
  { 2546, 15, 22, 11, -3, -15 },
  { 2588, 12, 15, 10, -1, -15 },
  { 2611, 10, 26, 9, 1, -21 },
  { 2644, 1, 29, 13, 7, -22 },
  { 2648, 11, 26, 9, -2, -21 },
  { 2684, 12, 2, 15, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC29PT7B_H_
