#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x00,
  0x18, 0x22, 0x0C, 0x41, 0x98, 0x23, 0x04, 0x40, 0x88, 0x31, 0x06, 0x60,
  0x88, 0x11, 0x02, 0x20, 0x4C, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x10, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x0C,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x04, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x18, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00,
  0x08, 0x04, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xE0, 0x03, 0x88, 0xF0, 0x18, 0x60, 0x40, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x20, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x40,
  0x00, 0x1D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xB0, 0x00,
  0x02, 0x70, 0x00, 0x08, 0x60, 0x00, 0x20, 0x80, 0x01, 0x83, 0x00, 0x04,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x0C,
  0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x08, 0x18, 0xE0, 0x3F,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x06, 0x0C, 0x10, 0x00, 0xC1, 0x81, 0x80, 0x08, 0x10, 0x08, 0x01,
  0x83, 0x00, 0x80, 0x30, 0x20, 0x08, 0x02, 0x06, 0x00, 0x80, 0x60, 0x60,
  0x08, 0x0C, 0x04, 0x00, 0x80, 0x80, 0x40, 0x18, 0x18, 0x0C, 0x01, 0x81,
  0x00, 0xC0, 0x10, 0x20, 0x08, 0x01, 0x06, 0x00, 0x80, 0x10, 0x40, 0x08,
  0x03, 0x08, 0x18, 0x80, 0x21, 0x87, 0xE8, 0x02, 0x11, 0x83, 0x80, 0x63,
  0x10, 0x18, 0x0C, 0x63, 0x01, 0xC0, 0x84, 0x20, 0x14, 0x18, 0xC6, 0x01,
  0x7F, 0x18, 0x40, 0x10, 0x81, 0x0C, 0x01, 0x00, 0x30, 0xC0, 0x10, 0x06,
  0x08, 0x01, 0x00, 0x40, 0x80, 0x10, 0x0C, 0x18, 0x03, 0x00, 0x81, 0x80,
  0x30, 0x10, 0x18, 0x02, 0x03, 0x01, 0x80, 0x20, 0x20, 0x10, 0x06, 0x04,
  0x01, 0x00, 0x40, 0xC0, 0x10, 0x0C, 0x08, 0x01, 0x80, 0x81, 0x00, 0x18,
  0x18, 0x30, 0x00, 0xC3, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x83, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x60, 0x08, 0x00, 0x10, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x02,
  0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01, 0x80,
  0x02, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x10,
  0xC0, 0x60, 0x08, 0x60, 0x08, 0x02, 0x30, 0x03, 0x01, 0x88, 0x00, 0x40,
  0x46, 0x00, 0x18, 0x31, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x44, 0x30, 0x00,
  0x1B, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x10,
  0x00, 0x16, 0x06, 0x00, 0x18, 0x81, 0xC0, 0x0C, 0x30, 0x38, 0x0E, 0x04,
  0x03, 0xFE, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x84, 0x63, 0x10, 0x84,
  0x62, 0x10, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x04, 0x02, 0x01, 0xE0, 0x80, 0x06, 0x10, 0x00, 0x32,
  0x01, 0x01, 0x4F, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x10, 0x60, 0x0C, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x10,
  0xC2, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x80, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x08, 0x10,
  0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06,
  0x20, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x64, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40,
  0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x30,
  0x10, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x38, 0x0D, 0x06, 0x21, 0x8C, 0xE1, 0xB0, 0x24,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x01,
  0xC0, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0xF0, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x80, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x60, 0x02, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x83, 0xFF, 0xFF, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0xFF,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x07, 0x00, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x1F,
  0x00, 0x23, 0xFF, 0x01, 0x98, 0x06, 0x04, 0x80, 0x0C, 0x14, 0x00, 0x10,
  0xE0, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x01, 0x00, 0x38, 0x18, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x60, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00,
  0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20, 0x30, 0x00,
  0xC0, 0x20, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x61, 0xC0,
  0x00, 0x6E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x30, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x30, 0x08, 0x00, 0x30, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18, 0x00,
  0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00,
  0xC1, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x70, 0x00, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x80,
  0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80, 0x01,
  0x03, 0x00, 0x02, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18,
  0x40, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x20, 0x00, 0x70, 0x60,
  0x01, 0xC0, 0x40, 0x06, 0x80, 0xE0, 0x31, 0x00, 0x7F, 0xC6, 0x00, 0x1C,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08,
  0x07, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x03, 0x07,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xC0, 0x00, 0x40, 0x0C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x18,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x70, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x03,
  0xFE, 0x03, 0x18, 0x01, 0x80, 0x80, 0x44, 0x00, 0xC0, 0x60, 0x11, 0x00,
  0x60, 0x18, 0x04, 0xC0, 0x30, 0x04, 0x03, 0x20, 0x18, 0x01, 0x00, 0xC8,
  0x04, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x30, 0x0D, 0x80, 0x80, 0x08, 0x02,
  0x40, 0x20, 0x02, 0x00, 0x90, 0x18, 0x01, 0x80, 0x64, 0x06, 0x00, 0x40,
  0x13, 0x01, 0x00, 0x10, 0x04, 0xC0, 0x40, 0x0C, 0x03, 0x30, 0x10, 0x03,
  0x00, 0x8C, 0x04, 0x01, 0x40, 0x63, 0x01, 0x80, 0xD0, 0x30, 0xC0, 0x60,
  0x24, 0x08, 0x30, 0x0C, 0x31, 0x8C, 0x04, 0x01, 0xF8, 0x3E, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x28, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x48, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x88, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x04, 0x00, 0x18, 0x04, 0x00, 0x10,
  0x04, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x06, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x02, 0x01, 0x00,
  0x02, 0x03, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x3C, 0x01, 0x00, 0x06, 0x01, 0x00,
  0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x38, 0x08, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x08, 0x01, 0xC0, 0x18, 0x00,
  0x70, 0x18, 0x00, 0x10, 0x10, 0x00, 0x18, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0x80, 0x1E,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x60, 0x1E, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x18,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00,
  0x03, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x18,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x40, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x70, 0x02, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x84, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x80, 0x7F, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x08, 0x70, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x30, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x40, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x08, 0xE0, 0x00, 0x01, 0x36, 0x00, 0x00, 0x2C, 0xC0, 0x00, 0x0F, 0x08,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x08,
  0x00, 0x10, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x40,
  0x00, 0x00, 0xE0, 0x14, 0x00, 0x00, 0x0A, 0x01, 0x40, 0x00, 0x01, 0xE0,
  0x34, 0x00, 0x00, 0x16, 0x03, 0x40, 0x00, 0x03, 0x40, 0x26, 0x00, 0x00,
  0x64, 0x02, 0x60, 0x00, 0x04, 0x40, 0x26, 0x00, 0x00, 0xCC, 0x06, 0x20,
  0x00, 0x08, 0xC0, 0x42, 0x00, 0x01, 0x88, 0x04, 0x20, 0x00, 0x10, 0x80,
  0x42, 0x00, 0x03, 0x08, 0x0C, 0x20, 0x00, 0x21, 0x80, 0xC3, 0x00, 0x06,
  0x18, 0x08, 0x30, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x08, 0x10, 0x08, 0x10,
  0x01, 0x83, 0x01, 0x81, 0x00, 0x10, 0x30, 0x18, 0x10, 0x03, 0x02, 0x01,
  0x01, 0x00, 0x20, 0x20, 0x10, 0x18, 0x06, 0x02, 0x01, 0x01, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x81, 0x80, 0x40, 0x20, 0x08,
  0x10, 0x04, 0x02, 0x00, 0x83, 0x00, 0x40, 0x60, 0x08, 0x20, 0x0C, 0x06,
  0x00, 0x86, 0x00, 0xC0, 0x40, 0x0C, 0x40, 0x08, 0x04, 0x00, 0xCC, 0x00,
  0x80, 0x40, 0x0C, 0x80, 0x08, 0x0C, 0x00, 0x58, 0x01, 0x80, 0xC0, 0x07,
  0x00, 0x10, 0x08, 0x00, 0x60, 0x01, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x02,
  0x80, 0x00, 0x20, 0x14, 0x00, 0x01, 0x01, 0xB0, 0x00, 0x08, 0x0C, 0x80,
  0x00, 0xC0, 0x44, 0x00, 0x06, 0x02, 0x30, 0x00, 0x20, 0x10, 0x80, 0x01,
  0x01, 0x84, 0x00, 0x18, 0x08, 0x30, 0x00, 0xC0, 0x40, 0x80, 0x04, 0x02,
  0x04, 0x00, 0x20, 0x30, 0x30, 0x01, 0x01, 0x80, 0x80, 0x18, 0x08, 0x04,
  0x00, 0xC0, 0x40, 0x30, 0x04, 0x02, 0x00, 0x80, 0x20, 0x30, 0x06, 0x01,
  0x01, 0x80, 0x30, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x40, 0x06, 0x04, 0x02,
  0x00, 0x30, 0x20, 0x30, 0x00, 0x83, 0x01, 0x80, 0x06, 0x18, 0x08, 0x00,
  0x30, 0x80, 0x40, 0x00, 0x84, 0x06, 0x00, 0x06, 0x20, 0x30, 0x00, 0x33,
  0x01, 0x00, 0x00, 0x98, 0x08, 0x00, 0x06, 0x80, 0x40, 0x00, 0x34, 0x06,
  0x00, 0x00, 0xA0, 0x30, 0x00, 0x07, 0x01, 0x00, 0x00, 0x38, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x01, 0xE0, 0x04, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x81,
  0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30,
  0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00,
  0x06, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0, 0x1C,
  0x01, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x10, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x01, 0xE0, 0x04,
  0x00, 0x60, 0x08, 0x00, 0x60, 0x10, 0x00, 0x60, 0x60, 0x00, 0x40, 0xC0,
  0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0xE0, 0x20, 0x07, 0x00,
  0xFF, 0xF8, 0x01, 0x80, 0xC0, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x0C, 0x01, 0x00,
  0x18, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x20, 0x00,
  0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x70,
  0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x80, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x0C,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00,
  0x40, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x60, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0xA0,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x20,
  0x06, 0x08, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x08, 0x03,
  0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x04, 0x02, 0x03, 0x00, 0xC0, 0xC0, 0x20,
  0x20, 0x0C, 0x08, 0x02, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x0C, 0x10,
  0x02, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x0C, 0x20, 0x02, 0x08, 0x00,
  0xC6, 0x00, 0x21, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x05, 0x80,
  0x03, 0x40, 0x00, 0x50, 0x00, 0x34, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x80, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00,
  0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x61, 0x80, 0x06, 0x0C,
  0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x03, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x08, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x06,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x40, 0x00, 0x11,
  0x80, 0x00, 0xC6, 0x00, 0x06, 0x08, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0,
  0x06, 0x01, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x20, 0x10,
  0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x62, 0x00, 0x00, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x86, 0x10, 0xC2, 0x18, 0x41, 0x00, 0x3F, 0x00, 0x03, 0xCE,
  0x10, 0x18, 0x0C, 0x80, 0xC0, 0x1A, 0x06, 0x00, 0x28, 0x30, 0x00, 0xA0,
  0x80, 0x03, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x10, 0x01,
  0xA0, 0x60, 0x04, 0x80, 0x80, 0x66, 0x03, 0x03, 0x10, 0x07, 0xF8, 0x40,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x7C, 0x00, 0x43, 0x9E, 0x00, 0x98, 0x06, 0x03, 0x60,
  0x04, 0x05, 0x80, 0x0C, 0x0A, 0x00, 0x08, 0x1C, 0x00, 0x10, 0x70, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x01, 0x82, 0x80, 0x02, 0x05, 0x80,
  0x08, 0x09, 0x00, 0x30, 0x33, 0x81, 0x80, 0x41, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x3C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x10, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0xF0, 0x60, 0x07, 0x9E, 0x20, 0x06, 0x01, 0x90, 0x06, 0x00, 0x48,
  0x06, 0x00, 0x3C, 0x06, 0x00, 0x0E, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x08, 0x00,
  0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xD0, 0x08,
  0x00, 0x58, 0x06, 0x00, 0x68, 0x01, 0x00, 0x64, 0x00, 0xC0, 0xE2, 0x00,
  0x3F, 0xC1, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x79, 0xC0,
  0x30, 0x18, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x11, 0x00, 0x0C, 0xC0,
  0x03, 0x20, 0x00, 0x98, 0x00, 0x64, 0x00, 0x31, 0x00, 0x18, 0xC0, 0x3C,
  0x3F, 0xF8, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x3F, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x79, 0xE2, 0x00, 0xC0, 0x32, 0x01,
  0x80, 0x12, 0x03, 0x00, 0x1A, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20, 0x00, 0x18, 0x20,
  0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xA0, 0x20,
  0x01, 0x60, 0x30, 0x03, 0x40, 0x10, 0x06, 0x40, 0x18, 0x1C, 0x40, 0x0F,
  0xF0, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x38, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x07, 0xC0, 0x08, 0x7B, 0xC0, 0x26, 0x01, 0x81, 0xB0, 0x02, 0x05, 0x80,
  0x08, 0x14, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08,
  0x30, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00,
  0x83, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x86,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x20, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x81, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x08,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0,
  0x80, 0x04, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0xCF, 0x00, 0x04, 0xC8, 0x00, 0x2C, 0x40, 0x01, 0xC3, 0x00, 0x1C, 0x08,
  0x00, 0xC0, 0x40, 0x04, 0x03, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x18,
  0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x60, 0x20, 0x01, 0x03, 0x00, 0x08,
  0x18, 0x00, 0x60, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x47, 0xBC,
  0x1E, 0xF0, 0x09, 0x80, 0x86, 0x03, 0x03, 0x60, 0x19, 0x80, 0x20, 0x58,
  0x01, 0x60, 0x04, 0x0A, 0x00, 0x28, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x18,
  0x70, 0x00, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x00, 0x41, 0x80, 0x06, 0x00,
  0x08, 0x20, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x10, 0x00, 0x61, 0x80, 0x02,
  0x00, 0x0C, 0x30, 0x00, 0x40, 0x01, 0x04, 0x00, 0x18, 0x00, 0x20, 0x80,
  0x03, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x86, 0x00, 0x08, 0x00, 0x20,
  0xC0, 0x01, 0x00, 0x04, 0x10, 0x00, 0x60, 0x00, 0x82, 0x00, 0x08, 0x00,
  0x30, 0x40, 0x01, 0x00, 0x06, 0x18, 0x00, 0x20, 0x00, 0x82, 0x00, 0x0C,
  0x00, 0x10, 0x40, 0x01, 0x80, 0x02, 0x08, 0x00, 0x20, 0x00, 0xC3, 0x00,
  0x04, 0x00, 0x18, 0x60, 0x01, 0x80, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x10,
  0xF7, 0x80, 0x98, 0x06, 0x0D, 0x80, 0x10, 0x58, 0x00, 0x82, 0x80, 0x04,
  0x18, 0x00, 0x21, 0xC0, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00,
  0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x42,
  0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00,
  0x42, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40,
  0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0x9E, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06,
  0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00, 0x09, 0x80, 0x00,
  0x48, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x68, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x21, 0x00, 0x03, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x1F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x43, 0x8E, 0x00, 0x27, 0x01,
  0x80, 0x36, 0x00, 0x40, 0x12, 0x00, 0x30, 0x0B, 0x00, 0x08, 0x07, 0x00,
  0x04, 0x07, 0x00, 0x02, 0x03, 0x80, 0x01, 0x01, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x60, 0x00, 0x10, 0x30, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x28, 0x00, 0x20, 0x16, 0x00, 0x30, 0x09, 0x00, 0x30,
  0x0C, 0xE0, 0x70, 0x06, 0x1F, 0xE0, 0x02, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x02, 0x01,
  0xE7, 0x88, 0x06, 0x01, 0x90, 0x18, 0x01, 0x20, 0x60, 0x03, 0x41, 0x80,
  0x03, 0x82, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30,
  0x00, 0xD0, 0x20, 0x01, 0xE0, 0x60, 0x06, 0xC0, 0x40, 0x19, 0x00, 0xC0,
  0xE2, 0x00, 0xFF, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0x81, 0x1E, 0x40, 0x98, 0x00, 0xD8, 0x00,
  0x58, 0x00, 0x28, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0xFC, 0x18, 0x01, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x10, 0x01, 0x83, 0x80, 0x60, 0x3F, 0xF8, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x0F,
  0xFF, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xF8, 0x02, 0x00, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60,
  0x00, 0x41, 0x80, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00,
  0xC3, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x86,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0A, 0x0C, 0x00, 0x68,
  0x30, 0x03, 0x60, 0x40, 0x19, 0x01, 0xC0, 0xC4, 0x03, 0xFE, 0x10, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0xC0,
  0x03, 0x30, 0x00, 0x8C, 0x00, 0x61, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x06,
  0x04, 0x01, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x06, 0x04, 0x01,
  0x83, 0x00, 0x60, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22,
  0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xA0, 0x01,
  0x80, 0x0D, 0x00, 0x14, 0x00, 0x48, 0x00, 0xB0, 0x02, 0x60, 0x0D, 0x80,
  0x23, 0x00, 0x4C, 0x01, 0x18, 0x06, 0x60, 0x18, 0xC0, 0x21, 0x00, 0x86,
  0x03, 0x08, 0x0C, 0x30, 0x10, 0x40, 0x41, 0x81, 0x82, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x60, 0xC0, 0x81, 0x01, 0x04, 0x04, 0x10, 0x08, 0x60, 0x20,
  0x80, 0x42, 0x01, 0x0C, 0x02, 0x30, 0x08, 0x40, 0x11, 0x00, 0x46, 0x00,
  0x98, 0x02, 0x20, 0x04, 0x80, 0x13, 0x00, 0x24, 0x00, 0xD0, 0x01, 0x40,
  0x06, 0x80, 0x0A, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x03, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x08, 0x00,
  0x18, 0x10, 0x00, 0x60, 0x30, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x00, 0xC0, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x1E, 0x07,
  0x00, 0xE0, 0x07, 0xDC, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 37, 11, 1, -37 },
  { 48, 11, 13, 15, 5, -37 },
  { 66, 27, 37, 27, 1, -37 },
  { 191, 22, 42, 25, 2, -39 },
  { 307, 28, 39, 35, 4, -38 },
  { 444, 26, 39, 29, 1, -38 },
  { 571, 5, 13, 8, 5, -37 },
  { 580, 14, 45, 13, 2, -37 },
  { 659, 14, 45, 13, -3, -37 },
  { 738, 19, 19, 24, 6, -39 },
  { 784, 22, 24, 26, 3, -30 },
  { 850, 6, 13, 9, -2, -6 },
  { 860, 12, 2, 15, 2, -15 },
  { 863, 3, 3, 10, 1, -3 },
  { 865, 22, 37, 16, -2, -37 },
  { 967, 21, 39, 25, 3, -38 },
  { 1070, 11, 37, 25, 8, -37 },
  { 1121, 23, 38, 25, 0, -38 },
  { 1231, 24, 39, 25, 0, -38 },
  { 1348, 23, 37, 25, 0, -37 },
  { 1455, 23, 38, 25, 1, -37 },
  { 1565, 22, 39, 25, 3, -38 },
  { 1673, 22, 37, 25, 4, -37 },
  { 1775, 23, 39, 25, 1, -38 },
  { 1888, 23, 39, 25, 1, -38 },
  { 2001, 8, 28, 10, 1, -28 },
  { 2029, 11, 35, 10, -2, -28 },
  { 2078, 22, 23, 26, 3, -30 },
  { 2142, 22, 12, 26, 3, -24 },
  { 2175, 22, 23, 26, 3, -30 },
  { 2239, 16, 38, 18, 3, -38 },
  { 2315, 34, 42, 37, 2, -37 },
  { 2494, 24, 37, 24, -3, -37 },
  { 2605, 24, 37, 27, 2, -37 },
  { 2716, 26, 39, 26, 3, -38 },
  { 2843, 26, 37, 30, 2, -37 },
  { 2964, 24, 37, 24, 2, -37 },
  { 3075, 24, 37, 22, 2, -37 },
  { 3186, 28, 39, 31, 3, -38 },
  { 3323, 29, 37, 31, 2, -37 },
  { 3458, 16, 37, 12, -1, -37 },
  { 3532, 19, 46, 11, -8, -37 },
  { 3642, 27, 37, 24, 2, -37 },
  { 3767, 16, 37, 22, 2, -37 },
  { 3841, 36, 37, 38, 2, -37 },
  { 4008, 29, 37, 31, 2, -37 },
  { 4143, 27, 39, 32, 3, -38 },
  { 4275, 23, 37, 25, 2, -37 },
  { 4382, 27, 47, 32, 3, -38 },
  { 4541, 23, 37, 25, 2, -37 },
  { 4648, 24, 39, 23, 0, -38 },
  { 4765, 21, 37, 22, 5, -37 },
  { 4863, 28, 38, 31, 3, -37 },
  { 4996, 23, 37, 24, 5, -37 },
  { 5103, 36, 37, 39, 6, -37 },
  { 5270, 29, 37, 22, -3, -37 },
  { 5405, 21, 37, 21, 5, -37 },
  { 5503, 27, 37, 24, -1, -37 },
  { 5628, 20, 45, 15, -1, -37 },
  { 5741, 8, 37, 16, 5, -37 },
  { 5778, 20, 45, 15, -4, -37 },
  { 5891, 22, 21, 26, 2, -37 },
  { 5949, 17, 2, 17, -4, 5 },
  { 5954, 5, 8, 11, 8, -40 },
  { 5959, 22, 29, 25, 2, -28 },
  { 6039, 23, 41, 26, 1, -40 },
  { 6157, 19, 29, 20, 2, -28 },
  { 6226, 25, 41, 26, 2, -40 },
  { 6355, 18, 29, 22, 3, -28 },
  { 6421, 26, 52, 12, -7, -40 },
  { 6590, 24, 40, 26, 1, -28 },
  { 6710, 22, 40, 25, 1, -40 },
  { 6820, 10, 37, 10, 1, -37 },
  { 6867, 18, 49, 10, -7, -37 },
  { 6978, 21, 40, 20, 1, -40 },
  { 7083, 10, 40, 10, 1, -40 },
  { 7133, 35, 28, 38, 1, -28 },
  { 7256, 21, 28, 25, 1, -28 },
  { 7330, 21, 29, 25, 2, -28 },
  { 7407, 25, 40, 26, -1, -28 },
  { 7532, 23, 40, 26, 2, -28 },
  { 7647, 17, 28, 17, 1, -28 },
  { 7707, 19, 29, 19, 0, -28 },
  { 7776, 13, 35, 14, 2, -34 },
  { 7833, 22, 28, 25, 2, -27 },
  { 7910, 18, 27, 19, 3, -27 },
  { 7971, 29, 27, 30, 3, -27 },
  { 8069, 23, 27, 20, -2, -27 },
  { 8147, 28, 40, 19, -6, -27 },
  { 8287, 20, 27, 19, -1, -27 },
  { 8355, 18, 45, 17, 2, -37 },
  { 8457, 2, 53, 24, 12, -40 },
  { 8471, 18, 45, 17, -3, -37 },
  { 8573, 22, 5, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC52PT7B_H_
