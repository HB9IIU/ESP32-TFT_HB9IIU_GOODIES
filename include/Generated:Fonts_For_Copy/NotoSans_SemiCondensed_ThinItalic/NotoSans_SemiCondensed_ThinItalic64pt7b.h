#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x18,
  0xC0, 0xCC, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60,
  0x23, 0x03, 0x10, 0x18, 0x80, 0x84, 0x04, 0x60, 0x22, 0x03, 0x10, 0x18,
  0x80, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0x80, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xE1, 0x01, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40,
  0x04, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFB, 0x7F, 0x00, 0x70, 0x60, 0x60, 0x18, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x90, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x47, 0x00, 0x00, 0x08, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x81,
  0xC0, 0x60, 0x10, 0x70, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0x80, 0x71, 0xC0, 0x00, 0x60, 0x18, 0x18, 0x00, 0x0C,
  0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x18, 0x04, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x00, 0x80, 0x20, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x30,
  0x01, 0x80, 0x60, 0x04, 0x00, 0x30, 0x18, 0x01, 0x80, 0x04, 0x03, 0x00,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x10, 0x00, 0xC1, 0x80, 0x02, 0x00, 0x30, 0x60, 0x7C, 0x40, 0x06,
  0x0C, 0x3F, 0xC8, 0x00, 0xC3, 0x0E, 0x0D, 0x00, 0x30, 0xC3, 0x01, 0xA0,
  0x06, 0x18, 0x60, 0x1E, 0x01, 0x86, 0x18, 0x03, 0xC0, 0x60, 0x82, 0x00,
  0x7C, 0x1C, 0x30, 0xC0, 0x0D, 0xC7, 0x0C, 0x18, 0x01, 0x9F, 0x81, 0x06,
  0x00, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x03, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x10, 0x03, 0x01, 0x80,
  0x02, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x01,
  0x00, 0x00, 0xC1, 0x80, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x08, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x18, 0xE0, 0x06,
  0x00, 0x23, 0x80, 0x0C, 0x00, 0xC6, 0x00, 0x0C, 0x01, 0x18, 0x00, 0x18,
  0x06, 0x30, 0x00, 0x18, 0x08, 0xC0, 0x00, 0x10, 0x31, 0x80, 0x00, 0x30,
  0xC3, 0x00, 0x00, 0x31, 0x84, 0x00, 0x00, 0x66, 0x08, 0x00, 0x00, 0x78,
  0x10, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x0D, 0x81, 0x80, 0x00, 0x71, 0x01, 0x80, 0x01, 0xC3, 0x01,
  0x80, 0x06, 0x02, 0x01, 0xC0, 0x78, 0x06, 0x01, 0xFF, 0xC0, 0x06, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x18, 0xCC, 0x63, 0x18, 0x84, 0x63, 0x10, 0x84,
  0x62, 0x10, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x00, 0x0E, 0x04,
  0x00, 0x0E, 0x10, 0x00, 0x0C, 0xC0, 0x30, 0x0E, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0x70, 0x00, 0x02, 0x40, 0x00, 0x31, 0x80, 0x01, 0x82, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x10, 0x03, 0x00, 0x60, 0x18, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFE, 0x5F,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x83, 0x80, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x07, 0xC0, 0x3A, 0x03, 0x88, 0x1C, 0x60, 0xC1, 0x8E, 0x06,
  0xE0, 0x11, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x3C, 0x00, 0x0F, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x60, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x10, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x05, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0x00,
  0x01, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x0F,
  0x80, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x06, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x1F, 0xC0, 0x01, 0x07, 0xFF, 0x00, 0x31, 0xC0, 0x18,
  0x03, 0x30, 0x00, 0xC0, 0x26, 0x00, 0x06, 0x02, 0xC0, 0x00, 0x60, 0x78,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x38, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0x36, 0x06, 0x00, 0x0C, 0x80, 0x60, 0x07, 0x30, 0x07, 0x87, 0xC6,
  0x00, 0x7F, 0xC0, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0xE0, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xF8,
  0x78, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x08, 0x00, 0x18, 0x60, 0x00,
  0x7F, 0xF0, 0x0C, 0x30, 0x00, 0xE0, 0x30, 0x06, 0x30, 0x00, 0xC0, 0x18,
  0x01, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x88, 0x00, 0xC0, 0x06, 0x00, 0x4C,
  0x00, 0xC0, 0x02, 0x00, 0x66, 0x00, 0x60, 0x03, 0x00, 0x36, 0x00, 0x60,
  0x01, 0x80, 0x1B, 0x00, 0x60, 0x00, 0xC0, 0x0D, 0x80, 0x30, 0x00, 0x40,
  0x06, 0xC0, 0x10, 0x00, 0x60, 0x02, 0x40, 0x18, 0x00, 0x30, 0x03, 0x60,
  0x0C, 0x00, 0x18, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x00, 0xD8, 0x02, 0x00,
  0x0C, 0x00, 0x4C, 0x03, 0x00, 0x06, 0x00, 0x66, 0x01, 0x80, 0x07, 0x00,
  0x33, 0x00, 0xC0, 0x03, 0x00, 0x31, 0x80, 0x60, 0x03, 0x80, 0x18, 0xC0,
  0x30, 0x01, 0x40, 0x18, 0x60, 0x08, 0x01, 0xA0, 0x18, 0x30, 0x06, 0x01,
  0x98, 0x1C, 0x18, 0x03, 0x81, 0x8C, 0x1C, 0x0C, 0x00, 0xFF, 0x83, 0xFC,
  0x06, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x40, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x40, 0x01, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x70, 0x06, 0x00, 0x0F,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x04, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x02,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x08,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x02, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFE, 0x30, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x31, 0xA0, 0x00, 0x00, 0x19, 0x98, 0x00,
  0x00, 0x0D, 0x8C, 0x00, 0x00, 0x05, 0x83, 0x00, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x03, 0x80, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x0B, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0xD0, 0x03, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x19,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x60, 0x06, 0x40,
  0x00, 0x00, 0x33, 0x00, 0x23, 0x00, 0x00, 0x03, 0x10, 0x03, 0x18, 0x00,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x00,
  0x08, 0x60, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x10, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x18, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x10, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x00, 0x08, 0x0C, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x04, 0x02,
  0x00, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x18, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x20, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC3, 0x00, 0x0C, 0x00, 0x80, 0x02, 0x18, 0x00, 0x40, 0x0C, 0x00,
  0x11, 0x80, 0x02, 0x00, 0x60, 0x00, 0x88, 0x00, 0x30, 0x03, 0x00, 0x06,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x80, 0x01, 0xE0,
  0x00, 0x40, 0x0C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00,
  0x20, 0x05, 0x80, 0x00, 0x06, 0x00, 0xC8, 0x00, 0x00, 0x60, 0x0C, 0xC0,
  0x00, 0x06, 0x00, 0xCC, 0x00, 0x00, 0x60, 0x0C, 0x40, 0x00, 0x04, 0x00,
  0x86, 0x00, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x0C, 0x01, 0x82, 0x00, 0x00,
  0xC0, 0x18, 0x30, 0x00, 0x08, 0x01, 0x03, 0x00, 0x00, 0x80, 0x10, 0x10,
  0x00, 0x18, 0x03, 0x01, 0x80, 0x01, 0x80, 0x30, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x80, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x04, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x18, 0x04,
  0x00, 0x80, 0x01, 0x80, 0xC0, 0x18, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x18, 0x00, 0x0C, 0x08, 0x01, 0x00, 0x00, 0x61, 0x80, 0x30,
  0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x61, 0x80, 0x30, 0x00, 0x03, 0x18,
  0x03, 0x00, 0x00, 0x31, 0x00, 0x20, 0x00, 0x03, 0x10, 0x06, 0x00, 0x00,
  0x1B, 0x00, 0x60, 0x00, 0x01, 0xB0, 0x06, 0x00, 0x00, 0x1B, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x07, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x20, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x04,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x1C, 0x00, 0xC0, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x80, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20,
  0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x01, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x08, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x60, 0x00, 0x0D,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x01, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x86, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x30, 0x00,
  0x80, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00,
  0x20, 0x20, 0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x08,
  0x18, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x02, 0x0C,
  0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x00, 0xC6, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x26,
  0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x02, 0x01,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0x80, 0x30, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xF8, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x04, 0x00,
  0x1F, 0xE0, 0x40, 0x1E, 0x1E, 0x10, 0x0E, 0x01, 0x8C, 0x06, 0x00, 0x33,
  0x03, 0x00, 0x06, 0x81, 0x80, 0x01, 0xA0, 0xC0, 0x00, 0x28, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C,
  0x00, 0x07, 0x83, 0x00, 0x01, 0x60, 0xC0, 0x00, 0xD0, 0x18, 0x00, 0x64,
  0x06, 0x00, 0x31, 0x00, 0xC0, 0x18, 0xC0, 0x1C, 0x1C, 0x30, 0x03, 0xFC,
  0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x1F,
  0xE0, 0x01, 0x87, 0x87, 0x80, 0x18, 0xE0, 0x1C, 0x01, 0x98, 0x00, 0xC0,
  0x13, 0x00, 0x06, 0x03, 0x60, 0x00, 0x60, 0x3C, 0x00, 0x02, 0x03, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x83, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x28, 0x00, 0x06, 0x02,
  0x80, 0x00, 0x60, 0x6C, 0x00, 0x0C, 0x06, 0x40, 0x01, 0x80, 0x46, 0x00,
  0x70, 0x04, 0x38, 0x1E, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x0E, 0x03, 0x80, 0x0F,
  0xFE, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x7C, 0x38, 0x60, 0x03, 0x80, 0x31,
  0x80, 0x18, 0x00, 0x66, 0x00, 0xC0, 0x00, 0x90, 0x06, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x06, 0x80, 0x30, 0x00,
  0x32, 0x00, 0x60, 0x01, 0xD8, 0x01, 0x80, 0x0E, 0x60, 0x03, 0x00, 0x71,
  0x80, 0x07, 0x07, 0x84, 0x00, 0x0F, 0xF8, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0xF0, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0x60, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x30, 0x0F, 0x80, 0x7F,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x0E, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x8E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x08, 0x00, 0xF8, 0x70, 0x40, 0x0E, 0x00, 0xC6, 0x00, 0xC0, 0x03,
  0x30, 0x0C, 0x00, 0x09, 0x00, 0xC0, 0x00, 0x68, 0x0C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0xE0, 0x20, 0x00, 0x07, 0x01, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x34, 0x03, 0x00, 0x03, 0x20, 0x0C, 0x00, 0x3B, 0x00, 0x60,
  0x03, 0x98, 0x01, 0x80, 0x38, 0xC0, 0x07, 0x07, 0x84, 0x00, 0x1F, 0xF0,
  0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x0F, 0xF0, 0x01, 0x87, 0x87, 0x80, 0x31, 0x80, 0x38, 0x06, 0x60, 0x03,
  0x00, 0x98, 0x00, 0x20, 0x36, 0x00, 0x06, 0x07, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x08,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x21, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x04, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x04, 0x18,
  0x00, 0x01, 0x0E, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x33, 0x20, 0x00, 0x0C,
  0x8C, 0x00, 0x02, 0x63, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x78, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x83, 0xFC,
  0x00, 0xFF, 0x00, 0x30, 0xE1, 0xC0, 0x70, 0xF0, 0x06, 0x70, 0x0C, 0x18,
  0x07, 0x00, 0x98, 0x00, 0x86, 0x00, 0x60, 0x12, 0x00, 0x19, 0x80, 0x06,
  0x06, 0x80, 0x03, 0x60, 0x00, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x81, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x04, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x00, 0x30, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x30, 0x00, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x81, 0xFE, 0x00, 0x30, 0xF0, 0xF0, 0x06, 0x30, 0x07, 0x00, 0x8C,
  0x00, 0x60, 0x13, 0x00, 0x04, 0x06, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x18,
  0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x08, 0x1C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x38, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1E,
  0x07, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x3F,
  0xC0, 0x00, 0x61, 0xE1, 0xE0, 0x00, 0xC7, 0x00, 0xE0, 0x01, 0x18, 0x00,
  0xC0, 0x02, 0x60, 0x00, 0xC0, 0x0D, 0x80, 0x01, 0x80, 0x1B, 0x00, 0x01,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x28, 0x00, 0x06, 0x00, 0x50, 0x00,
  0x0C, 0x01, 0xB0, 0x00, 0x30, 0x03, 0x20, 0x00, 0xC0, 0x06, 0x60, 0x07,
  0x00, 0x08, 0x70, 0x3C, 0x00, 0x10, 0x7F, 0xE0, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x20, 0x0F,
  0x87, 0x04, 0x03, 0x80, 0x31, 0x80, 0xC0, 0x03, 0x30, 0x30, 0x00, 0x24,
  0x0C, 0x00, 0x06, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x84, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x83, 0x00,
  0x00, 0xF0, 0x60, 0x00, 0x34, 0x0C, 0x00, 0x0E, 0x80, 0xC0, 0x03, 0xB0,
  0x18, 0x00, 0xE6, 0x01, 0x80, 0x38, 0xC0, 0x1C, 0x1E, 0x10, 0x01, 0xFF,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x81, 0xFC, 0x06, 0x1E, 0x20, 0x18,
  0xC0, 0x00, 0x46, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xFC, 0x06, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x60, 0x01, 0xC0, 0xF0,
  0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x40, 0x3F, 0xC0, 0x07, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x07, 0x82, 0x00, 0x01, 0x40, 0xC0, 0x00, 0xD0, 0x30, 0x00, 0x6C, 0x0C,
  0x00, 0x33, 0x01, 0x80, 0x18, 0x80, 0x38, 0x1C, 0x20, 0x07, 0xFC, 0x08,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x01,
  0x00, 0x0C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x01, 0x00, 0x02, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xF0, 0x00, 0x68,
  0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00,
  0x66, 0x00, 0x13, 0x00, 0x08, 0xC0, 0x06, 0x60, 0x03, 0x18, 0x00, 0x8C,
  0x00, 0x43, 0x00, 0x30, 0x80, 0x18, 0x60, 0x04, 0x10, 0x02, 0x0C, 0x01,
  0x82, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x18, 0x30, 0x0C, 0x08, 0x06, 0x06,
  0x01, 0x01, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x40, 0x18, 0x30, 0x0C, 0x18, 0x03,
  0x04, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x02, 0x18,
  0x01, 0x8C, 0x00, 0x46, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x06, 0x20, 0x01,
  0x30, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x09, 0x00, 0x05, 0x80, 0x01, 0x60,
  0x00, 0xB0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x5E, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0xBE, 0x80, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 46, 13, 2, -46 },
  { 70, 13, 17, 19, 7, -46 },
  { 98, 33, 46, 33, 1, -46 },
  { 288, 27, 53, 30, 2, -49 },
  { 467, 35, 47, 43, 5, -46 },
  { 673, 31, 47, 35, 2, -46 },
  { 856, 5, 17, 10, 7, -46 },
  { 867, 18, 56, 15, 2, -46 },
  { 993, 18, 56, 15, -4, -46 },
  { 1119, 22, 23, 29, 8, -48 },
  { 1183, 26, 29, 32, 4, -37 },
  { 1278, 8, 15, 11, -3, -7 },
  { 1293, 15, 1, 19, 2, -18 },
  { 1295, 3, 4, 12, 2, -4 },
  { 1297, 27, 46, 19, -3, -46 },
  { 1453, 26, 47, 30, 3, -46 },
  { 1606, 14, 46, 30, 9, -46 },
  { 1687, 29, 46, 30, 0, -46 },
  { 1854, 29, 47, 30, 0, -46 },
  { 2025, 29, 46, 30, 0, -46 },
  { 2192, 29, 47, 30, 1, -46 },
  { 2363, 28, 47, 30, 3, -46 },
  { 2528, 27, 46, 30, 5, -46 },
  { 2684, 28, 47, 30, 2, -46 },
  { 2849, 27, 47, 30, 2, -46 },
  { 3008, 10, 34, 12, 1, -34 },
  { 3051, 14, 42, 12, -3, -34 },
  { 3125, 26, 28, 32, 4, -37 },
  { 3216, 26, 15, 32, 4, -30 },
  { 3265, 26, 28, 32, 4, -37 },
  { 3356, 20, 46, 22, 4, -46 },
  { 3471, 41, 51, 46, 3, -45 },
  { 3733, 30, 46, 30, -4, -46 },
  { 3906, 30, 46, 33, 2, -46 },
  { 4079, 31, 47, 32, 4, -46 },
  { 4262, 33, 46, 37, 2, -46 },
  { 4452, 30, 46, 30, 2, -46 },
  { 4625, 30, 46, 27, 2, -46 },
  { 4798, 34, 47, 39, 4, -46 },
  { 4998, 36, 46, 38, 2, -46 },
  { 5205, 19, 46, 15, -1, -46 },
  { 5315, 24, 57, 13, -10, -46 },
  { 5486, 33, 46, 30, 2, -46 },
  { 5676, 20, 46, 27, 2, -46 },
  { 5791, 45, 46, 46, 2, -46 },
  { 6050, 36, 46, 38, 2, -46 },
  { 6257, 33, 47, 39, 4, -46 },
  { 6451, 29, 46, 31, 2, -46 },
  { 6618, 33, 57, 39, 4, -46 },
  { 6854, 29, 46, 31, 2, -46 },
  { 7021, 29, 47, 28, 0, -46 },
  { 7192, 26, 46, 27, 6, -46 },
  { 7342, 34, 47, 38, 4, -46 },
  { 7542, 29, 46, 30, 6, -46 },
  { 7709, 45, 46, 47, 7, -46 },
  { 7968, 36, 46, 27, -4, -46 },
  { 8175, 26, 46, 26, 6, -46 },
  { 8325, 33, 46, 29, -1, -46 },
  { 8515, 24, 56, 19, -1, -46 },
  { 8683, 10, 46, 20, 6, -46 },
  { 8741, 23, 56, 19, -4, -46 },
  { 8902, 26, 26, 31, 3, -46 },
  { 8987, 21, 1, 21, -5, 7 },
  { 8990, 7, 10, 14, 9, -49 },
  { 8999, 26, 35, 31, 3, -34 },
  { 9113, 28, 50, 32, 1, -49 },
  { 9288, 23, 35, 25, 3, -34 },
  { 9389, 30, 50, 32, 3, -49 },
  { 9577, 23, 35, 28, 3, -34 },
  { 9678, 32, 64, 15, -8, -49 },
  { 9934, 29, 49, 32, 1, -34 },
  { 10112, 27, 49, 31, 1, -49 },
  { 10278, 12, 46, 12, 1, -46 },
  { 10347, 22, 61, 12, -9, -46 },
  { 10515, 26, 49, 25, 1, -49 },
  { 10675, 12, 49, 12, 1, -49 },
  { 10749, 43, 34, 47, 1, -34 },
  { 10932, 27, 34, 31, 1, -34 },
  { 11047, 25, 35, 31, 3, -34 },
  { 11157, 31, 49, 32, -2, -34 },
  { 11347, 27, 49, 32, 3, -34 },
  { 11513, 22, 34, 20, 1, -34 },
  { 11607, 23, 35, 24, 0, -34 },
  { 11708, 16, 43, 17, 2, -42 },
  { 11794, 26, 35, 31, 3, -34 },
  { 11908, 23, 34, 23, 3, -34 },
  { 12006, 35, 34, 37, 4, -34 },
  { 12155, 28, 34, 25, -2, -34 },
  { 12274, 34, 50, 23, -7, -34 },
  { 12487, 25, 34, 23, -1, -34 },
  { 12594, 22, 56, 21, 2, -46 },
  { 12748, 2, 64, 30, 15, -49 },
  { 12764, 23, 56, 20, -4, -46 },
  { 12925, 26, 5, 32, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC64PT7B_H_
