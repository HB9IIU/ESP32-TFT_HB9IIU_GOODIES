#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x86, 0x06, 0x10, 0x18, 0xC0, 0x63,
  0x01, 0x8C, 0x04, 0x20, 0x30, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x40, 0x21,
  0x01, 0x84, 0x06, 0x30, 0x10, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x06, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF6, 0xFE,
  0x00, 0x38, 0x30, 0x38, 0x03, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x00, 0x39,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x2E, 0x00, 0x00, 0x01, 0x3C, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x38, 0x08, 0x03,
  0x03, 0x80, 0x70, 0x18, 0x70, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0x00, 0xE1, 0xC0, 0x00, 0x30, 0x0E, 0x06, 0x00, 0x03, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x04, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0xC0, 0xFC, 0x60, 0x03, 0x06, 0x1F, 0xF3, 0x00, 0x30, 0x61,
  0xC0, 0xD8, 0x01, 0x86, 0x0C, 0x06, 0xC0, 0x18, 0x30, 0xC0, 0x1E, 0x00,
  0xC3, 0x0C, 0x00, 0xF0, 0x0C, 0x30, 0x60, 0x06, 0xC0, 0xC1, 0x86, 0x00,
  0x37, 0x1C, 0x18, 0x30, 0x01, 0x9F, 0xC0, 0xC1, 0x00, 0x0C, 0x10, 0x0C,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x06, 0x06, 0x00, 0x10,
  0x00, 0x60, 0x60, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x06, 0x00, 0x10, 0x01,
  0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x0C, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x0C, 0x00,
  0x10, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x20, 0x00, 0x30, 0x18, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x30, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x10, 0x60, 0x0C, 0x00, 0x10, 0x60, 0x03, 0x00, 0x18, 0x60,
  0x01, 0x80, 0x08, 0x60, 0x00, 0x60, 0x0C, 0x30, 0x00, 0x30, 0x06, 0x30,
  0x00, 0x0C, 0x06, 0x10, 0x00, 0x06, 0x02, 0x18, 0x00, 0x01, 0x83, 0x0C,
  0x00, 0x00, 0xC3, 0x06, 0x00, 0x00, 0x31, 0x83, 0x00, 0x00, 0x0D, 0x81,
  0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x01, 0xD8, 0x0E, 0x00, 0x01, 0xC6,
  0x03, 0x80, 0x01, 0xC3, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x3C, 0x07, 0x80,
  0x60, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x18, 0xC6,
  0x31, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0x21, 0x18, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x08, 0x00, 0xF0, 0x08, 0x00, 0x38, 0x08, 0x00, 0x0E, 0x08,
  0x00, 0x03, 0x98, 0x01, 0x00, 0xD0, 0x7F, 0x00, 0x3F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x88, 0x00, 0x03, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x02, 0x00, 0x70, 0x03, 0x00, 0x20, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x21, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0,
  0x32, 0x03, 0x88, 0x1C, 0x61, 0xC1, 0x8E, 0x06, 0x60, 0x13, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x20,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x38,
  0x03, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x02, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3C, 0x06, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x08, 0x3E, 0x3E, 0x00,
  0xC7, 0x00, 0x38, 0x06, 0x60, 0x00, 0xC0, 0x36, 0x00, 0x03, 0x01, 0x60,
  0x00, 0x0C, 0x1E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x36, 0x07, 0x00, 0x06,
  0x60, 0x38, 0x01, 0xC4, 0x01, 0xE0, 0xF8, 0xC0, 0x07, 0xFE, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x03,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x18,
  0x07, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x03, 0xC0, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x07, 0xE0,
  0xF0, 0x10, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0x18, 0x60,
  0x00, 0x7F, 0xF8, 0x03, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x63, 0x00, 0x0E,
  0x00, 0x60, 0x04, 0x60, 0x03, 0x80, 0x08, 0x00, 0x8C, 0x00, 0x60, 0x03,
  0x00, 0x13, 0x00, 0x18, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xCC, 0x00, 0xC0, 0x01, 0x00, 0x1B, 0x00, 0x30, 0x00, 0x60, 0x03, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x80, 0x01, 0x80, 0x0D, 0x80, 0x30,
  0x00, 0x60, 0x03, 0x20, 0x06, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x80, 0x01,
  0x80, 0x0D, 0x80, 0x30, 0x00, 0x20, 0x03, 0x30, 0x06, 0x00, 0x0C, 0x00,
  0x66, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x18,
  0x03, 0x00, 0x0E, 0x00, 0x63, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x60, 0x0C,
  0x00, 0x58, 0x07, 0x0C, 0x01, 0x80, 0x1B, 0x00, 0xC1, 0x80, 0x18, 0x06,
  0x60, 0x30, 0x30, 0x03, 0x83, 0x86, 0x1C, 0x06, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x40, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x78, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x07, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x04,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x04,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xA0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xC0, 0x07, 0xC0, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xF0, 0x60, 0x00, 0x1F, 0xFF, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x06, 0x3C, 0x00,
  0x00, 0x00, 0x8F, 0x80, 0x00, 0x00, 0x33, 0x98, 0x00, 0x00, 0x06, 0xC3,
  0x00, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x01, 0x40, 0x00, 0x00, 0x01,
  0xE0, 0x06, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x0D,
  0x80, 0x1B, 0x00, 0x00, 0x00, 0x32, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0x98, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x03, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x06, 0x20, 0x00, 0x00, 0x18, 0x80,
  0x08, 0x40, 0x00, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x0C,
  0x08, 0x00, 0x00, 0xC1, 0x80, 0x18, 0x10, 0x00, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x18, 0x04,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x08, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x61, 0x80, 0x02, 0x00, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x8C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x60, 0x00, 0x60, 0x06, 0x00, 0x07, 0x80, 0x00,
  0x80, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x02, 0x00, 0x68, 0x00, 0x00, 0x18, 0x01, 0xB0, 0x00, 0x00, 0x60,
  0x06, 0xC0, 0x00, 0x01, 0x80, 0x19, 0x00, 0x00, 0x06, 0x00, 0x46, 0x00,
  0x00, 0x10, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x20, 0x00, 0x03, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x00, 0x83, 0x00, 0x00, 0x20, 0x06, 0x04, 0x00,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x06, 0x00, 0x60, 0x60, 0x00, 0x18, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x04, 0x03, 0x00, 0x01, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x20, 0x03, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x02, 0x00,
  0x01, 0x80, 0x80, 0x18, 0x00, 0x06, 0x06, 0x00, 0x60, 0x00, 0x18, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x60, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x10, 0x00,
  0x03, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x30, 0x03, 0x00, 0x00, 0x18, 0xC0,
  0x0C, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x80, 0x00,
  0x03, 0x20, 0x06, 0x00, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x01, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xE8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xC0, 0x07, 0x80, 0x01, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x88, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x19,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x10, 0x00, 0x18, 0x20,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x80,
  0x03, 0x00, 0x80, 0x03, 0x01, 0x00, 0x06, 0x01, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x04, 0x00, 0x30, 0x06, 0x00, 0x30, 0x08, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x20, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x06, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x40, 0x38, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x38, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x01, 0x00, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x81, 0x83, 0x03, 0x02,
  0x06, 0x06, 0x0C, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0x00,
  0x70, 0x0C, 0x20, 0x0E, 0x00, 0x62, 0x01, 0x80, 0x03, 0x60, 0x30, 0x00,
  0x36, 0x06, 0x00, 0x01, 0x60, 0x60, 0x00, 0x14, 0x0C, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x06,
  0xC0, 0x60, 0x00, 0x68, 0x06, 0x00, 0x0C, 0x80, 0x70, 0x01, 0x98, 0x03,
  0x00, 0x71, 0x80, 0x1C, 0x1E, 0x18, 0x00, 0xFF, 0x81, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xC0,
  0x00, 0xC1, 0xFF, 0x80, 0x04, 0x38, 0x0E, 0x00, 0x63, 0x80, 0x18, 0x03,
  0x30, 0x00, 0x60, 0x1B, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x0C, 0x0D, 0x80,
  0x00, 0x60, 0x78, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x02, 0x80, 0x00, 0x30, 0x16, 0x00, 0x03,
  0x81, 0xB0, 0x00, 0x18, 0x0C, 0xC0, 0x03, 0x80, 0x63, 0x00, 0x38, 0x02,
  0x1E, 0x07, 0x80, 0x30, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x02, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x40, 0x0F, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x74, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xF0, 0x18, 0x00, 0x1F, 0xFC, 0x10, 0x00, 0x70,
  0x0E, 0x30, 0x00, 0xE0, 0x03, 0x30, 0x01, 0x80, 0x03, 0x30, 0x03, 0x00,
  0x01, 0xB0, 0x06, 0x00, 0x00, 0xA0, 0x06, 0x00, 0x00, 0xA0, 0x0C, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x10, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xC0, 0x00,
  0x36, 0x00, 0x40, 0x00, 0x64, 0x00, 0x60, 0x00, 0xC4, 0x00, 0x70, 0x01,
  0xCC, 0x00, 0x30, 0x03, 0x8C, 0x00, 0x1C, 0x0E, 0x08, 0x00, 0x0F, 0xFC,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x78, 0x0E, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x20, 0x00, 0x38, 0x60, 0x00, 0xE0, 0x60, 0x07, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x20,
  0x0F, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x0F,
  0xFE, 0x08, 0x00, 0x78, 0x0E, 0x10, 0x01, 0xC0, 0x06, 0x60, 0x06, 0x00,
  0x04, 0xC0, 0x18, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x0A, 0x00, 0xC0, 0x00,
  0x14, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x3C, 0x03, 0x00, 0x00, 0xF8, 0x06, 0x00,
  0x01, 0xA0, 0x04, 0x00, 0x06, 0x40, 0x0C, 0x00, 0x19, 0x80, 0x18, 0x00,
  0x73, 0x00, 0x18, 0x01, 0x86, 0x00, 0x1C, 0x0E, 0x08, 0x00, 0x1F, 0xF8,
  0x10, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x01, 0x83,
  0xFF, 0x00, 0x21, 0xC0, 0x30, 0x0C, 0x60, 0x03, 0x01, 0x98, 0x00, 0x30,
  0x36, 0x00, 0x06, 0x05, 0x80, 0x00, 0xC0, 0xA0, 0x00, 0x18, 0x3C, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x08,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x21, 0xE0, 0x00, 0x0C, 0x6C, 0x00, 0x01, 0x98,
  0x80, 0x00, 0x36, 0x18, 0x00, 0x05, 0x83, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x04, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x23,
  0x80, 0xE0, 0x70, 0x18, 0x03, 0x38, 0x03, 0x0E, 0x00, 0x60, 0x1B, 0x00,
  0x0C, 0x60, 0x03, 0x00, 0x98, 0x00, 0x66, 0x00, 0x0C, 0x05, 0x80, 0x01,
  0x60, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x87, 0x00, 0xC0, 0x18, 0xC0, 0x06,
  0x01, 0x98, 0x00, 0x30, 0x1B, 0x00, 0x03, 0x01, 0x60, 0x00, 0x30, 0x14,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x43, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x10, 0x3F, 0xF0, 0x00, 0x10, 0xE0, 0x38, 0x00, 0x31, 0xC0,
  0x0C, 0x00, 0x33, 0x80, 0x06, 0x00, 0x37, 0x00, 0x06, 0x00, 0x2E, 0x00,
  0x03, 0x00, 0x2C, 0x00, 0x03, 0x00, 0x78, 0x00, 0x03, 0x00, 0x78, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x05, 0x80, 0x00,
  0xE0, 0x0D, 0x80, 0x00, 0xC0, 0x0C, 0xC0, 0x03, 0x80, 0x0C, 0x60, 0x07,
  0x00, 0x0C, 0x78, 0x1E, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x08, 0x00, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0x84, 0x01, 0xC0, 0x06, 0x20,
  0x18, 0x00, 0x33, 0x01, 0x80, 0x00, 0xD8, 0x18, 0x00, 0x06, 0x80, 0xC0,
  0x00, 0x14, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x3C, 0x0C, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x1B, 0x01, 0x00, 0x01,
  0x90, 0x0C, 0x00, 0x1D, 0x80, 0x70, 0x01, 0xCC, 0x01, 0x80, 0x18, 0x60,
  0x07, 0x03, 0x82, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x01, 0x07, 0xF8,
  0x02, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x58, 0x00, 0x00, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x0F, 0x01,
  0x80, 0x01, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xF8, 0x07, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F,
  0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x80, 0x7F, 0x80, 0x0E, 0x00, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x04, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x06,
  0x81, 0x80, 0x00, 0x90, 0x30, 0x00, 0x36, 0x03, 0x00, 0x0C, 0xC0, 0x60,
  0x07, 0x10, 0x07, 0x03, 0xC2, 0x00, 0x7F, 0xE0, 0x40, 0x01, 0xC0, 0x10,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x02, 0x03,
  0x00, 0x04, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x02, 0x60, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xB0, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x04,
  0xC0, 0x03, 0x18, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x41, 0x80, 0x18, 0x20,
  0x06, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x0C, 0x08, 0x03, 0x03, 0x00,
  0x60, 0x40, 0x18, 0x18, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x30, 0x10, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x40, 0x10, 0x18, 0x06, 0x06, 0x00, 0x81, 0x80,
  0x30, 0x20, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01,
  0x06, 0x00, 0x61, 0x80, 0x08, 0x20, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18,
  0x40, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00, 0x88,
  0x00, 0x13, 0x00, 0x06, 0xC0, 0x00, 0x90, 0x00, 0x34, 0x00, 0x05, 0x80,
  0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x01, 0x40, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x78,
  0x3C, 0x00, 0x3E, 0x00, 0x70, 0x06, 0x80, 0x03, 0xF7, 0xC8, 0x00, 0x07,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 48, 14, 2, -48 },
  { 73, 14, 17, 20, 7, -48 },
  { 103, 34, 48, 35, 2, -48 },
  { 307, 29, 55, 32, 2, -51 },
  { 507, 37, 50, 45, 5, -49 },
  { 739, 33, 50, 37, 2, -49 },
  { 946, 5, 17, 11, 7, -48 },
  { 957, 19, 59, 16, 2, -48 },
  { 1098, 18, 59, 16, -4, -48 },
  { 1231, 24, 25, 30, 8, -51 },
  { 1306, 28, 31, 34, 4, -39 },
  { 1415, 9, 16, 12, -3, -7 },
  { 1433, 15, 2, 20, 2, -19 },
  { 1437, 3, 4, 13, 2, -4 },
  { 1439, 28, 48, 20, -3, -48 },
  { 1607, 28, 50, 32, 3, -49 },
  { 1782, 14, 48, 32, 10, -48 },
  { 1866, 30, 49, 32, 0, -49 },
  { 2050, 31, 50, 32, 0, -49 },
  { 2244, 30, 48, 32, 0, -48 },
  { 2424, 30, 49, 32, 1, -48 },
  { 2608, 29, 50, 32, 3, -49 },
  { 2790, 27, 48, 32, 6, -48 },
  { 2952, 29, 50, 32, 2, -49 },
  { 3134, 28, 50, 32, 2, -49 },
  { 3309, 11, 36, 13, 1, -36 },
  { 3359, 15, 45, 13, -3, -36 },
  { 3444, 28, 29, 34, 4, -39 },
  { 3546, 28, 15, 34, 4, -31 },
  { 3599, 28, 29, 34, 4, -39 },
  { 3701, 21, 49, 23, 4, -49 },
  { 3830, 43, 54, 48, 3, -48 },
  { 4121, 31, 48, 31, -4, -48 },
  { 4307, 32, 48, 35, 2, -48 },
  { 4499, 33, 50, 34, 4, -49 },
  { 4706, 35, 48, 39, 2, -48 },
  { 4916, 31, 48, 31, 2, -48 },
  { 5102, 31, 48, 28, 2, -48 },
  { 5288, 36, 50, 40, 4, -49 },
  { 5513, 38, 48, 40, 2, -48 },
  { 5741, 20, 48, 16, -1, -48 },
  { 5861, 25, 60, 14, -11, -48 },
  { 6049, 35, 48, 32, 2, -48 },
  { 6259, 21, 48, 28, 2, -48 },
  { 6385, 47, 48, 49, 2, -48 },
  { 6667, 38, 48, 40, 2, -48 },
  { 6895, 35, 50, 41, 4, -49 },
  { 7114, 31, 48, 32, 2, -48 },
  { 7300, 35, 60, 41, 4, -49 },
  { 7563, 31, 48, 33, 2, -48 },
  { 7749, 31, 50, 29, 0, -49 },
  { 7943, 28, 48, 28, 6, -48 },
  { 8111, 36, 49, 40, 4, -48 },
  { 8332, 29, 48, 31, 7, -48 },
  { 8506, 47, 48, 50, 7, -48 },
  { 8788, 37, 48, 28, -4, -48 },
  { 9010, 28, 48, 28, 6, -48 },
  { 9178, 34, 48, 30, -1, -48 },
  { 9382, 25, 59, 20, -1, -48 },
  { 9567, 9, 48, 21, 7, -48 },
  { 9621, 25, 59, 20, -5, -48 },
  { 9806, 28, 27, 33, 3, -48 },
  { 9901, 22, 2, 22, -5, 7 },
  { 9907, 7, 10, 15, 10, -51 },
  { 9916, 28, 37, 33, 3, -36 },
  { 10046, 29, 52, 33, 1, -51 },
  { 10235, 24, 37, 26, 3, -36 },
  { 10346, 32, 52, 33, 3, -51 },
  { 10554, 24, 37, 29, 3, -36 },
  { 10665, 34, 67, 16, -9, -51 },
  { 10950, 31, 52, 33, 1, -36 },
  { 11152, 27, 51, 32, 2, -51 },
  { 11325, 13, 48, 13, 1, -48 },
  { 11403, 23, 64, 13, -9, -48 },
  { 11587, 27, 51, 26, 1, -51 },
  { 11760, 13, 51, 12, 1, -51 },
  { 11843, 45, 36, 49, 1, -36 },
  { 12046, 28, 36, 32, 1, -36 },
  { 12172, 27, 37, 33, 3, -36 },
  { 12297, 32, 51, 33, -2, -36 },
  { 12501, 29, 52, 33, 3, -36 },
  { 12690, 23, 36, 21, 1, -36 },
  { 12794, 24, 37, 25, 0, -36 },
  { 12905, 16, 45, 18, 3, -44 },
  { 12995, 27, 36, 32, 3, -35 },
  { 13117, 23, 35, 24, 4, -35 },
  { 13218, 37, 35, 39, 4, -35 },
  { 13380, 30, 35, 26, -2, -35 },
  { 13512, 36, 51, 25, -8, -35 },
  { 13742, 26, 35, 24, -1, -35 },
  { 13856, 23, 59, 22, 2, -48 },
  { 14026, 1, 67, 31, 16, -51 },
  { 14035, 24, 59, 21, -4, -48 },
  { 14212, 28, 6, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC67PT7B_H_
