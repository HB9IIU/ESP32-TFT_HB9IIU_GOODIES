#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38,
  0x00, 0x30, 0x64, 0x08, 0x81, 0x10, 0x66, 0x0C, 0xC1, 0x10, 0x22, 0x04,
  0x41, 0x98, 0x22, 0x04, 0x40, 0x88, 0x11, 0x06, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x04, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x18, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x30,
  0x00, 0x18, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18,
  0x04, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1C,
  0x20, 0xC0, 0xC0, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40,
  0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03,
  0x02, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x34,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0x83, 0x00, 0x02, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x40, 0x60, 0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0xC0, 0x02, 0x06, 0x00, 0x08, 0x30, 0x30, 0x23, 0x80, 0xFF, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x30, 0xC0, 0x03,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x10, 0x01, 0x01, 0x00, 0x80, 0x18, 0x18,
  0x04, 0x00, 0x80, 0x80, 0x20, 0x08, 0x0C, 0x01, 0x00, 0xC0, 0x60, 0x08,
  0x04, 0x02, 0x00, 0x40, 0x40, 0x10, 0x02, 0x06, 0x01, 0x80, 0x30, 0x20,
  0x0C, 0x01, 0x83, 0x00, 0x40, 0x08, 0x30, 0x02, 0x00, 0x41, 0x00, 0x10,
  0x06, 0x18, 0x7C, 0x80, 0x31, 0x86, 0x34, 0x01, 0x08, 0x40, 0xE0, 0x18,
  0xC6, 0x07, 0x01, 0x8C, 0x60, 0x1C, 0x08, 0x42, 0x00, 0xB0, 0xC6, 0x30,
  0x04, 0xF8, 0x61, 0x80, 0x20, 0x02, 0x08, 0x01, 0x00, 0x30, 0xC0, 0x18,
  0x01, 0x06, 0x00, 0xC0, 0x10, 0x20, 0x06, 0x01, 0x81, 0x00, 0x20, 0x08,
  0x08, 0x01, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x40, 0x30,
  0x04, 0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x02, 0x02, 0x00, 0x20, 0x30,
  0x30, 0x01, 0x01, 0x03, 0x00, 0x0C, 0x10, 0x30, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x30, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x10, 0xC0, 0x20, 0x0C, 0x40, 0x0C, 0x02, 0x30, 0x01, 0x00,
  0x98, 0x00, 0x60, 0x46, 0x00, 0x08, 0x31, 0x00, 0x03, 0x08, 0xC0, 0x00,
  0x66, 0x30, 0x00, 0x0B, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x38, 0x10, 0x00, 0x1A, 0x06, 0x00, 0x0C, 0xC0, 0xC0, 0x0C, 0x10,
  0x38, 0x0E, 0x06, 0x03, 0xFE, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x32, 0x22,
  0x66, 0x44, 0x4C, 0x88, 0x88, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x80, 0x40, 0x30, 0x10,
  0x07, 0x04, 0x00, 0x62, 0x00, 0x06, 0x83, 0xC0, 0x7F, 0x80, 0x18, 0x00,
  0x09, 0x00, 0x04, 0x40, 0x06, 0x08, 0x03, 0x02, 0x01, 0x80, 0xC0, 0xC0,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00,
  0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0x03, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x20,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00,
  0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90,
  0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00,
  0xD0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x1A, 0x00,
  0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00,
  0x20, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x03, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x0F,
  0x83, 0x20, 0xC4, 0x60, 0x98, 0x34, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x78,
  0x1C, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x80, 0x01, 0x80, 0xF0, 0x07, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x84, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x10, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00,
  0x20, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x60, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x30, 0x00, 0x0F, 0xFF,
  0x00, 0x04, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x03, 0x00, 0xE0, 0x0E,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x70,
  0x10, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x3F, 0x80, 0x63, 0x83, 0x81, 0xB8, 0x03, 0x05, 0x80, 0x04, 0x14,
  0x00, 0x18, 0xE0, 0x00, 0x23, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00,
  0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x18,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0xC0,
  0x01, 0x81, 0x00, 0x04, 0x06, 0x00, 0x30, 0x08, 0x01, 0x80, 0x38, 0x1C,
  0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x06, 0x01,
  0x80, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x02, 0x00, 0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x06, 0x01,
  0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x31, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE3, 0x00, 0x03,
  0x81, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x30, 0x00, 0x20, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0x40, 0x30, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xE0, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0x60,
  0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x50, 0x60, 0x01, 0xE0, 0x60, 0x06, 0xC0, 0x60, 0x31, 0x00,
  0x7F, 0xC2, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x08, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x03, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xE0, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x0E, 0x06, 0x04, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x1F, 0x80,
  0x20, 0x80, 0x0E, 0x3C, 0x06, 0x30, 0x03, 0x01, 0x80, 0xC4, 0x01, 0x80,
  0x20, 0x19, 0x80, 0x20, 0x04, 0x03, 0x30, 0x0C, 0x01, 0x80, 0x64, 0x03,
  0x00, 0x20, 0x08, 0x80, 0x40, 0x04, 0x01, 0x30, 0x18, 0x01, 0x80, 0x26,
  0x02, 0x00, 0x30, 0x0C, 0x80, 0x40, 0x04, 0x01, 0x90, 0x18, 0x00, 0x80,
  0x22, 0x03, 0x00, 0x30, 0x04, 0xC0, 0x60, 0x06, 0x01, 0x98, 0x0C, 0x00,
  0x80, 0x23, 0x01, 0x80, 0x30, 0x0C, 0x60, 0x30, 0x0E, 0x01, 0x0C, 0x06,
  0x01, 0x40, 0x61, 0x80, 0x40, 0x4C, 0x18, 0x10, 0x0E, 0x38, 0x8E, 0x02,
  0x00, 0xFC, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60,
  0x00, 0x03, 0x10, 0x00, 0x01, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x20,
  0x20, 0x00, 0x30, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08,
  0x03, 0x00, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x04, 0x01, 0x80, 0x02, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x20, 0x00, 0x04, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x88, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0xFE, 0x00, 0x60,
  0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x20, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x40, 0x00, 0x20, 0x20, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x30, 0x00, 0x38, 0x18, 0x00, 0x30, 0x08, 0x03, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x7F, 0x00,
  0x06, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x10, 0x00, 0x10, 0x02, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x04, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x03,
  0x00, 0x07, 0x00, 0x60, 0x03, 0x80, 0x08, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFC,
  0x40, 0x01, 0xFF, 0xC4, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x07, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x01, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x00, 0x80, 0x01, 0x80, 0x10, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00,
  0x08, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x1E, 0x00, 0x00, 0x26, 0xC0, 0x00, 0x05, 0x88, 0x00, 0x01, 0xE1, 0x80,
  0x00, 0x38, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10,
  0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x00,
  0x02, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x1C, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x14, 0x00,
  0x00, 0x0F, 0x00, 0xA0, 0x00, 0x00, 0xD0, 0x0D, 0x80, 0x00, 0x04, 0x80,
  0x6C, 0x00, 0x00, 0x64, 0x02, 0x20, 0x00, 0x02, 0x60, 0x11, 0x00, 0x00,
  0x33, 0x00, 0x88, 0x00, 0x01, 0x10, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x62,
  0x00, 0x01, 0x84, 0x02, 0x18, 0x00, 0x0C, 0x60, 0x10, 0xC0, 0x00, 0xC3,
  0x01, 0x86, 0x00, 0x04, 0x10, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x40, 0x80,
  0x02, 0x0C, 0x02, 0x04, 0x00, 0x30, 0x60, 0x10, 0x20, 0x01, 0x02, 0x01,
  0x81, 0x00, 0x18, 0x10, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x40, 0x60, 0x08,
  0x0C, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x60, 0x10, 0x0C, 0x02, 0x02, 0x00, 0x80, 0x40, 0x10, 0x30, 0x0C,
  0x02, 0x00, 0x81, 0x00, 0x60, 0x30, 0x06, 0x18, 0x02, 0x01, 0x80, 0x30,
  0x80, 0x10, 0x0C, 0x00, 0x88, 0x00, 0x80, 0x40, 0x04, 0xC0, 0x0C, 0x02,
  0x00, 0x24, 0x00, 0x40, 0x30, 0x01, 0x60, 0x02, 0x01, 0x80, 0x0A, 0x00,
  0x10, 0x08, 0x00, 0x70, 0x01, 0x80, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x80, 0x50,
  0x00, 0x02, 0x01, 0x60, 0x00, 0x18, 0x05, 0x80, 0x00, 0x60, 0x32, 0x00,
  0x01, 0x00, 0xCC, 0x00, 0x04, 0x02, 0x30, 0x00, 0x10, 0x08, 0x40, 0x00,
  0xC0, 0x21, 0x80, 0x03, 0x01, 0x86, 0x00, 0x08, 0x06, 0x08, 0x00, 0x20,
  0x10, 0x30, 0x01, 0x80, 0x40, 0xC0, 0x06, 0x03, 0x01, 0x00, 0x10, 0x0C,
  0x06, 0x00, 0x40, 0x20, 0x18, 0x01, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x00, 0x80, 0x60, 0x04, 0x02, 0x01, 0x00, 0x18,
  0x08, 0x04, 0x00, 0x60, 0x60, 0x10, 0x00, 0x81, 0x80, 0xC0, 0x03, 0x04,
  0x03, 0x00, 0x0C, 0x10, 0x08, 0x00, 0x10, 0xC0, 0x20, 0x00, 0x63, 0x01,
  0x80, 0x01, 0x88, 0x06, 0x00, 0x02, 0x20, 0x18, 0x00, 0x0C, 0x80, 0x40,
  0x00, 0x16, 0x01, 0x00, 0x00, 0x58, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x83, 0xF0, 0x01, 0x80, 0x1C,
  0x01, 0x80, 0x0C, 0x01, 0x00, 0x06, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x08, 0x00, 0xE0, 0x18, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x83, 0xF0,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x04, 0x01, 0x00, 0x06, 0x01, 0x00, 0x02,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x38,
  0x08, 0x00, 0x60, 0x08, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x18, 0x04, 0x00,
  0x10, 0x06, 0x00, 0x10, 0x06, 0x00, 0x10, 0x02, 0x00, 0x30, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x60, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0xC0,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60,
  0x00, 0x0F, 0xFC, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x01, 0x80,
  0xE0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x01, 0x00, 0x60, 0x01, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20,
  0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x30, 0x20, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x11, 0x00, 0x00, 0x11, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x14, 0x00, 0x00, 0x14, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x48,
  0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0xD0, 0x00, 0x32, 0x00, 0x04, 0x80,
  0x01, 0x10, 0x00, 0x64, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x84, 0x00,
  0x11, 0x00, 0x0C, 0x20, 0x01, 0x88, 0x00, 0x41, 0x00, 0x08, 0x40, 0x02,
  0x08, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x04, 0x18, 0x01, 0x03, 0x00, 0x60,
  0xC0, 0x18, 0x18, 0x02, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x06,
  0x01, 0x01, 0x80, 0x40, 0x30, 0x08, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x0C, 0x04, 0x03, 0x01, 0x00, 0x60, 0x60, 0x18, 0x18, 0x03, 0x02,
  0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x40,
  0x06, 0x18, 0x00, 0x86, 0x00, 0x30, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00,
  0x21, 0x00, 0x04, 0x60, 0x01, 0x18, 0x00, 0x22, 0x00, 0x08, 0x80, 0x01,
  0x30, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x16,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00, 0x80, 0x08, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x40, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x00, 0x01, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x81, 0x00,
  0x06, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x20, 0x00, 0x0D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x10, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10,
  0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xD0, 0x00, 0x02, 0x40, 0x00, 0x19, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x08,
  0x00, 0x18, 0x30, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x18, 0x06, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x40, 0x01, 0x03, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0x98, 0x00, 0x03,
  0xC0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x86, 0x10, 0xC2, 0x18,
  0x41, 0x08, 0x00, 0x7F, 0x84, 0x03, 0x03, 0x10, 0x30, 0x06, 0x41, 0x80,
  0x0B, 0x04, 0x00, 0x38, 0x30, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x07, 0x04, 0x00, 0x3C, 0x10, 0x00, 0xA0, 0x60, 0x04, 0x80, 0x80,
  0x32, 0x03, 0x83, 0x08, 0x07, 0xF8, 0x60, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0xFE, 0x00,
  0x47, 0x07, 0x00, 0x98, 0x02, 0x03, 0x60, 0x06, 0x05, 0x80, 0x04, 0x0A,
  0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x60, 0x00, 0x61,
  0xC0, 0x00, 0x82, 0x80, 0x03, 0x05, 0x80, 0x0C, 0x09, 0x80, 0x30, 0x31,
  0x81, 0xC0, 0x61, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x1C,
  0x04, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x70, 0x18,
  0x03, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x86, 0x00,
  0x30, 0x39, 0x80, 0x30, 0x02, 0x40, 0x18, 0x00, 0xD0, 0x04, 0x00, 0x14,
  0x03, 0x00, 0x05, 0x01, 0x80, 0x01, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x04, 0x00, 0x14, 0x01, 0x00,
  0x0D, 0x00, 0x60, 0x06, 0x40, 0x08, 0x03, 0x30, 0x03, 0x83, 0x88, 0x00,
  0x7F, 0x82, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x60,
  0x30, 0x0C, 0x18, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0xC0,
  0x03, 0x20, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x31, 0x00, 0x38, 0xC0, 0x38,
  0x3F, 0xF8, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x3F, 0xE0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0x60, 0x71, 0x01, 0xC0,
  0x13, 0x03, 0x00, 0x1A, 0x02, 0x00, 0x0A, 0x06, 0x00, 0x0A, 0x0C, 0x00,
  0x0E, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x20, 0x00,
  0xA0, 0x20, 0x01, 0xA0, 0x30, 0x03, 0x60, 0x10, 0x06, 0x60, 0x1C, 0x1C,
  0x40, 0x0F, 0xF0, 0x40, 0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x0F, 0xF0, 0x08, 0xE0, 0xE0, 0x26, 0x00,
  0x81, 0xB0, 0x03, 0x05, 0x80, 0x0C, 0x14, 0x00, 0x10, 0x60, 0x00, 0x41,
  0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x01, 0x81, 0x00, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xCB, 0x00,
  0x04, 0xC8, 0x00, 0x2C, 0x60, 0x01, 0xC1, 0x00, 0x1C, 0x08, 0x00, 0xC0,
  0x60, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x01, 0x00,
  0xC0, 0x0C, 0x04, 0x00, 0x20, 0x20, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x02, 0x1F, 0xC0, 0x7F, 0x80, 0x46, 0x0C, 0x18, 0x18,
  0x09, 0x00, 0xC6, 0x01, 0x83, 0x40, 0x09, 0x80, 0x10, 0x50, 0x01, 0x60,
  0x02, 0x0E, 0x00, 0x28, 0x00, 0x41, 0x80, 0x07, 0x00, 0x08, 0x30, 0x00,
  0xC0, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x21, 0x80, 0x02, 0x00, 0x0C, 0x20,
  0x00, 0x40, 0x01, 0x84, 0x00, 0x18, 0x00, 0x21, 0x80, 0x03, 0x00, 0x04,
  0x30, 0x00, 0x40, 0x01, 0x84, 0x00, 0x08, 0x00, 0x30, 0x80, 0x03, 0x00,
  0x04, 0x10, 0x00, 0x60, 0x00, 0x86, 0x00, 0x08, 0x00, 0x10, 0xC0, 0x01,
  0x00, 0x06, 0x10, 0x00, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x00, 0x10, 0x40,
  0x01, 0x80, 0x02, 0x18, 0x00, 0x20, 0x00, 0x43, 0x00, 0x04, 0x00, 0x18,
  0x40, 0x00, 0x80, 0x03, 0x08, 0x00, 0x30, 0x00, 0x43, 0x00, 0x06, 0x00,
  0x08, 0x60, 0x00, 0x80, 0x03, 0x00, 0x02, 0x0F, 0xF0, 0x08, 0xC0, 0xE0,
  0x26, 0x00, 0x81, 0xB0, 0x03, 0x05, 0x80, 0x0C, 0x14, 0x00, 0x10, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00,
  0x7F, 0xC0, 0x03, 0x01, 0x80, 0x38, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x4C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x84,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x80,
  0xE0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x83, 0xF8, 0x00, 0x47,
  0x07, 0x00, 0x26, 0x00, 0x80, 0x36, 0x00, 0x60, 0x16, 0x00, 0x10, 0x0A,
  0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x70, 0x00, 0x20, 0x28, 0x00, 0x30, 0x16, 0x00,
  0x30, 0x09, 0x00, 0x30, 0x04, 0x60, 0x70, 0x06, 0x1F, 0xE0, 0x03, 0x01,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x82, 0x01, 0x81, 0xC4, 0x0C, 0x00, 0x98, 0x30, 0x01, 0xA0,
  0x40, 0x01, 0x41, 0x80, 0x02, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E,
  0x18, 0x00, 0x38, 0x10, 0x00, 0x50, 0x20, 0x01, 0xA0, 0x60, 0x06, 0xC0,
  0x40, 0x19, 0x80, 0xE0, 0xE2, 0x00, 0xFF, 0x04, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x02, 0x1F, 0xC0, 0x8C, 0x00,
  0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x70, 0x1C, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x10, 0x01, 0x83,
  0x80, 0x60, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x0F, 0xFF, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x1F, 0xC0, 0x30, 0x00, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80,
  0x01, 0x86, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xA0,
  0x40, 0x04, 0x81, 0x80, 0x26, 0x07, 0x03, 0x10, 0x07, 0xF8, 0x40, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0xCC,
  0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x08,
  0x01, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x80, 0x60, 0x18,
  0x18, 0x03, 0x02, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x86, 0x00, 0x10,
  0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0xB0, 0x01, 0x40, 0x04,
  0xC0, 0x0D, 0x00, 0x33, 0x00, 0x24, 0x00, 0x8C, 0x01, 0x90, 0x06, 0x30,
  0x04, 0x40, 0x10, 0xC0, 0x31, 0x00, 0x43, 0x00, 0x84, 0x02, 0x0C, 0x06,
  0x10, 0x08, 0x30, 0x10, 0x40, 0x60, 0xC0, 0xC1, 0x01, 0x01, 0x02, 0x04,
  0x0C, 0x04, 0x18, 0x10, 0x20, 0x10, 0x40, 0x61, 0x80, 0x43, 0x01, 0x84,
  0x01, 0x08, 0x06, 0x10, 0x04, 0x20, 0x18, 0x80, 0x11, 0x00, 0x62, 0x00,
  0x44, 0x00, 0x98, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x0B, 0x00, 0x16,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x03, 0x00, 0x03, 0x01, 0x00, 0x06,
  0x01, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30,
  0x00, 0x40, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x02, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x0C, 0x01, 0x00, 0x08, 0x01, 0x80, 0x10, 0x00, 0x80, 0x30, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x10, 0x0C, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0D, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x10, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x41, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0xF0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xE8, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x05, 0xC7, 0x80, 0x1C, 0x03, 0x80, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 38, 11, 1, -38 },
  { 49, 11, 14, 15, 6, -38 },
  { 69, 27, 38, 28, 1, -38 },
  { 198, 22, 43, 25, 2, -40 },
  { 317, 29, 39, 36, 4, -38 },
  { 459, 26, 39, 29, 1, -38 },
  { 586, 4, 14, 9, 6, -38 },
  { 593, 14, 46, 13, 2, -38 },
  { 674, 14, 46, 13, -3, -38 },
  { 755, 18, 19, 24, 7, -40 },
  { 798, 22, 24, 27, 3, -31 },
  { 864, 7, 13, 9, -2, -6 },
  { 876, 12, 1, 16, 2, -15 },
  { 878, 3, 3, 10, 1, -3 },
  { 880, 22, 38, 16, -2, -38 },
  { 985, 21, 39, 25, 3, -38 },
  { 1088, 11, 38, 25, 8, -38 },
  { 1141, 24, 38, 25, 0, -38 },
  { 1255, 24, 39, 25, 0, -38 },
  { 1372, 24, 38, 25, 0, -38 },
  { 1486, 24, 39, 25, 1, -38 },
  { 1603, 22, 39, 25, 3, -38 },
  { 1711, 21, 38, 25, 5, -38 },
  { 1811, 24, 39, 25, 1, -38 },
  { 1928, 23, 39, 25, 1, -38 },
  { 2041, 8, 28, 10, 1, -28 },
  { 2069, 11, 35, 10, -2, -28 },
  { 2118, 22, 23, 27, 3, -31 },
  { 2182, 22, 12, 27, 3, -25 },
  { 2215, 22, 23, 27, 3, -31 },
  { 2279, 17, 38, 18, 3, -38 },
  { 2360, 35, 43, 38, 2, -38 },
  { 2549, 25, 38, 25, -3, -38 },
  { 2668, 25, 38, 27, 2, -38 },
  { 2787, 25, 39, 27, 4, -38 },
  { 2909, 27, 38, 31, 2, -38 },
  { 3038, 24, 38, 25, 2, -38 },
  { 3152, 24, 38, 22, 2, -38 },
  { 3266, 28, 39, 32, 3, -38 },
  { 3403, 30, 38, 31, 2, -38 },
  { 3546, 16, 38, 13, -1, -38 },
  { 3622, 19, 47, 11, -8, -38 },
  { 3734, 27, 38, 25, 2, -38 },
  { 3863, 16, 38, 22, 2, -38 },
  { 3939, 37, 38, 38, 2, -38 },
  { 4115, 30, 38, 32, 2, -38 },
  { 4258, 28, 39, 33, 3, -38 },
  { 4395, 24, 38, 26, 2, -38 },
  { 4509, 28, 47, 33, 3, -38 },
  { 4674, 24, 38, 26, 2, -38 },
  { 4788, 24, 39, 23, 0, -38 },
  { 4905, 22, 38, 22, 5, -38 },
  { 5010, 28, 39, 31, 4, -38 },
  { 5147, 24, 38, 25, 5, -38 },
  { 5261, 37, 38, 39, 6, -38 },
  { 5437, 29, 38, 22, -3, -38 },
  { 5575, 22, 38, 22, 5, -38 },
  { 5680, 27, 38, 24, -1, -38 },
  { 5809, 20, 46, 15, -1, -38 },
  { 5924, 8, 38, 16, 5, -38 },
  { 5962, 20, 46, 15, -4, -38 },
  { 6077, 22, 21, 26, 2, -38 },
  { 6135, 17, 2, 18, -4, 5 },
  { 6140, 5, 9, 12, 8, -41 },
  { 6146, 22, 29, 26, 2, -28 },
  { 6226, 23, 41, 26, 1, -40 },
  { 6344, 19, 29, 20, 2, -28 },
  { 6413, 26, 41, 26, 2, -40 },
  { 6547, 18, 29, 23, 3, -28 },
  { 6613, 27, 54, 12, -7, -41 },
  { 6796, 24, 41, 26, 1, -28 },
  { 6919, 22, 40, 26, 1, -40 },
  { 7029, 10, 38, 10, 1, -38 },
  { 7077, 18, 51, 10, -7, -38 },
  { 7192, 21, 40, 21, 1, -40 },
  { 7297, 10, 40, 10, 1, -40 },
  { 7347, 35, 28, 39, 1, -28 },
  { 7470, 22, 28, 26, 1, -28 },
  { 7547, 22, 29, 26, 2, -28 },
  { 7627, 25, 40, 26, -1, -28 },
  { 7752, 23, 40, 26, 2, -28 },
  { 7867, 18, 28, 17, 1, -28 },
  { 7930, 19, 29, 20, 0, -28 },
  { 7999, 13, 36, 14, 2, -35 },
  { 8058, 22, 29, 26, 2, -28 },
  { 8138, 19, 28, 19, 3, -28 },
  { 8205, 30, 28, 31, 3, -28 },
  { 8310, 24, 28, 21, -2, -28 },
  { 8394, 28, 41, 19, -6, -28 },
  { 8538, 21, 28, 19, -1, -28 },
  { 8612, 18, 46, 17, 2, -38 },
  { 8716, 1, 53, 25, 13, -40 },
  { 8723, 19, 46, 17, -3, -38 },
  { 8833, 22, 5, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC53PT7B_H_
