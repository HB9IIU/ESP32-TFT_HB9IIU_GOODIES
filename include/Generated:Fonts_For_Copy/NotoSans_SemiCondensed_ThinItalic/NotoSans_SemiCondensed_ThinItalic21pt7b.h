#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x44, 0x44, 0x80, 0x00, 0x80, 0x4A, 0x95, 0x29,
  0x00, 0x04, 0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11, 0x02, 0x20, 0x88,
  0x11, 0x0F, 0xBA, 0x48, 0x11, 0x02, 0x20, 0x48, 0x11, 0x00, 0x04, 0x02,
  0x07, 0xE4, 0x84, 0x42, 0x41, 0x20, 0x70, 0x08, 0x06, 0x04, 0x82, 0x41,
  0x20, 0x93, 0x70, 0x40, 0x20, 0x00, 0x78, 0x69, 0x0A, 0x22, 0x44, 0x88,
  0x91, 0x14, 0x25, 0x3C, 0xA9, 0xEA, 0x21, 0x44, 0x48, 0x91, 0x12, 0x42,
  0x84, 0xA0, 0xE0, 0x0F, 0x04, 0x42, 0x10, 0x84, 0x21, 0x05, 0x81, 0x80,
  0xA0, 0x48, 0x61, 0x18, 0x2A, 0x0C, 0x81, 0x20, 0xCF, 0xC8, 0x56, 0x80,
  0x08, 0x84, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x86, 0x00,
  0x18, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x08, 0x84, 0x44, 0x00,
  0x10, 0x22, 0x43, 0x73, 0x0A, 0x22, 0x04, 0x08, 0x04, 0x02, 0x01, 0x0F,
  0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x29, 0x48, 0xF0, 0x80, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x00, 0x0F, 0x08, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x02,
  0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x21, 0xE0, 0x19, 0xB4, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x00, 0x0F, 0x08, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0xF8, 0x0F,
  0x84, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x10, 0x78, 0x01, 0x00, 0x40,
  0x08, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48,
  0x48, 0x44, 0x42, 0x21, 0x20, 0xBF, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x0F,
  0xC4, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x8F, 0xC0, 0x0F, 0x88, 0x08, 0x04, 0x04, 0x02,
  0x01, 0xF8, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x11, 0xF0, 0xFF,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x80, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x09, 0x08, 0x58, 0x78, 0x42,
  0x41, 0x20, 0x50, 0x28, 0x24, 0x11, 0xF0, 0x1E, 0x10, 0x90, 0x28, 0x14,
  0x0A, 0x05, 0x04, 0x86, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x40, 0x43, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x10, 0x88, 0x40, 0x01, 0x83, 0x06, 0x04, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x7C, 0x04, 0x08, 0x10, 0x20,
  0x82, 0x08, 0x20, 0x81, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x20,
  0x41, 0x00, 0x88, 0x02, 0x43, 0x85, 0x11, 0x18, 0x84, 0x62, 0x11, 0x90,
  0x8A, 0x42, 0x29, 0x08, 0xA4, 0x64, 0x8E, 0x62, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x1F, 0x80, 0x01, 0x00, 0x40, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88,
  0x42, 0x1F, 0x88, 0x22, 0x09, 0x01, 0x40, 0x60, 0x18, 0x04, 0x1F, 0x08,
  0x22, 0x04, 0x81, 0x20, 0x50, 0x24, 0x11, 0xF8, 0x41, 0x10, 0x28, 0x0A,
  0x02, 0x81, 0x20, 0x8F, 0xC0, 0x07, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x0F, 0xC0, 0x1F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01,
  0x40, 0x50, 0x18, 0x06, 0x02, 0x81, 0x20, 0x8F, 0xC0, 0x1F, 0x90, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x04, 0xFC, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xF0, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0xFC, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x1C, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x24,
  0x04, 0x81, 0x0F, 0xE0, 0x10, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x47, 0xFC, 0x40, 0x44, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88,
  0x08, 0x80, 0x80, 0x1C, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x0E, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x23, 0x80, 0x10, 0x64, 0x10, 0x84,
  0x11, 0x02, 0x40, 0x90, 0x14, 0x03, 0x40, 0x48, 0x08, 0x82, 0x10, 0x42,
  0x08, 0x21, 0x04, 0x20, 0x40, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x0F, 0xC0, 0x10, 0x04, 0x40, 0x13, 0x00, 0xCC, 0x05,
  0x30, 0x15, 0x20, 0xA4, 0x82, 0x92, 0x12, 0x48, 0x89, 0x22, 0x48, 0x91,
  0x22, 0x44, 0x86, 0x12, 0x18, 0x48, 0x42, 0x00, 0x10, 0x11, 0x02, 0x30,
  0x22, 0x82, 0x28, 0x24, 0x82, 0x44, 0x44, 0x44, 0x44, 0x44, 0x24, 0x82,
  0x48, 0x28, 0x81, 0x88, 0x18, 0x80, 0x80, 0x0F, 0xC2, 0x04, 0x80, 0x90,
  0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x24,
  0x08, 0x81, 0x0F, 0xC0, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02,
  0x86, 0x7C, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x0F, 0xC2, 0x04,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x24, 0x08, 0x83, 0x0E, 0x80, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x1F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x04, 0x84, 0x7C, 0x22, 0x21,
  0x10, 0x48, 0x24, 0x12, 0x08, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xC0,
  0xFF, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20,
  0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80,
  0x84, 0x10, 0x3E, 0x00, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x12, 0x11,
  0x08, 0x88, 0x24, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x00, 0x81, 0x03, 0x02,
  0x06, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x88,
  0x91, 0x11, 0x22, 0x42, 0x82, 0x85, 0x06, 0x0A, 0x0C, 0x08, 0x10, 0x10,
  0x20, 0x00, 0x10, 0x21, 0x08, 0x21, 0x04, 0x40, 0x50, 0x0A, 0x01, 0x80,
  0x20, 0x0A, 0x01, 0x40, 0x48, 0x10, 0x84, 0x10, 0x82, 0x20, 0x40, 0x81,
  0xC0, 0xA0, 0x90, 0x84, 0x42, 0x41, 0x20, 0xA0, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0, 0x0F,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0xF0, 0x92, 0x44, 0x92, 0x48, 0x92, 0x48, 0x1E,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x11, 0xE0, 0x04, 0x05, 0x02, 0x82, 0x42, 0x11, 0x09, 0x05, 0x01,
  0xFE, 0x94, 0x1E, 0x90, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82,
  0x43, 0x1E, 0x80, 0x08, 0x08, 0x04, 0x02, 0x01, 0x21, 0x6C, 0xC2, 0x41,
  0x20, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x05, 0x7C, 0x1E, 0x41, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x87, 0xA2, 0x19, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20,
  0x88, 0x61, 0xE8, 0x1E, 0x45, 0x0A, 0x18, 0xDE, 0x20, 0x40, 0x81, 0x01,
  0xF0, 0x00, 0xE0, 0x20, 0x08, 0x01, 0x00, 0x20, 0x1F, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x0E, 0x00, 0x0F, 0x44, 0x32, 0x09, 0x02, 0x40,
  0x90, 0x24, 0x09, 0x04, 0x41, 0x10, 0xC3, 0xD0, 0x04, 0x02, 0x00, 0x80,
  0x43, 0xE0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x21, 0x6C, 0xC2, 0x41, 0x20,
  0x90, 0x50, 0x28, 0x24, 0x12, 0x09, 0x05, 0x02, 0x10, 0x00, 0x22, 0x22,
  0x24, 0x44, 0x44, 0x80, 0x02, 0x00, 0x00, 0x00, 0x20, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x87, 0x00, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x04, 0x84, 0x44, 0x24, 0x14, 0x16, 0x0D, 0x04,
  0x42, 0x21, 0x09, 0x04, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48,
  0x2F, 0x3C, 0xC3, 0x12, 0x08, 0x48, 0x21, 0x21, 0x05, 0x04, 0x14, 0x10,
  0x50, 0x41, 0x41, 0x09, 0x08, 0x28, 0x20, 0x80, 0x2F, 0x98, 0x48, 0x24,
  0x12, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x20, 0xA0, 0x40, 0x1E, 0x21, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x17, 0xC6, 0x11, 0x04,
  0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x25, 0xF1, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x1E, 0x90, 0xD0, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x04, 0x82, 0x43, 0x1E, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x2E, 0x60,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x3E, 0x81, 0x02, 0x02,
  0x03, 0x01, 0x02, 0x04, 0x0B, 0xE0, 0x21, 0x09, 0xB4, 0x21, 0x08, 0x84,
  0x21, 0x08, 0x70, 0x40, 0xA0, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x09, 0x04,
  0x82, 0x43, 0x3E, 0x80, 0x83, 0x82, 0x84, 0x84, 0x88, 0x88, 0x50, 0x50,
  0x60, 0x60, 0x40, 0x84, 0x18, 0x42, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24,
  0x92, 0x8A, 0x28, 0xA3, 0x04, 0x30, 0x82, 0x00, 0x10, 0xC4, 0x21, 0x10,
  0x28, 0x0C, 0x02, 0x00, 0xC0, 0x50, 0x22, 0x10, 0x88, 0x10, 0x10, 0x22,
  0x08, 0x41, 0x08, 0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x3F, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x41, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0C, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x21, 0xC0, 0xFF, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 4, 1, -15 },
  { 9, 5, 5, 6, 2, -15 },
  { 13, 11, 15, 11, 0, -15 },
  { 34, 9, 17, 10, 1, -16 },
  { 54, 11, 15, 14, 2, -15 },
  { 75, 10, 15, 12, 1, -15 },
  { 94, 2, 5, 3, 2, -15 },
  { 96, 5, 18, 5, 1, -15 },
  { 108, 5, 18, 5, -1, -15 },
  { 120, 7, 8, 10, 3, -16 },
  { 127, 9, 9, 11, 1, -12 },
  { 138, 3, 5, 4, -1, -2 },
  { 140, 4, 1, 6, 1, -6 },
  { 141, 1, 1, 4, 1, -1 },
  { 142, 9, 15, 6, -1, -15 },
  { 159, 9, 15, 10, 1, -15 },
  { 176, 5, 15, 10, 3, -15 },
  { 186, 9, 15, 10, 0, -15 },
  { 203, 10, 15, 10, 0, -15 },
  { 222, 9, 15, 10, 0, -15 },
  { 239, 10, 15, 10, 0, -15 },
  { 258, 9, 15, 10, 1, -15 },
  { 275, 8, 15, 10, 2, -15 },
  { 290, 9, 15, 10, 1, -15 },
  { 307, 9, 15, 10, 1, -15 },
  { 324, 4, 11, 4, 0, -11 },
  { 330, 5, 14, 4, -1, -11 },
  { 339, 9, 9, 11, 1, -12 },
  { 350, 9, 5, 11, 1, -10 },
  { 356, 9, 9, 11, 1, -12 },
  { 367, 7, 15, 7, 1, -15 },
  { 381, 14, 17, 15, 1, -15 },
  { 411, 10, 15, 10, -1, -15 },
  { 430, 10, 15, 11, 1, -15 },
  { 449, 11, 15, 11, 1, -15 },
  { 470, 10, 15, 12, 1, -15 },
  { 489, 9, 15, 10, 1, -15 },
  { 506, 9, 15, 9, 1, -15 },
  { 523, 11, 15, 13, 1, -15 },
  { 544, 12, 15, 12, 1, -15 },
  { 567, 6, 15, 5, 0, -15 },
  { 579, 7, 19, 4, -3, -15 },
  { 596, 11, 15, 10, 1, -15 },
  { 617, 6, 15, 9, 1, -15 },
  { 629, 14, 15, 15, 1, -15 },
  { 656, 12, 15, 13, 1, -15 },
  { 679, 11, 15, 13, 1, -15 },
  { 700, 9, 15, 10, 1, -15 },
  { 717, 11, 19, 13, 1, -15 },
  { 744, 9, 15, 10, 1, -15 },
  { 761, 10, 15, 9, 0, -15 },
  { 780, 9, 15, 9, 2, -15 },
  { 797, 12, 15, 12, 1, -15 },
  { 820, 9, 15, 10, 2, -15 },
  { 837, 15, 15, 16, 2, -15 },
  { 866, 11, 15, 9, -1, -15 },
  { 887, 9, 15, 9, 2, -15 },
  { 904, 10, 15, 10, 0, -15 },
  { 923, 8, 18, 6, 0, -15 },
  { 941, 3, 15, 7, 2, -15 },
  { 947, 7, 18, 6, -1, -15 },
  { 963, 9, 8, 10, 1, -15 },
  { 972, 7, 1, 7, -2, 2 },
  { 973, 2, 3, 5, 3, -16 },
  { 974, 9, 11, 10, 1, -11 },
  { 987, 9, 16, 10, 0, -16 },
  { 1005, 7, 11, 8, 1, -11 },
  { 1015, 10, 16, 10, 1, -16 },
  { 1035, 7, 11, 9, 1, -11 },
  { 1045, 11, 21, 5, -3, -16 },
  { 1074, 10, 16, 10, 0, -11 },
  { 1094, 9, 16, 10, 0, -16 },
  { 1112, 4, 15, 4, 0, -15 },
  { 1120, 7, 20, 4, -3, -15 },
  { 1138, 9, 16, 8, 0, -16 },
  { 1156, 4, 16, 4, 0, -16 },
  { 1164, 14, 11, 15, 0, -11 },
  { 1184, 9, 11, 10, 0, -11 },
  { 1197, 8, 11, 10, 1, -11 },
  { 1208, 10, 16, 10, -1, -11 },
  { 1228, 9, 16, 10, 1, -11 },
  { 1246, 7, 11, 7, 0, -11 },
  { 1256, 7, 11, 8, 0, -11 },
  { 1266, 5, 14, 6, 1, -14 },
  { 1275, 9, 11, 10, 1, -11 },
  { 1288, 8, 11, 8, 1, -11 },
  { 1299, 12, 11, 12, 1, -11 },
  { 1316, 10, 11, 8, -1, -11 },
  { 1330, 11, 16, 8, -2, -11 },
  { 1352, 8, 11, 8, 0, -11 },
  { 1363, 7, 18, 7, 1, -15 },
  { 1379, 1, 21, 10, 5, -16 },
  { 1382, 7, 18, 7, -1, -15 },
  { 1398, 9, 1, 11, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC21PT7B_H_
