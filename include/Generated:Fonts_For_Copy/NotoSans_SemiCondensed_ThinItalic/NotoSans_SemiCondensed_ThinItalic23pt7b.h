#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x00, 0x08, 0x4A, 0x52, 0x99,
  0x48, 0x04, 0x40, 0x88, 0x21, 0x04, 0x46, 0xFE, 0x21, 0x04, 0x40, 0x88,
  0x11, 0x04, 0x23, 0xFF, 0x11, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x02,
  0x01, 0xC1, 0xAC, 0x90, 0x24, 0x11, 0x02, 0x40, 0xD0, 0x08, 0x03, 0x80,
  0x90, 0x24, 0x11, 0x04, 0x41, 0x23, 0xF0, 0x10, 0x08, 0x00, 0x30, 0x14,
  0x82, 0x44, 0x28, 0x44, 0x84, 0x88, 0x48, 0x89, 0x08, 0xA7, 0x8A, 0x99,
  0x51, 0x69, 0x10, 0x91, 0x12, 0x12, 0x21, 0x22, 0x14, 0x22, 0xC1, 0xC0,
  0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80, 0x60, 0x18,
  0x04, 0x81, 0x10, 0xC1, 0x28, 0x25, 0x03, 0x20, 0x44, 0x14, 0x7C, 0x40,
  0x55, 0xA0, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x04, 0x00, 0x08,
  0x08, 0xD0, 0x3F, 0x30, 0x48, 0x88, 0x04, 0x04, 0x01, 0x00, 0x40, 0x10,
  0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x29, 0x28, 0xF8, 0x80,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x02, 0x21, 0x08,
  0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81,
  0x20, 0x48, 0x22, 0x08, 0x7C, 0x00, 0x19, 0x72, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x07, 0x86, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x00, 0x07, 0x83, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x0C, 0x0E, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0xFE, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x05, 0x02, 0x41, 0x20, 0x48, 0x22,
  0x10, 0x88, 0x24, 0x11, 0x04, 0xFF, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x0F, 0xE1, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x0F, 0x80, 0x0C, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x47, 0xF0, 0x03, 0xC3,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x78, 0x61, 0x10, 0x28, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x11, 0x08, 0x3C, 0x00, 0x7F, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x4C,
  0x1C, 0x08, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x7C, 0x00,
  0x0E, 0x08, 0xC8, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0x91, 0xC7,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x42, 0x00,
  0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x00, 0x3C, 0x42,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x07, 0xF8, 0x10, 0x08, 0x40, 0x11, 0x00, 0x12, 0x1C,
  0x28, 0x44, 0x51, 0x08, 0xC4, 0x11, 0x88, 0x43, 0x10, 0x8A, 0x21, 0x14,
  0x46, 0x28, 0x95, 0x90, 0xC4, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F,
  0x80, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10,
  0x47, 0xF2, 0x04, 0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x1F, 0xC2, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x21, 0xF8, 0x40, 0x88, 0x11, 0x01,
  0x20, 0x28, 0x09, 0x01, 0x20, 0x47, 0xF0, 0x03, 0xC1, 0x84, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0x02, 0x20, 0x22,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x04, 0x80, 0x48, 0x08, 0x83, 0x0F, 0xC0, 0x1F, 0xC4, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0xF8, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x7F, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03,
  0xC0, 0xC3, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x3C, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x84, 0x08, 0x3F,
  0x80, 0x10, 0x08, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x87, 0xFC, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x10, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x1E, 0x00, 0x10, 0x31, 0x04, 0x20, 0x82, 0x10, 0x22, 0x02,
  0x40, 0x28, 0x05, 0x80, 0x64, 0x04, 0x40, 0x44, 0x08, 0x20, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x10, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x10, 0x03, 0x10, 0x02, 0x28, 0x06,
  0x28, 0x0A, 0x28, 0x0A, 0x28, 0x12, 0x28, 0x14, 0x48, 0x24, 0x48, 0x24,
  0x44, 0x44, 0x44, 0x44, 0x84, 0x88, 0x85, 0x08, 0x85, 0x08, 0x86, 0x08,
  0x82, 0x08, 0x10, 0x08, 0x80, 0x4A, 0x04, 0x50, 0x22, 0x41, 0x12, 0x08,
  0x90, 0x88, 0x44, 0x42, 0x22, 0x11, 0x10, 0x49, 0x02, 0x88, 0x14, 0x40,
  0x62, 0x03, 0x10, 0x10, 0x07, 0x83, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0,
  0x24, 0x08, 0x7E, 0x00, 0x1F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x05, 0x06, 0x7E, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x07, 0x83, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x24, 0x08, 0x76, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x1F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x09, 0x04, 0x7E, 0x11, 0x04, 0x21, 0x08, 0x82, 0x20, 0x48, 0x12,
  0x04, 0x07, 0x81, 0x0C, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0xFE,
  0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x20, 0x14, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x81, 0x07, 0xE0, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x81, 0x20, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04, 0x81, 0x20,
  0x50, 0x14, 0x06, 0x01, 0x00, 0x81, 0x03, 0x83, 0x02, 0x83, 0x02, 0x85,
  0x04, 0x85, 0x04, 0x89, 0x08, 0x89, 0x08, 0x89, 0x10, 0x91, 0x10, 0x91,
  0x20, 0xA1, 0x20, 0xA1, 0x20, 0xC1, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x08, 0x10, 0x82, 0x08, 0x40, 0x44, 0x04, 0x80, 0x50, 0x05, 0x00,
  0x20, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x21, 0x04, 0x08, 0x40, 0x88,
  0x08, 0x80, 0xE0, 0x44, 0x11, 0x08, 0x42, 0x11, 0x04, 0x80, 0xA0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x1F, 0xE0, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x07, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0xF0, 0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x07,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x06, 0x01,
  0x80, 0x90, 0x44, 0x11, 0x08, 0x24, 0x09, 0x02, 0x80, 0x40, 0xFF, 0x89,
  0x10, 0x1F, 0x48, 0x64, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x20, 0xC8, 0x51, 0xE8, 0x08, 0x02, 0x01, 0x00, 0x40, 0x11, 0x05, 0xA1,
  0x84, 0x41, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x09, 0x84,
  0x9E, 0x00, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x44, 0x36, 0x88, 0x32,
  0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0xC4, 0x28,
  0x79, 0x00, 0x1F, 0x21, 0x41, 0x41, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x7E, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0F,
  0x80, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x0C, 0x00, 0x0F, 0xA2, 0x0C, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12,
  0x04, 0x40, 0x88, 0x31, 0x0A, 0x1E, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10,
  0xC4, 0x07, 0x00, 0x10, 0x08, 0x08, 0x04, 0x02, 0x21, 0x68, 0xC2, 0x41,
  0x40, 0xA0, 0x50, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x00, 0x08,
  0x40, 0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x31, 0x10, 0x88, 0x24, 0x0A, 0x03, 0x81, 0x90,
  0x44, 0x11, 0x04, 0x21, 0x08, 0x81, 0x00, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x17, 0x9E, 0x28, 0xA1, 0x10, 0x41,
  0x20, 0x41, 0x20, 0x81, 0x20, 0x82, 0x40, 0x82, 0x40, 0x82, 0x41, 0x02,
  0x41, 0x02, 0x41, 0x04, 0x81, 0x04, 0x17, 0x8A, 0x11, 0x04, 0x81, 0x20,
  0x48, 0x14, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x04, 0x1F, 0x10, 0x50,
  0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x8F, 0x80, 0x0B,
  0xC1, 0x84, 0x20, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x08, 0xC2, 0x27, 0x84, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x00, 0x1F,
  0x48, 0x34, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0xC8,
  0x51, 0xE4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x17, 0x28, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1F, 0x20, 0x40,
  0x20, 0x20, 0x18, 0x04, 0x02, 0x02, 0x02, 0x02, 0xFC, 0x21, 0x09, 0xF4,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x43, 0xC0, 0x20, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x21, 0x8F, 0x40, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x44, 0x48, 0x48, 0x50, 0x60, 0x60, 0x40, 0x82, 0x0C, 0x10,
  0x61, 0x85, 0x0C, 0x28, 0x92, 0x44, 0x92, 0x45, 0x12, 0x28, 0xA1, 0x45,
  0x0C, 0x10, 0x40, 0x82, 0x00, 0x10, 0x62, 0x10, 0x22, 0x04, 0x80, 0xA0,
  0x08, 0x03, 0x00, 0x50, 0x12, 0x04, 0x41, 0x04, 0x40, 0x80, 0x08, 0x18,
  0x40, 0x82, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05,
  0x00, 0x28, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x1F, 0x80, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x40, 0x30, 0xFF, 0xFF, 0xFE, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0xC0, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 7, 2, -16 },
  { 13, 11, 16, 12, 1, -16 },
  { 35, 10, 18, 11, 1, -17 },
  { 58, 12, 17, 16, 2, -17 },
  { 84, 11, 17, 13, 1, -17 },
  { 108, 2, 6, 4, 2, -16 },
  { 110, 6, 20, 6, 1, -16 },
  { 125, 7, 20, 6, -2, -16 },
  { 143, 8, 8, 10, 3, -17 },
  { 151, 10, 10, 12, 1, -13 },
  { 164, 3, 5, 4, -1, -2 },
  { 166, 5, 1, 7, 1, -7 },
  { 167, 1, 1, 4, 1, -1 },
  { 168, 10, 16, 7, -1, -16 },
  { 188, 10, 17, 11, 1, -17 },
  { 210, 5, 16, 11, 3, -16 },
  { 220, 10, 17, 11, 0, -17 },
  { 242, 11, 17, 11, 0, -17 },
  { 266, 10, 17, 11, 0, -17 },
  { 288, 11, 16, 11, 0, -16 },
  { 310, 10, 17, 11, 1, -17 },
  { 332, 9, 16, 11, 2, -16 },
  { 350, 10, 17, 11, 1, -17 },
  { 372, 9, 17, 11, 1, -17 },
  { 392, 4, 12, 4, 0, -12 },
  { 398, 5, 15, 4, -1, -12 },
  { 408, 10, 10, 12, 1, -13 },
  { 421, 10, 6, 12, 1, -11 },
  { 429, 10, 10, 12, 1, -13 },
  { 442, 8, 17, 8, 1, -17 },
  { 459, 15, 18, 16, 1, -16 },
  { 493, 10, 16, 11, -1, -16 },
  { 513, 11, 16, 12, 1, -16 },
  { 535, 11, 17, 12, 2, -17 },
  { 559, 12, 16, 13, 1, -16 },
  { 583, 10, 16, 11, 1, -16 },
  { 603, 10, 16, 10, 1, -16 },
  { 623, 12, 17, 14, 2, -17 },
  { 649, 13, 16, 14, 1, -16 },
  { 675, 7, 16, 5, 0, -16 },
  { 689, 9, 20, 5, -4, -16 },
  { 712, 12, 16, 11, 1, -16 },
  { 736, 7, 16, 10, 1, -16 },
  { 750, 16, 16, 17, 1, -16 },
  { 782, 13, 16, 14, 1, -16 },
  { 808, 11, 17, 14, 2, -17 },
  { 832, 10, 16, 11, 1, -16 },
  { 852, 11, 21, 14, 2, -17 },
  { 881, 10, 16, 11, 1, -16 },
  { 901, 11, 17, 10, 0, -17 },
  { 925, 10, 16, 10, 2, -16 },
  { 945, 12, 16, 14, 2, -16 },
  { 969, 10, 16, 11, 2, -16 },
  { 989, 16, 16, 17, 3, -16 },
  { 1021, 12, 16, 10, -1, -16 },
  { 1045, 10, 16, 10, 2, -16 },
  { 1065, 11, 16, 10, 0, -16 },
  { 1087, 8, 20, 7, 0, -16 },
  { 1107, 4, 16, 7, 2, -16 },
  { 1115, 9, 20, 7, -2, -16 },
  { 1138, 10, 9, 11, 1, -16 },
  { 1150, 8, 1, 8, -2, 2 },
  { 1151, 3, 4, 5, 3, -18 },
  { 1153, 10, 12, 11, 1, -12 },
  { 1168, 10, 17, 11, 0, -17 },
  { 1190, 8, 12, 9, 1, -12 },
  { 1202, 11, 17, 11, 1, -17 },
  { 1226, 8, 12, 10, 1, -12 },
  { 1238, 12, 24, 5, -3, -18 },
  { 1274, 11, 18, 11, 0, -12 },
  { 1299, 9, 17, 11, 1, -17 },
  { 1319, 5, 17, 4, 0, -17 },
  { 1330, 8, 23, 4, -3, -17 },
  { 1353, 10, 17, 9, 0, -17 },
  { 1375, 5, 17, 4, 0, -17 },
  { 1386, 16, 12, 17, 0, -12 },
  { 1410, 10, 12, 11, 0, -12 },
  { 1425, 9, 12, 11, 1, -12 },
  { 1439, 11, 17, 11, -1, -12 },
  { 1463, 10, 17, 11, 1, -12 },
  { 1485, 8, 12, 7, 0, -12 },
  { 1497, 8, 12, 8, 0, -12 },
  { 1509, 5, 15, 6, 1, -15 },
  { 1519, 9, 12, 11, 1, -12 },
  { 1533, 8, 12, 8, 1, -12 },
  { 1545, 13, 12, 13, 1, -12 },
  { 1565, 11, 12, 9, -1, -12 },
  { 1582, 13, 18, 8, -3, -12 },
  { 1612, 9, 12, 8, 0, -12 },
  { 1626, 8, 20, 7, 1, -16 },
  { 1646, 1, 23, 11, 5, -17 },
  { 1649, 8, 20, 7, -1, -16 },
  { 1669, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC23PT7B_H_
