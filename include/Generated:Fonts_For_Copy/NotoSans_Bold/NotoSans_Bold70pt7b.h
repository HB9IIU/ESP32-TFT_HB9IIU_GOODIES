#ifndef _NOTOSANS_BOLD70PT7B_H_
#define _NOTOSANS_BOLD70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0xC7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07,
  0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0,
  0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB,
  0xFF, 0x8F, 0xFF, 0x1E, 0x07, 0xE3, 0xFF, 0x87, 0x80, 0x18, 0xFF, 0xC1,
  0xE0, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x03, 0xFF,
  0x87, 0x80, 0x00, 0xFF, 0xF9, 0xE0, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7B, 0xFF, 0xF0, 0x00, 0x1E, 0x7F, 0xFC, 0x00, 0x07, 0x87, 0xFF, 0x00,
  0x01, 0xE0, 0xFF, 0xC0, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x1E, 0x0F, 0xFF,
  0x80, 0x07, 0x83, 0xFF, 0xFC, 0x01, 0xE1, 0xFF, 0xFF, 0xF0, 0x79, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xE7, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x87, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x01, 0xFC,
  0x00, 0xE7, 0xE0, 0x3F, 0x01, 0xF9, 0xFF, 0x8F, 0xC7, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x03, 0xFC, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0xC1, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0x8F, 0xFE, 0x7F, 0x87, 0xFF, 0x1F,
  0x83, 0xFF, 0x87, 0x01, 0xFF, 0xC1, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xC0,
  0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xF8, 0x08, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xFF,
  0xC1, 0xF0, 0x00, 0x7F, 0xF8, 0x30, 0x00, 0x0F, 0xFE, 0x08, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xE0, 0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFB, 0x00, 0x00, 0x1F, 0xFE, 0xF0,
  0x00, 0x0F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFF,
  0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xFF,
  0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xE0,
  0x00, 0x70, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xC1,
  0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x1F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xFC, 0x07, 0xF8,
  0x0F, 0xE7, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xF8,
  0x01, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xBF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xEF, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFB, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFC, 0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFE, 0x01,
  0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xFF, 0xE7,
  0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0x81, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x01, 0xFF, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x81, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x00,
  0x3F, 0xF7, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xB0, 0x7F, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xE3,
  0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xBF, 0xFF, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xE7, 0xFC,
  0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xFF, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x7F,
  0x8F, 0xFF, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xDF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x01,
  0xFF, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFE,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x1F,
  0xFE, 0x00, 0x1F, 0x0F, 0xFE, 0x00, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFB, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF1, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xC7,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF0, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0x80, 0xF0, 0x00, 0xFF, 0xF0, 0x10, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF,
  0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x41, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x47, 0xFF, 0x80, 0x03, 0x8F,
  0xFF, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xF3, 0xFF, 0x07,
  0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0,
  0x3F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F,
  0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0x03,
  0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x3F, 0xFE, 0x00, 0x03,
  0x81, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFF,
  0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF,
  0x3F, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F,
  0xFF, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0x80, 0x00, 0x1F, 0xFE,
  0x3F, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFD,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0x8F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xBF,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03,
  0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F,
  0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF8,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF,
  0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xF8,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x7C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xC7,
  0xFE, 0x00, 0x06, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x10, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFD, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFE,
  0x00, 0x7F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x8F, 0xF0, 0x3F, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xF8, 0x0F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x7F, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF7, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xFF, 0x80,
  0x00, 0x13, 0xFF, 0xFC, 0x00, 0x0D, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xEC,
  0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_Bold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 12, 51, 20, 4, -50 },
  { 78, 25, 18, 34, 4, -50 },
  { 135, 42, 50, 45, 2, -50 },
  { 398, 34, 57, 40, 3, -53 },
  { 641, 59, 52, 63, 2, -51 },
  { 1025, 50, 52, 53, 3, -51 },
  { 1350, 10, 18, 19, 4, -50 },
  { 1373, 19, 61, 24, 3, -50 },
  { 1518, 19, 61, 24, 2, -50 },
  { 1663, 34, 33, 38, 2, -53 },
  { 1804, 34, 34, 40, 3, -42 },
  { 1949, 14, 17, 20, 2, -8 },
  { 1979, 18, 9, 22, 2, -23 },
  { 2000, 12, 12, 20, 4, -11 },
  { 2018, 29, 50, 29, 0, -50 },
  { 2200, 34, 52, 40, 3, -51 },
  { 2421, 25, 50, 40, 4, -50 },
  { 2578, 35, 51, 40, 3, -51 },
  { 2802, 34, 52, 40, 3, -51 },
  { 3023, 38, 50, 40, 1, -50 },
  { 3261, 34, 51, 40, 3, -50 },
  { 3478, 36, 52, 40, 2, -51 },
  { 3712, 36, 50, 40, 2, -50 },
  { 3937, 36, 52, 40, 2, -51 },
  { 4171, 36, 52, 40, 2, -51 },
  { 4405, 12, 40, 20, 4, -39 },
  { 4465, 14, 48, 20, 2, -39 },
  { 4549, 34, 37, 40, 3, -44 },
  { 4707, 34, 21, 40, 3, -35 },
  { 4797, 34, 37, 40, 3, -44 },
  { 4955, 32, 52, 33, 0, -51 },
  { 5163, 57, 56, 63, 3, -50 },
  { 5562, 48, 50, 48, 0, -50 },
  { 5862, 37, 50, 47, 6, -50 },
  { 6094, 39, 52, 45, 4, -51 },
  { 6348, 41, 50, 51, 6, -50 },
  { 6605, 29, 50, 39, 6, -50 },
  { 6787, 29, 50, 38, 6, -50 },
  { 6969, 41, 52, 51, 4, -51 },
  { 7236, 41, 50, 54, 6, -50 },
  { 7493, 23, 50, 27, 2, -50 },
  { 7637, 22, 65, 23, -5, -50 },
  { 7816, 40, 50, 46, 6, -50 },
  { 8066, 31, 50, 39, 6, -50 },
  { 8260, 54, 50, 66, 6, -50 },
  { 8598, 45, 50, 57, 6, -50 },
  { 8880, 47, 52, 55, 4, -51 },
  { 9186, 35, 50, 43, 6, -50 },
  { 9405, 47, 63, 55, 4, -51 },
  { 9776, 40, 50, 46, 6, -50 },
  { 10026, 33, 52, 39, 3, -51 },
  { 10241, 38, 50, 40, 1, -50 },
  { 10479, 41, 51, 53, 6, -50 },
  { 10741, 46, 50, 46, 0, -50 },
  { 11029, 68, 50, 68, 0, -50 },
  { 11454, 47, 50, 47, 0, -50 },
  { 11748, 44, 50, 44, 0, -50 },
  { 12023, 37, 50, 41, 2, -50 },
  { 12255, 16, 61, 23, 5, -50 },
  { 12377, 29, 50, 29, 0, -50 },
  { 12559, 16, 61, 23, 2, -50 },
  { 12681, 36, 32, 40, 2, -50 },
  { 12825, 29, 5, 29, 0, 6 },
  { 12844, 20, 12, 26, 3, -54 },
  { 12874, 34, 40, 42, 3, -39 },
  { 13044, 36, 54, 44, 5, -53 },
  { 13287, 31, 40, 36, 3, -39 },
  { 13442, 36, 54, 44, 3, -53 },
  { 13685, 36, 40, 42, 3, -39 },
  { 13865, 29, 54, 27, 1, -54 },
  { 14061, 36, 56, 44, 3, -39 },
  { 14313, 36, 53, 46, 5, -53 },
  { 14552, 11, 53, 21, 5, -53 },
  { 14625, 20, 70, 21, -4, -53 },
  { 14800, 38, 53, 43, 5, -53 },
  { 15052, 11, 53, 21, 5, -53 },
  { 15125, 58, 39, 68, 5, -39 },
  { 15408, 36, 39, 46, 5, -39 },
  { 15584, 37, 40, 44, 3, -39 },
  { 15769, 36, 56, 44, 5, -39 },
  { 16021, 36, 56, 44, 3, -39 },
  { 16273, 25, 39, 31, 5, -39 },
  { 16395, 29, 40, 35, 3, -39 },
  { 16540, 26, 47, 30, 2, -46 },
  { 16693, 35, 39, 46, 5, -38 },
  { 16864, 40, 38, 40, 0, -38 },
  { 17054, 58, 38, 60, 1, -38 },
  { 17330, 40, 38, 40, 0, -38 },
  { 17520, 40, 55, 40, 0, -38 },
  { 17795, 30, 38, 35, 2, -38 },
  { 17938, 24, 61, 28, 1, -50 },
  { 18121, 7, 69, 39, 16, -53 },
  { 18182, 24, 61, 28, 3, -50 },
  { 18365, 34, 12, 40, 3, -31 },
};

const GFXfont NotoSans_Bold70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold70pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_BOLD70PT7B_H_
