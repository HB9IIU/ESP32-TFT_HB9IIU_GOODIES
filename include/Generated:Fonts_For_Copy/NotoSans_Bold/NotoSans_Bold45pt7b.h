#ifndef _NOTOSANS_BOLD45PT7B_H_
#define _NOTOSANS_BOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E,
  0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xF9, 0xC1, 0xCF,
  0xE7, 0x00, 0x3F, 0x9C, 0x00, 0xFE, 0x70, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xDF, 0xF0, 0x07, 0x3F, 0xC0,
  0x1C, 0x7F, 0x80, 0x71, 0xFF, 0x01, 0xC7, 0xFF, 0xC7, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x01,
  0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x1F,
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0xFC, 0x3E, 0x07, 0xC3, 0xE3, 0xE3,
  0xFE, 0x1F, 0x9F, 0x9F, 0x9F, 0xFC, 0x3F, 0xFE, 0x7C, 0xFF, 0xF8, 0xFF,
  0xF3, 0xF3, 0xFF, 0xE1, 0xFF, 0x8F, 0x8F, 0x8F, 0xC3, 0xFC, 0x7E, 0x7E,
  0x1F, 0x01, 0x81, 0xF1, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00,
  0x7E, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x07, 0xC0, 0x07,
  0xC0, 0x7E, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x1F,
  0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0x81, 0xFC, 0x7F, 0xBF, 0xC3, 0xF8, 0xFF,
  0x1F, 0xE3, 0xF8, 0xFE, 0x0F, 0xF7, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0xFE,
  0x03, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE3, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x80,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x07, 0x07, 0x83, 0x9F, 0xDE, 0x7F, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7F, 0x01, 0xE0, 0xE0, 0x01, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7E, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF9,
  0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x7C, 0x7F, 0x38, 0x7F, 0x30, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0x8F, 0x00, 0xFE,
  0x18, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xC0, 0x7F, 0x8C, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x03, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0x87,
  0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0x7C, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x84,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x40, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFB, 0x00, 0x1F, 0xEF, 0x80, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0xFF, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xCF, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x7F, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F,
  0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xF7, 0xFC, 0x7F, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0xF7,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0xFC, 0x7F, 0xFD, 0xF8, 0x7F, 0xF3,
  0xF0, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3E,
  0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E,
  0x08, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF0, 0x1F, 0xC6, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0xFF,
  0x83, 0xE3, 0xF0, 0x7F, 0xFE, 0x3E, 0x3E, 0x0F, 0xFF, 0xE1, 0xF7, 0xC1,
  0xFF, 0xFE, 0x1F, 0x7C, 0x3F, 0x83, 0xE1, 0xF7, 0xC3, 0xF0, 0x3E, 0x1F,
  0xF8, 0x7E, 0x03, 0xE1, 0xFF, 0x87, 0xE0, 0x3E, 0x0F, 0xF8, 0x7C, 0x03,
  0xE1, 0xFF, 0x87, 0xC0, 0x7E, 0x1F, 0xF8, 0x7C, 0x07, 0xE1, 0xFF, 0x87,
  0xC0, 0x7E, 0x1F, 0xF8, 0x7C, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0xFE, 0x3E,
  0xF8, 0x3F, 0x1F, 0xE7, 0xE7, 0xC3, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F, 0xFD,
  0xFF, 0x87, 0xC0, 0xFF, 0x8F, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x80,
  0x0F, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x07,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFE, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0x80, 0x08, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x7F,
  0xF0, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x07, 0xFC, 0xFE, 0x00,
  0x7F, 0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x7F, 0xE3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0xFF, 0x80,
  0x04, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF3,
  0xFC, 0x01, 0xFC, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xA3, 0xFE, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x7C, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x3E, 0xFF, 0xF7, 0xE0,
  0x1F, 0xBF, 0xFC, 0xF8, 0x07, 0xCF, 0xFF, 0x3F, 0x01, 0xF3, 0xFF, 0xCF,
  0xC0, 0xFC, 0xFF, 0xF1, 0xF0, 0x3E, 0x3F, 0xFC, 0x7C, 0x0F, 0x8F, 0xFF,
  0x1F, 0x87, 0xE3, 0xFF, 0xC7, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7C, 0x3F,
  0xFC, 0x3F, 0x3F, 0x0F, 0xFF, 0x0F, 0xCF, 0x83, 0xFF, 0xC1, 0xF3, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF0,
  0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xC7,
  0xF0, 0x3F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x87, 0xF8,
  0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x03, 0xF8, 0x7F,
  0xF8, 0x0F, 0xE3, 0xFF, 0xC0, 0x7F, 0x9F, 0xFE, 0x01, 0xFC, 0xFF, 0xF0,
  0x0F, 0xF7, 0xFF, 0x80, 0x3F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0x00, 0x38,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFE, 0x0F, 0x8F, 0xE0, 0x0C, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x1F, 0xE7, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xBE, 0x01, 0xF8,
  0x1F, 0x80, 0xFB, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xBF, 0x03, 0xF8, 0x1F,
  0xC1, 0xF9, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF1, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF0,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0xFC,
  0xFE, 0x00, 0x7E, 0x7E, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x7C, 0xFC,
  0x00, 0x3F, 0x7E, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x00,
  0x3F, 0x7C, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x0F, 0xE0, 0x80, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF, 0xFF, 0x3F, 0x1F, 0xF0,
  0x7C, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x03, 0xF9, 0xFF, 0x87, 0xF7, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0x7F, 0xC0, 0xFE, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFC, 0xFF, 0xE1,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x7C, 0x7F, 0x80, 0x47, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x27, 0xFC, 0x0E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF1, 0xFC, 0x3F,
  0xFB, 0xF8, 0xFF, 0xFB, 0xF3, 0xFF, 0xF7, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xBF, 0x0F, 0xFE, 0x7E, 0x0F, 0xF8, 0x7C, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x20, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7E, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0x07, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE6, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x83, 0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x7D,
  0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03,
  0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F,
  0xC0, 0xFC, 0x7F, 0x80, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x9F, 0xFF, 0xBF, 0xEF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F,
  0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0xFC, 0x1F, 0xC1, 0xF8, 0xFF, 0xE3, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFD, 0xFF, 0xBF, 0xE0, 0x7F, 0x7F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xFE, 0x1F,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0x7F, 0xF0,
  0xFE, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x7E, 0x0F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFC, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0x07, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x1F, 0xFE, 0x3F, 0xBF,
  0x3F, 0xDF, 0xBF, 0xEF, 0xDF, 0xF7, 0xFF, 0xFB, 0xFF, 0xC5, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFC, 0x07, 0x3F, 0x80, 0x27, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF, 0x8F,
  0xFF, 0x3F, 0x0F, 0xF8, 0x3E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xF0, 0x1F, 0x9F, 0xC0, 0x7F, 0xC0, 0x7E, 0x3F, 0x01,
  0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x83, 0xCF, 0x87, 0xF0, 0x7E, 0x1F,
  0x3E, 0x1F, 0x81, 0xFC, 0x7C, 0xF8, 0x7E, 0x03, 0xF1, 0xF1, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC7, 0xCF, 0xE0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFE, 0xF8,
  0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x07, 0xEF, 0x83, 0xEF, 0x80,
  0x1F, 0xBC, 0x0F, 0xFE, 0x00, 0x3E, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x04, 0xFF,
  0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x03, 0xFF, 0xA0, 0x01, 0xF0,
};

const GFXglyph NotoSans_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 33, 13, 2, -32 },
  { 34, 16, 11, 22, 3, -32 },
  { 56, 27, 32, 29, 1, -32 },
  { 164, 22, 37, 26, 2, -34 },
  { 266, 38, 33, 41, 1, -33 },
  { 423, 32, 33, 34, 2, -33 },
  { 555, 6, 11, 12, 3, -32 },
  { 564, 12, 39, 15, 2, -32 },
  { 623, 12, 39, 15, 1, -32 },
  { 682, 22, 21, 24, 1, -34 },
  { 740, 22, 22, 26, 2, -27 },
  { 801, 9, 11, 13, 1, -5 },
  { 814, 12, 6, 14, 1, -15 },
  { 823, 8, 8, 13, 2, -7 },
  { 831, 18, 32, 19, 0, -32 },
  { 903, 22, 33, 26, 2, -33 },
  { 994, 16, 32, 26, 3, -32 },
  { 1058, 22, 33, 26, 2, -33 },
  { 1149, 22, 33, 26, 2, -33 },
  { 1240, 24, 32, 26, 1, -32 },
  { 1336, 22, 32, 26, 2, -32 },
  { 1424, 22, 32, 26, 2, -32 },
  { 1512, 23, 32, 26, 1, -32 },
  { 1604, 22, 33, 26, 2, -33 },
  { 1695, 23, 32, 26, 1, -32 },
  { 1787, 8, 26, 13, 2, -25 },
  { 1813, 9, 31, 13, 1, -25 },
  { 1848, 22, 24, 26, 2, -28 },
  { 1914, 22, 14, 26, 2, -23 },
  { 1953, 22, 24, 26, 2, -28 },
  { 2019, 21, 34, 21, 0, -33 },
  { 2109, 36, 36, 40, 2, -32 },
  { 2271, 31, 32, 31, 0, -32 },
  { 2395, 24, 32, 30, 4, -32 },
  { 2491, 26, 33, 29, 2, -33 },
  { 2599, 27, 32, 33, 4, -32 },
  { 2707, 19, 32, 25, 4, -32 },
  { 2783, 18, 32, 25, 4, -32 },
  { 2855, 26, 33, 33, 3, -33 },
  { 2963, 26, 32, 34, 4, -32 },
  { 3067, 15, 32, 18, 1, -32 },
  { 3127, 14, 41, 15, -3, -32 },
  { 3199, 26, 32, 30, 4, -32 },
  { 3303, 20, 32, 25, 4, -32 },
  { 3383, 34, 32, 42, 4, -32 },
  { 3519, 29, 32, 37, 4, -32 },
  { 3635, 31, 33, 36, 2, -33 },
  { 3763, 22, 32, 28, 4, -32 },
  { 3851, 31, 41, 36, 2, -33 },
  { 4010, 26, 32, 30, 4, -32 },
  { 4114, 21, 33, 25, 2, -33 },
  { 4201, 24, 32, 26, 1, -32 },
  { 4297, 26, 32, 34, 4, -32 },
  { 4401, 29, 32, 29, 0, -32 },
  { 4517, 44, 32, 44, 0, -32 },
  { 4693, 30, 32, 30, 0, -32 },
  { 4813, 28, 32, 28, 0, -32 },
  { 4925, 24, 32, 26, 1, -32 },
  { 5021, 11, 39, 15, 3, -32 },
  { 5075, 18, 32, 19, 0, -32 },
  { 5147, 11, 39, 15, 1, -32 },
  { 5201, 24, 21, 26, 1, -32 },
  { 5264, 19, 3, 19, 0, 4 },
  { 5272, 13, 7, 16, 2, -34 },
  { 5284, 22, 25, 27, 2, -25 },
  { 5353, 23, 34, 28, 3, -34 },
  { 5451, 20, 25, 23, 2, -25 },
  { 5514, 23, 34, 28, 2, -34 },
  { 5612, 23, 25, 27, 2, -25 },
  { 5684, 18, 34, 17, 1, -34 },
  { 5761, 23, 36, 28, 2, -25 },
  { 5865, 23, 34, 29, 3, -34 },
  { 5963, 7, 34, 13, 3, -34 },
  { 5993, 12, 45, 13, -2, -34 },
  { 6061, 24, 34, 28, 4, -34 },
  { 6163, 7, 34, 13, 3, -34 },
  { 6193, 38, 25, 44, 3, -25 },
  { 6312, 23, 25, 29, 3, -25 },
  { 6384, 24, 25, 28, 2, -25 },
  { 6459, 23, 36, 28, 3, -25 },
  { 6563, 23, 36, 28, 2, -25 },
  { 6667, 17, 25, 20, 3, -25 },
  { 6721, 19, 25, 23, 2, -25 },
  { 6781, 17, 30, 20, 1, -30 },
  { 6845, 23, 25, 29, 3, -25 },
  { 6917, 26, 25, 26, 0, -25 },
  { 6999, 38, 25, 39, 0, -25 },
  { 7118, 26, 25, 26, 0, -25 },
  { 7200, 26, 36, 26, 0, -25 },
  { 7317, 20, 25, 22, 1, -25 },
  { 7380, 15, 39, 18, 1, -32 },
  { 7454, 5, 44, 25, 10, -34 },
  { 7482, 15, 39, 18, 2, -32 },
  { 7556, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_Bold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold45pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_BOLD45PT7B_H_
