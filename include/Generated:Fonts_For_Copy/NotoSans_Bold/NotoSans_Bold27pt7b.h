#ifndef _NOTOSANS_BOLD27PT7B_H_
#define _NOTOSANS_BOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x00, 0x0F, 0xFF,
  0xDE, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x07, 0x1C, 0x07,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFB, 0xCC, 0x5E, 0x60,
  0xFB, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x0D, 0xF0,
  0x6F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0xFC, 0x07, 0x81, 0xFC, 0x0E, 0x07, 0xBC, 0x3C,
  0x0E, 0x38, 0x70, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x80, 0x71, 0xCE, 0x00,
  0xE3, 0x9C, 0xF1, 0xEF, 0x73, 0xF1, 0xFD, 0xEF, 0xF1, 0xF3, 0x9C, 0xE0,
  0x8F, 0x79, 0xC0, 0x1C, 0xF3, 0xC0, 0x71, 0xE7, 0x80, 0xE3, 0xCE, 0x03,
  0x83, 0x9C, 0x07, 0x07, 0x78, 0x1C, 0x0F, 0xE0, 0x78, 0x0F, 0x80, 0x01,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xC7, 0x80, 0x70,
  0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0x3F, 0xE1, 0xEF, 0x9F, 0x79, 0xE1, 0xFF, 0x3C, 0x1F, 0xC7, 0xC1,
  0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF1, 0xF0, 0xFE,
  0xEE, 0xEE, 0xE0, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x80,
  0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE3,
  0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x0C, 0x73, 0x7F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0x80,
  0xFE, 0x0F, 0x78, 0xF3, 0xC1, 0x88, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x7B, 0xDD, 0xEF, 0x70, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF,
  0xE7, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x0F, 0x78, 0xF1, 0xFF, 0x8F,
  0xF8, 0x3F, 0x80, 0x07, 0x87, 0xCF, 0xEF, 0xFF, 0xFF, 0xBD, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x02, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x70, 0xF8, 0x81, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x06, 0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xF6, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x07, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0x80, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0x3C,
  0x1C, 0x78, 0x78, 0xF0, 0xE1, 0xE3, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF8, 0x1F, 0xFF,
  0xF7, 0xFF, 0x1F, 0xF0, 0x00, 0x40, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x20, 0xF7, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE,
  0x1E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFE, 0x1E, 0x78, 0xF9, 0xFF, 0xE3,
  0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x02, 0x00, 0xFF, 0x1F, 0xFC, 0xFB, 0xF7, 0x87, 0xB8, 0x3D, 0xE1,
  0xEF, 0x9E, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0xFF, 0xE7, 0x8F, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xDF, 0xFC, 0x3F, 0xC0, 0x02, 0x00,
  0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC7, 0xDF, 0xFE, 0xFF, 0x73, 0xF3, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x73, 0xFE, 0xF2, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBD, 0xDE, 0xF7, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x1E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x0F, 0x00, 0x60, 0x00, 0x02, 0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x60, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x1F, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x38,
  0xE3, 0xFC, 0xE7, 0x1F, 0xF1, 0xDC, 0xF1, 0xC7, 0x73, 0x87, 0x1F, 0x8E,
  0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3, 0x87, 0x3B, 0x8F, 0x7F,
  0xE7, 0x1F, 0xFF, 0x1C, 0x3C, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x01, 0x01,
  0xF8, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07,
  0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7,
  0x83, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3E,
  0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x40, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3F, 0x0E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xF7, 0xE0, 0x4F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0x7E, 0x1E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xDF, 0xC7, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF7, 0xFB, 0xF9,
  0xF8, 0xF0, 0x00, 0xF8, 0x1F, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0xF9, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF9, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x3C, 0xF8, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xDC, 0x1D, 0xFE, 0xE0, 0xEF, 0xF7, 0x87, 0x7F, 0x9C, 0x73,
  0xFC, 0xE3, 0x9F, 0xE7, 0x9C, 0xFF, 0x1D, 0xC7, 0xF8, 0xEE, 0x3F, 0xC7,
  0xF1, 0xFE, 0x3F, 0x8F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1E,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFD,
  0xE0, 0xFF, 0x7C, 0x3F, 0xCF, 0x0F, 0xF3, 0xE3, 0xFC, 0x78, 0xFF, 0x1F,
  0x3F, 0xC3, 0xCF, 0xF0, 0x7B, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xF3,
  0xC0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7,
  0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x3F, 0x1F, 0x83,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x3E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1F,
  0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x3F, 0x1F, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0x02, 0x00, 0xFF, 0x8F, 0xFE,
  0xFF, 0xE7, 0x83, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF,
  0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xDE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xF7, 0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x1E,
  0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE3, 0xC7, 0xF8, 0xF0, 0xF1, 0xCE,
  0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x1C, 0xF3, 0xC1, 0xEF, 0x3C, 0xE0, 0x7B,
  0xC7, 0x78, 0x1E, 0xE1, 0xDE, 0x03, 0xB8, 0x77, 0x80, 0xEE, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0xFC, 0x0F, 0xCF, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x0F, 0x3E,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xCF, 0x01, 0xE3, 0xE0, 0xF8,
  0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xBC, 0x07,
  0x9F, 0x07, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xFF, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x1D, 0xC0, 0x77,
  0x03, 0x8E, 0x0E, 0x38, 0x70, 0x71, 0xC1, 0xCE, 0x03, 0xB8, 0x0F, 0xFF,
  0xFF, 0xFC, 0xF8, 0x78, 0x3C, 0x1E, 0x07, 0x0F, 0xC1, 0xFF, 0x8F, 0xFE,
  0x20, 0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xEF, 0xFF, 0x7C, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFF, 0xFF, 0xBF, 0xDC, 0xFC, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFC, 0xFF, 0xFB,
  0xF3, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x7B, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0xE7, 0xE0, 0x07, 0xE1, 0xFF,
  0x3F, 0xF7, 0xC6, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC3, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF3, 0xCF, 0xFF, 0x7F, 0xFD,
  0xF3, 0xF7, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0x78, 0x3D, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x9C, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x02, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x00,
  0x03, 0x83, 0xFC, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F, 0xE7, 0xFC, 0xFF,
  0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x0F, 0x1C, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F,
  0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x83,
  0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0x00, 0x3D, 0x01,
  0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFC, 0xFF, 0xFB, 0xF3, 0xEF,
  0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x2F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x3C, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0xFF, 0xFB, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0x78, 0x3C, 0xF0, 0xF1, 0xE3,
  0xC3, 0xCF, 0x87, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7D, 0xF0,
  0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xE7, 0x83, 0xEF, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xE1, 0xF3,
  0xFF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0x9F, 0xF8, 0x7C, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xC0, 0xE3, 0xE3, 0xBF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xE3, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x79, 0xE0, 0xF3, 0xE3, 0xE3, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0xE3,
  0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7B, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBE, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF,
  0x7E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x1C, 0xFF, 0xF7, 0xFF, 0xDF, 0x1F, 0x78, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x83, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0xE3, 0xF9, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0xCF, 0xFD, 0xFF,
  0xF8, 0x2F, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x1C, 0x0F, 0x03, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0x3F, 0xC7, 0xF0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x3F, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0xF0,
  0x1D, 0xE0, 0x3B, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x7C, 0x1E, 0xF0, 0xF8, 0x3D, 0xE1, 0xF0, 0xF3, 0xC3, 0x71, 0xE7,
  0x8E, 0xE3, 0xC7, 0x9D, 0xCF, 0x0F, 0x3B, 0x9E, 0x1E, 0xF3, 0xBC, 0x1D,
  0xC7, 0x70, 0x3B, 0x8E, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1E, 0xF8, 0x78,
  0xF1, 0xF0, 0xF3, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF3, 0xC3, 0xC7, 0xCF, 0x87, 0xBE, 0x07,
  0x80, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x70, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x8F, 0xC3, 0xC0, 0xFC, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x0F, 0xC3, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x0F, 0x07, 0xE0, 0xF1, 0xF8, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x8F, 0xC7, 0xC3, 0xE0, 0x3C, 0x0F, 0xF8, 0xFF, 0xFF,
  0x8F, 0xF8, 0x0E, 0x00,
};

const GFXglyph NotoSans_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 8, 1, -19 },
  { 13, 9, 7, 13, 2, -19 },
  { 21, 16, 19, 17, 1, -19 },
  { 59, 13, 23, 15, 1, -21 },
  { 97, 23, 20, 24, 1, -20 },
  { 155, 19, 20, 20, 1, -20 },
  { 203, 4, 7, 7, 2, -19 },
  { 207, 7, 23, 9, 1, -19 },
  { 228, 7, 23, 9, 1, -19 },
  { 249, 13, 13, 15, 1, -21 },
  { 271, 13, 13, 15, 1, -16 },
  { 293, 5, 6, 8, 1, -3 },
  { 297, 7, 3, 9, 1, -9 },
  { 300, 5, 4, 8, 1, -4 },
  { 303, 11, 19, 11, 0, -19 },
  { 330, 13, 20, 15, 1, -20 },
  { 363, 9, 19, 15, 2, -19 },
  { 385, 14, 20, 15, 1, -20 },
  { 420, 13, 20, 15, 1, -20 },
  { 453, 15, 19, 15, 0, -19 },
  { 489, 13, 19, 15, 1, -19 },
  { 520, 14, 20, 15, 1, -20 },
  { 555, 14, 19, 15, 1, -19 },
  { 589, 13, 20, 15, 1, -20 },
  { 622, 13, 20, 15, 1, -20 },
  { 655, 5, 15, 8, 1, -15 },
  { 665, 5, 18, 8, 1, -15 },
  { 677, 13, 14, 15, 1, -17 },
  { 700, 13, 8, 15, 1, -14 },
  { 713, 13, 14, 15, 1, -17 },
  { 736, 12, 20, 13, 0, -20 },
  { 766, 22, 21, 24, 1, -19 },
  { 824, 19, 19, 19, 0, -19 },
  { 870, 15, 19, 18, 2, -19 },
  { 906, 16, 20, 17, 1, -20 },
  { 946, 16, 19, 20, 2, -19 },
  { 984, 12, 19, 15, 2, -19 },
  { 1013, 11, 19, 15, 2, -19 },
  { 1040, 15, 20, 20, 2, -20 },
  { 1078, 16, 19, 21, 2, -19 },
  { 1116, 9, 19, 11, 1, -19 },
  { 1138, 9, 25, 9, -2, -19 },
  { 1167, 16, 19, 18, 2, -19 },
  { 1205, 12, 19, 15, 2, -19 },
  { 1234, 21, 19, 25, 2, -19 },
  { 1284, 18, 19, 22, 2, -19 },
  { 1327, 19, 20, 21, 1, -20 },
  { 1375, 14, 19, 17, 2, -19 },
  { 1409, 19, 25, 21, 1, -20 },
  { 1469, 16, 19, 18, 2, -19 },
  { 1507, 13, 20, 15, 1, -20 },
  { 1540, 14, 19, 16, 1, -19 },
  { 1574, 16, 19, 20, 2, -19 },
  { 1612, 18, 19, 18, 0, -19 },
  { 1655, 26, 19, 26, 0, -19 },
  { 1717, 18, 19, 18, 0, -19 },
  { 1760, 17, 19, 17, 0, -19 },
  { 1801, 14, 19, 16, 1, -19 },
  { 1835, 6, 23, 9, 2, -19 },
  { 1853, 11, 19, 11, 0, -19 },
  { 1880, 6, 23, 9, 1, -19 },
  { 1898, 14, 12, 15, 1, -19 },
  { 1919, 11, 2, 11, 0, 2 },
  { 1922, 8, 5, 10, 1, -21 },
  { 1927, 13, 15, 16, 1, -15 },
  { 1952, 14, 21, 17, 2, -21 },
  { 1989, 12, 15, 14, 1, -15 },
  { 2012, 14, 21, 17, 1, -21 },
  { 2049, 14, 15, 16, 1, -15 },
  { 2076, 11, 21, 10, 1, -21 },
  { 2105, 14, 21, 17, 1, -15 },
  { 2142, 14, 21, 18, 2, -21 },
  { 2179, 4, 21, 8, 2, -21 },
  { 2190, 7, 27, 8, -1, -21 },
  { 2214, 15, 21, 17, 2, -21 },
  { 2254, 4, 21, 8, 2, -21 },
  { 2265, 22, 15, 26, 2, -15 },
  { 2307, 14, 15, 18, 2, -15 },
  { 2334, 15, 15, 17, 1, -15 },
  { 2363, 14, 21, 17, 2, -15 },
  { 2400, 14, 21, 17, 1, -15 },
  { 2437, 10, 15, 12, 2, -15 },
  { 2456, 11, 15, 14, 1, -15 },
  { 2477, 10, 18, 12, 1, -18 },
  { 2500, 14, 15, 18, 2, -15 },
  { 2527, 15, 15, 15, 0, -15 },
  { 2556, 23, 15, 23, 0, -15 },
  { 2600, 15, 15, 16, 0, -15 },
  { 2629, 15, 21, 15, 0, -15 },
  { 2669, 11, 15, 13, 1, -15 },
  { 2690, 10, 23, 11, 0, -19 },
  { 2719, 3, 26, 15, 6, -20 },
  { 2729, 9, 23, 11, 1, -19 },
  { 2755, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_Bold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold27pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_BOLD27PT7B_H_
