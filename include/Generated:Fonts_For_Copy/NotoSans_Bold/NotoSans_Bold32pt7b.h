#ifndef _NOTOSANS_BOLD32PT7B_H_
#define _NOTOSANS_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x00,
  0x1D, 0xFF, 0xFF, 0xE0, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7B, 0x8F, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC7,
  0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC1, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3, 0xC7, 0x00, 0x71, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFD, 0x8E,
  0xF9, 0x80, 0xF9, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0x81, 0x9F, 0xF1, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xF8, 0x07, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1F, 0x00, 0x3C, 0x0F, 0xF0, 0x0F, 0x01, 0xFF, 0x01, 0xC0,
  0x79, 0xE0, 0x78, 0x0F, 0x1E, 0x1E, 0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78,
  0xF0, 0x07, 0x8F, 0x1E, 0x00, 0xF1, 0xE7, 0x80, 0x1E, 0x3C, 0xE3, 0xE3,
  0xCF, 0x3C, 0xFE, 0x3F, 0xE7, 0x3F, 0xE3, 0xF9, 0xE7, 0xBC, 0x3E, 0x79,
  0xE3, 0xC0, 0x0F, 0x3C, 0x78, 0x03, 0xC7, 0x8F, 0x00, 0x78, 0xF1, 0xE0,
  0x1E, 0x1E, 0x3C, 0x03, 0x83, 0xC7, 0x80, 0xF0, 0x78, 0xE0, 0x1C, 0x07,
  0xFC, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xE3, 0xFF, 0x07, 0xCF, 0xDF, 0x1F,
  0x1F, 0x1F, 0x3E, 0x7C, 0x1F, 0xF8, 0xF8, 0x1F, 0xF1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x03,
  0xFE, 0x1F, 0x80, 0xFF, 0xBD, 0xEF, 0x7B, 0xCE, 0x07, 0x87, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83,
  0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x0E, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7,
  0xC3, 0x8E, 0x01, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3D,
  0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFE, 0xFB, 0x9F,
  0x23, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0x78, 0x3E, 0x30, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFE, 0x30, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0E, 0xF8, 0x0F, 0x7C,
  0x0F, 0x3E, 0x07, 0x1F, 0x07, 0x8F, 0x87, 0x87, 0xC7, 0x83, 0xE3, 0xC1,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0x81, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xE6, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x3E, 0x3E, 0x7C, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC,
  0x7E, 0x7E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xEF,
  0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x37, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x00,
  0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xC0, 0x39, 0xF7, 0xDF, 0x7C, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC0, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE3, 0xC1, 0xFE, 0x38, 0xF1, 0xFF, 0xCF, 0x78,
  0xFF, 0xF3, 0xDE, 0x3C, 0x38, 0x77, 0x1E, 0x0E, 0x1D, 0xC7, 0x83, 0x87,
  0x71, 0xC0, 0xE1, 0xFC, 0x70, 0x38, 0x77, 0x1E, 0x1E, 0x3D, 0xC7, 0x87,
  0x8E, 0x71, 0xFF, 0xF7, 0x9E, 0x3F, 0xDF, 0xC7, 0x87, 0xE3, 0xE0, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x06, 0x00, 0xFF, 0x3F, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0x03, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x18, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF,
  0x03, 0xF3, 0xE0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0x18, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0x7D, 0xFC, 0x0F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xA7, 0xEF, 0xFB, 0xFC,
  0xFE, 0x3E, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xFC,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F,
  0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C,
  0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xEF, 0xF7, 0x81, 0xEF,
  0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF,
  0xF3, 0xC3, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xF7, 0xC0, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0xFF, 0x3E, 0x0F, 0xF1, 0xF0,
  0xFF, 0x1F, 0x8F, 0xF0, 0xF8, 0xFF, 0x07, 0xCF, 0xF0, 0x7C, 0xFF, 0x03,
  0xEF, 0xF0, 0x3E, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x03, 0xF1, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xF0, 0x3F, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x03, 0xF1, 0xF8,
  0x07, 0xCF, 0xC0, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8,
  0x7E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x83,
  0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xFC, 0xF8,
  0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xE7, 0xC0, 0xCF, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0,
  0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xFB,
  0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xF0, 0x0F, 0x80, 0x7D, 0xE0, 0x1F, 0x00, 0xF3, 0xE0, 0x7F, 0x03, 0xE7,
  0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0x8F, 0x03, 0xB8, 0x1E, 0x1E,
  0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF0, 0x78,
  0xFB, 0xC3, 0xC0, 0xF1, 0xE3, 0xC7, 0x81, 0xF3, 0xC7, 0x9F, 0x03, 0xE7,
  0x8F, 0x3E, 0x03, 0xDF, 0x1E, 0x78, 0x07, 0xBC, 0x1E, 0xF0, 0x0F, 0x78,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7C,
  0x7E, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xC3, 0xE0, 0x3F, 0x3E, 0x00, 0xFB,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x39, 0xC0,
  0x3C, 0xF0, 0x1C, 0x38, 0x1E, 0x1E, 0x0E, 0x07, 0x0F, 0x03, 0xC7, 0x00,
  0xE7, 0x80, 0x7B, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0x78, 0x1C, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x18, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF,
  0x7F, 0xEF, 0x1F, 0x8F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE3, 0xC1, 0xF7, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0x8F, 0xDF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xDF, 0x83, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF3, 0xEF, 0xF1, 0xE3, 0xF0, 0x01, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xE7, 0xF0, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x8F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x3E, 0x3F, 0xDF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0x87, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0xC3, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0x9E, 0x1F, 0x8F, 0x03, 0xE0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x79, 0xF0, 0x3E, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x08, 0xFC, 0x3C, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x87, 0xFC, 0x7E, 0x23, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE7, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xE1,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0x1F, 0xEF, 0x87, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFB, 0x81,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE3,
  0xE1, 0xF7, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x8F, 0xDF, 0x83, 0xEF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x7F, 0xFE, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0xC3, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF3, 0xFF,
  0xFF, 0xFB, 0xF8, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0xF8, 0x3F,
  0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xBE, 0x0F, 0x8F, 0xC3, 0xE1,
  0xF8, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x1E, 0x1E, 0x7F, 0x8F, 0xF3, 0xFF, 0xFB, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xE3, 0xFC, 0x7F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xC0,
  0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0,
  0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07,
  0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03,
  0xE0, 0x7C, 0x00, 0xF0, 0x79, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3,
  0xF7, 0xE0, 0xFB, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x07,
  0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0xFC,
  0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x7D, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xF7,
  0xE0, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7C, 0xFC, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x1F, 0xEF, 0x87, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x7F, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xF8, 0x13,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F,
  0x00, 0x7E, 0x01, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xC7, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF8,
  0xF0, 0x3E, 0x3E, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x7C, 0x78, 0x1F,
  0x3E, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x83, 0xEF,
  0x83, 0xF0, 0x7D, 0xF0, 0xFE, 0x0F, 0x3E, 0x1F, 0xC3, 0xE3, 0xC3, 0xBC,
  0x7C, 0x7C, 0x77, 0x8F, 0x0F, 0x9E, 0x71, 0xE0, 0xF3, 0xCE, 0x7C, 0x1E,
  0x71, 0xEF, 0x83, 0xEE, 0x3D, 0xE0, 0x7F, 0xC7, 0xBC, 0x07, 0xF8, 0x7F,
  0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xCF, 0x87, 0xE3, 0xF1,
  0xF0, 0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF9, 0xF8, 0x3E, 0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x0F, 0x0F, 0x87, 0xC1, 0xE1,
  0xF0, 0x7C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x83, 0xF8, 0x7F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7C, 0x00, 0x3E, 0x01,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 11, 8, 15, 2, -23 },
  { 27, 19, 23, 21, 1, -23 },
  { 82, 16, 26, 18, 1, -24 },
  { 134, 27, 23, 29, 1, -23 },
  { 212, 23, 23, 24, 1, -23 },
  { 279, 5, 8, 9, 2, -23 },
  { 284, 9, 28, 11, 1, -23 },
  { 316, 9, 28, 11, 1, -23 },
  { 348, 15, 15, 17, 1, -24 },
  { 377, 16, 15, 18, 1, -19 },
  { 407, 6, 8, 9, 1, -4 },
  { 413, 8, 4, 10, 1, -11 },
  { 417, 5, 5, 9, 2, -5 },
  { 421, 13, 23, 13, 0, -23 },
  { 459, 16, 23, 18, 1, -23 },
  { 505, 11, 23, 18, 2, -23 },
  { 537, 16, 23, 18, 1, -23 },
  { 583, 16, 23, 18, 1, -23 },
  { 629, 17, 23, 18, 1, -23 },
  { 678, 15, 23, 18, 2, -23 },
  { 722, 16, 23, 18, 1, -23 },
  { 768, 16, 23, 18, 1, -23 },
  { 814, 16, 23, 18, 1, -23 },
  { 860, 16, 23, 18, 1, -23 },
  { 906, 5, 18, 9, 2, -18 },
  { 918, 6, 22, 9, 1, -18 },
  { 935, 16, 17, 18, 1, -20 },
  { 969, 16, 9, 18, 1, -16 },
  { 987, 16, 17, 18, 1, -20 },
  { 1021, 15, 23, 15, 0, -23 },
  { 1065, 26, 26, 29, 1, -23 },
  { 1150, 22, 23, 22, 0, -23 },
  { 1214, 17, 23, 21, 3, -23 },
  { 1263, 18, 23, 21, 2, -23 },
  { 1315, 19, 23, 23, 3, -23 },
  { 1370, 13, 23, 18, 3, -23 },
  { 1408, 13, 23, 18, 3, -23 },
  { 1446, 19, 23, 23, 2, -23 },
  { 1501, 19, 23, 24, 3, -23 },
  { 1556, 10, 23, 12, 1, -23 },
  { 1585, 10, 30, 11, -2, -23 },
  { 1623, 18, 23, 21, 3, -23 },
  { 1675, 14, 23, 18, 3, -23 },
  { 1716, 24, 23, 30, 3, -23 },
  { 1785, 20, 23, 26, 3, -23 },
  { 1843, 22, 23, 25, 2, -23 },
  { 1907, 16, 23, 20, 3, -23 },
  { 1953, 22, 28, 25, 2, -23 },
  { 2030, 18, 23, 21, 3, -23 },
  { 2082, 15, 23, 18, 1, -23 },
  { 2126, 17, 23, 18, 1, -23 },
  { 2175, 18, 23, 24, 3, -23 },
  { 2227, 21, 23, 21, 0, -23 },
  { 2288, 31, 23, 31, 0, -23 },
  { 2378, 21, 23, 21, 0, -23 },
  { 2439, 20, 23, 20, 0, -23 },
  { 2497, 17, 23, 19, 1, -23 },
  { 2546, 8, 28, 11, 2, -23 },
  { 2574, 13, 23, 13, 0, -23 },
  { 2612, 7, 28, 11, 1, -23 },
  { 2637, 17, 15, 18, 1, -23 },
  { 2669, 13, 2, 13, 0, 3 },
  { 2673, 9, 6, 12, 1, -25 },
  { 2680, 16, 18, 19, 1, -18 },
  { 2716, 17, 24, 20, 2, -24 },
  { 2767, 15, 18, 17, 1, -18 },
  { 2801, 17, 24, 20, 1, -24 },
  { 2852, 17, 18, 19, 1, -18 },
  { 2891, 13, 24, 12, 1, -24 },
  { 2930, 17, 26, 20, 1, -18 },
  { 2986, 17, 24, 21, 2, -24 },
  { 3037, 5, 24, 10, 2, -24 },
  { 3052, 9, 32, 10, -2, -24 },
  { 3088, 18, 24, 20, 2, -24 },
  { 3142, 5, 24, 10, 2, -24 },
  { 3157, 27, 18, 31, 2, -18 },
  { 3218, 17, 18, 21, 2, -18 },
  { 3257, 17, 18, 20, 1, -18 },
  { 3296, 17, 26, 20, 2, -18 },
  { 3352, 17, 26, 20, 1, -18 },
  { 3408, 12, 18, 14, 2, -18 },
  { 3435, 14, 18, 16, 1, -18 },
  { 3467, 12, 21, 14, 1, -21 },
  { 3499, 16, 17, 21, 2, -17 },
  { 3533, 18, 17, 18, 0, -17 },
  { 3572, 27, 17, 27, 0, -17 },
  { 3630, 18, 17, 19, 0, -17 },
  { 3669, 18, 25, 18, 0, -17 },
  { 3726, 14, 17, 16, 1, -17 },
  { 3756, 11, 28, 13, 0, -23 },
  { 3795, 4, 31, 18, 7, -24 },
  { 3811, 11, 28, 13, 1, -23 },
  { 3850, 16, 5, 18, 1, -14 },
};

const GFXfont NotoSans_Bold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold32pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_BOLD32PT7B_H_
