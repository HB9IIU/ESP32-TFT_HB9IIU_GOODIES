#ifndef _NOTOSANS_BOLD62PT7B_H_
#define _NOTOSANS_BOLD62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x1F, 0xC7, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF,
  0x1F, 0xE0, 0xF0, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE7, 0x8F, 0xE3, 0xFE, 0x1E, 0x03, 0x8F, 0xF8, 0x78, 0x00,
  0x3F, 0xE1, 0xE0, 0x00, 0xFF, 0x87, 0x80, 0x03, 0xFF, 0x1E, 0x00, 0x0F,
  0xFE, 0x78, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7B, 0xFF,
  0xC0, 0x01, 0xE3, 0xFF, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x1E, 0x1F, 0xF8,
  0x00, 0x78, 0x7F, 0xFC, 0x01, 0xE3, 0xFF, 0xFE, 0x07, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFF, 0xE0, 0x7F, 0x07, 0xF1, 0xFE, 0x3F, 0xFF, 0x07, 0xF8, 0xFF, 0x1F,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE0, 0xFF,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x07, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0,
  0x1F, 0x80, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x60, 0x0F, 0xC0, 0x19, 0xF8, 0x3F, 0x07, 0xE7, 0xFC, 0xFD, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xC7, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0x8F,
  0xFC, 0xFC, 0x3F, 0xF3, 0xE0, 0xFF, 0xC7, 0x03, 0xFF, 0x08, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F,
  0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x3C, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x3F, 0xF8, 0x1C, 0x00, 0x3F, 0xF8,
  0x20, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xC0, 0x0F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFD,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x07, 0xE1, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE8, 0x00, 0x01, 0xFF, 0xB8, 0x00, 0x0F,
  0xFE, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x3F, 0xFF,
  0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0x81,
  0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x74, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFE, 0x3F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0x9F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xC0, 0x03, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xF1, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF8, 0x3C, 0x00,
  0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF,
  0x1F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0xF1, 0xC0, 0x01, 0xFF, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07,
  0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xF8, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x9F, 0xC0,
  0x7F, 0xF3, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0xE0, 0x3F, 0x81, 0xF9, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x7E, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xFF,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFF,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0x01,
  0xFB, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0xBF, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0xFF,
  0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x7F, 0xE1, 0xFC, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xFF,
  0xEF, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0xE0, 0x00, 0xE0, 0x7F, 0xF8, 0x00, 0x04,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x41, 0xFF, 0xF0, 0x00, 0x38, 0x1F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x0F, 0xC1, 0xFF, 0xF0, 0x00, 0x18, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xE0,
  0x07, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0,
  0x0F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0xC7, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFB,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0xFF,
  0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0xFF,
  0x9F, 0xC0, 0x03, 0xF9, 0xFF, 0xFF, 0x3F, 0xC0, 0x07, 0xF3, 0xFF, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0x87,
  0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x81, 0xFE,
  0x7F, 0x01, 0xFF, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x1F,
  0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xCF,
  0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF,
  0x87, 0xFF, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0xF0, 0x03, 0xFF, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE1, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE,
  0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF0, 0x0F, 0xC3, 0xFF, 0x00, 0x0E, 0x3F, 0xF0, 0x00, 0x11, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xE0, 0x07, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF8, 0x00,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xBF,
  0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF9,
  0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0x01, 0xE0, 0x07, 0xFE, 0x01, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xFB,
  0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0x07,
  0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xF8,
  0x07, 0xFF, 0x7F, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF,
  0xFC, 0x1F, 0xC3, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7C, 0x7F, 0xF0, 0x01, 0x8F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x2F, 0xFE, 0x00, 0x18, 0xFF, 0xF0, 0x1F, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF3, 0xFF,
  0x07, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xF9, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0xE1, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFC, 0x0C, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xF9,
  0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x03, 0xFF, 0xF3,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x20, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE3, 0xFF, 0xF0, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x81, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x1F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x7F,
  0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0xFE, 0x03, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x83, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0x03,
  0xFC, 0x7F, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xE0, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x81,
  0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0x07, 0xFF,
  0xF9, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0,
  0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x03, 0xFF,
  0xF3, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0x0B, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFC, 0x0F, 0xE3, 0xFE, 0x00, 0x38, 0xFF, 0x80, 0x02, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0x00, 0x0F, 0xFB, 0xFE, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xBF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFE,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xF1, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFE, 0x3F, 0x83, 0xFE, 0x03, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xF0, 0x7E, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFE, 0x0F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x80,
  0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0x03, 0xFE, 0x7F, 0x07, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xC0, 0x7E, 0x7F, 0xC0, 0x07, 0xFB, 0xF8, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x3F,
  0xBF, 0xC0, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xF2, 0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_Bold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 45, 17, 3, -44 },
  { 63, 22, 16, 30, 4, -44 },
  { 107, 38, 44, 40, 1, -44 },
  { 316, 30, 51, 35, 3, -47 },
  { 508, 52, 46, 56, 2, -45 },
  { 807, 45, 46, 47, 2, -45 },
  { 1066, 9, 16, 16, 4, -44 },
  { 1084, 17, 54, 21, 2, -44 },
  { 1199, 17, 54, 21, 2, -44 },
  { 1314, 30, 29, 34, 2, -47 },
  { 1423, 30, 30, 35, 3, -37 },
  { 1536, 12, 15, 18, 2, -7 },
  { 1559, 16, 7, 20, 2, -20 },
  { 1573, 11, 11, 17, 3, -10 },
  { 1589, 25, 45, 26, 0, -45 },
  { 1730, 31, 46, 35, 2, -45 },
  { 1909, 22, 44, 35, 4, -44 },
  { 2030, 31, 45, 35, 2, -45 },
  { 2205, 31, 46, 35, 2, -45 },
  { 2384, 33, 44, 35, 1, -44 },
  { 2566, 30, 45, 35, 3, -44 },
  { 2735, 31, 46, 35, 2, -45 },
  { 2914, 31, 44, 35, 2, -44 },
  { 3085, 31, 46, 35, 2, -45 },
  { 3264, 31, 46, 35, 2, -45 },
  { 3443, 11, 35, 17, 3, -34 },
  { 3492, 12, 42, 18, 2, -34 },
  { 3555, 30, 33, 35, 3, -39 },
  { 3679, 30, 18, 35, 3, -31 },
  { 3747, 30, 33, 35, 3, -39 },
  { 3871, 28, 46, 30, 0, -45 },
  { 4032, 50, 50, 56, 3, -45 },
  { 4345, 43, 44, 43, 0, -44 },
  { 4582, 33, 44, 41, 5, -44 },
  { 4764, 35, 46, 40, 3, -45 },
  { 4966, 37, 44, 45, 5, -44 },
  { 5170, 25, 44, 35, 6, -44 },
  { 5308, 25, 44, 34, 6, -44 },
  { 5446, 36, 46, 45, 4, -45 },
  { 5653, 36, 44, 47, 6, -44 },
  { 5851, 20, 44, 24, 2, -44 },
  { 5961, 20, 57, 21, -5, -44 },
  { 6104, 35, 44, 41, 6, -44 },
  { 6297, 28, 44, 35, 5, -44 },
  { 6451, 47, 44, 58, 6, -44 },
  { 6710, 39, 44, 50, 6, -44 },
  { 6925, 43, 46, 49, 3, -45 },
  { 7173, 31, 44, 39, 5, -44 },
  { 7344, 43, 56, 49, 3, -45 },
  { 7645, 36, 44, 41, 5, -44 },
  { 7843, 29, 46, 34, 3, -45 },
  { 8010, 34, 44, 36, 1, -44 },
  { 8197, 37, 45, 47, 5, -44 },
  { 8406, 40, 44, 40, 0, -44 },
  { 8626, 60, 44, 60, 0, -44 },
  { 8956, 41, 44, 42, 0, -44 },
  { 9182, 39, 44, 39, 0, -44 },
  { 9397, 33, 44, 36, 1, -44 },
  { 9579, 15, 54, 21, 4, -44 },
  { 9681, 25, 45, 26, 0, -45 },
  { 9822, 14, 54, 21, 2, -44 },
  { 9917, 33, 29, 35, 1, -45 },
  { 10037, 26, 4, 25, 0, 6 },
  { 10050, 18, 9, 23, 2, -47 },
  { 10071, 31, 35, 37, 2, -34 },
  { 10207, 31, 48, 39, 5, -47 },
  { 10393, 27, 35, 32, 3, -34 },
  { 10512, 32, 48, 39, 3, -47 },
  { 10704, 31, 35, 37, 3, -34 },
  { 10840, 26, 47, 24, 1, -47 },
  { 10993, 32, 49, 39, 3, -34 },
  { 11189, 31, 47, 40, 5, -47 },
  { 11372, 10, 47, 19, 4, -47 },
  { 11431, 17, 62, 18, -3, -47 },
  { 11563, 33, 47, 38, 5, -47 },
  { 11757, 9, 47, 18, 5, -47 },
  { 11810, 51, 34, 60, 5, -34 },
  { 12027, 31, 34, 40, 5, -34 },
  { 12159, 33, 35, 39, 3, -34 },
  { 12304, 31, 49, 39, 5, -34 },
  { 12494, 32, 49, 39, 3, -34 },
  { 12690, 22, 34, 28, 5, -34 },
  { 12784, 26, 35, 31, 3, -34 },
  { 12898, 24, 42, 27, 1, -41 },
  { 13024, 32, 35, 40, 4, -34 },
  { 13164, 35, 34, 35, 0, -34 },
  { 13313, 51, 34, 53, 1, -34 },
  { 13530, 36, 34, 36, 0, -34 },
  { 13683, 35, 49, 35, 0, -34 },
  { 13898, 27, 34, 31, 2, -34 },
  { 14013, 21, 54, 24, 1, -44 },
  { 14155, 6, 61, 34, 14, -47 },
  { 14201, 22, 54, 24, 2, -44 },
  { 14350, 30, 10, 35, 3, -27 },
};

const GFXfont NotoSans_Bold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold62pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_BOLD62PT7B_H_
