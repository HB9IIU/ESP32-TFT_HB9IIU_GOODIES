#ifndef _NOTOSANS_BOLD16PT7B_H_
#define _NOTOSANS_BOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB0, 0x1F, 0x80, 0xDF, 0x3C, 0xB2, 0x09, 0x86, 0x41,
  0xB1, 0xFF, 0x1B, 0x04, 0xCF, 0xFB, 0xFE, 0x36, 0x0D, 0x82, 0x60, 0x10,
  0x7E, 0xFE, 0xD2, 0xD0, 0xF8, 0x3E, 0x1E, 0x17, 0xFE, 0xFE, 0x10, 0x10,
  0x30, 0x01, 0xE1, 0x86, 0xCC, 0x33, 0x30, 0x4D, 0x81, 0xB6, 0xE7, 0xB7,
  0xC4, 0x93, 0x06, 0x4C, 0x31, 0x30, 0xC6, 0xC6, 0x0E, 0x18, 0x0F, 0xC1,
  0x98, 0x33, 0x06, 0xE0, 0x78, 0x5E, 0x37, 0x6E, 0xC7, 0x98, 0x73, 0xFE,
  0x3F, 0x70, 0xFF, 0x76, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0xE1, 0x8C,
  0x61, 0x8C, 0x63, 0x19, 0x8C, 0x66, 0x60, 0x18, 0x18, 0x6B, 0xFF, 0x1C,
  0x36, 0x76, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08, 0x76, 0x6C, 0xFF,
  0xC0, 0xFC, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x87,
  0x00, 0x18, 0x7C, 0xEE, 0xC6, 0xC6, 0xC7, 0xC7, 0xC7, 0xC6, 0xC6, 0xFE,
  0x7C, 0x3D, 0xFF, 0xD7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x18, 0xFE,
  0xEE, 0x86, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x30, 0xFE,
  0xCE, 0x06, 0x06, 0x7C, 0x7C, 0x06, 0x07, 0x86, 0xFE, 0xFC, 0x07, 0x07,
  0x87, 0xC3, 0xE3, 0x73, 0x39, 0x9D, 0xFF, 0xFF, 0x83, 0x81, 0xC0, 0xFF,
  0xFF, 0x06, 0x0F, 0xDF, 0xC1, 0x83, 0x87, 0xFF, 0xF0, 0x0C, 0x3E, 0x72,
  0xC0, 0xC0, 0xFE, 0xEE, 0xC7, 0xC7, 0xC6, 0xFE, 0x7C, 0xFF, 0xFF, 0x80,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x10, 0x7E,
  0xE6, 0xC6, 0xEE, 0x7C, 0x7C, 0xEE, 0xC7, 0xC7, 0xFE, 0x7C, 0x10, 0x7C,
  0xEE, 0xC6, 0xC7, 0xC7, 0xFF, 0x7E, 0x06, 0x0E, 0xFC, 0xF8, 0xDF, 0x00,
  0x07, 0xE0, 0x67, 0x60, 0x00, 0x07, 0x66, 0xC0, 0x02, 0x1C, 0xF7, 0x8C,
  0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC1, 0xE0, 0xF0,
  0x67, 0xBC, 0x60, 0x19, 0xFD, 0xB8, 0x30, 0x63, 0x8E, 0x18, 0x00, 0x00,
  0xE1, 0xC0, 0x02, 0x00, 0xFE, 0x0C, 0x18, 0xC6, 0x6C, 0xF9, 0x6C, 0xCF,
  0x66, 0x7B, 0x32, 0xD9, 0xB6, 0x77, 0x38, 0x00, 0xE1, 0x81, 0xFC, 0x00,
  0x0E, 0x03, 0x60, 0x6C, 0x0D, 0x83, 0xB8, 0x63, 0x0F, 0xE3, 0xFE, 0x60,
  0xCC, 0x1F, 0x83, 0x80, 0xFF, 0x77, 0xB8, 0xFC, 0x6F, 0xF7, 0xFB, 0x8F,
  0xC7, 0xE3, 0xFF, 0xBF, 0x80, 0x0E, 0x1F, 0xDE, 0xDC, 0x0E, 0x06, 0x03,
  0x01, 0xC0, 0xE0, 0x38, 0x5F, 0xC7, 0xE0, 0xFF, 0x3F, 0xEE, 0x1B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0x87,
  0x0F, 0xFF, 0xF8, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0x0F, 0xFF,
  0xF8, 0x70, 0xE1, 0xC3, 0x80, 0x06, 0x1F, 0xDE, 0x7C, 0x0E, 0x06, 0x03,
  0x1F, 0xCF, 0xE1, 0xB0, 0xDF, 0xE7, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFB, 0x98, 0xC6,
  0x31, 0x8C, 0x67, 0xBE, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F,
  0x78, 0xE3, 0xF9, 0xCE, 0x63, 0xB0, 0xFC, 0x3F, 0x0E, 0xE3, 0x98, 0xE7,
  0x38, 0xEE, 0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF,
  0xF8, 0xF0, 0x7F, 0x83, 0xF6, 0x3F, 0xF1, 0xFF, 0x8F, 0xF6, 0xDF, 0xB6,
  0xFD, 0xB7, 0xEF, 0x3F, 0x39, 0xF9, 0xCE, 0xF0, 0xFF, 0x1F, 0x63, 0xFE,
  0x7E, 0xCF, 0xDD, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0x87, 0x80, 0x0E,
  0x07, 0xF1, 0xEF, 0x70, 0x6E, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xCE,
  0x39, 0xFE, 0x1F, 0x80, 0xFE, 0xFF, 0xE3, 0xE3, 0xE7, 0xFF, 0xFC, 0xE0,
  0xE0, 0xE0, 0xE0, 0x0E, 0x07, 0xF1, 0xEF, 0x70, 0x6E, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x78,
  0xFE, 0x3B, 0xCE, 0x33, 0x8C, 0xE7, 0x3F, 0x8F, 0xE3, 0x98, 0xE7, 0x38,
  0xEE, 0x3C, 0x18, 0xFF, 0xBE, 0x0E, 0x1F, 0x0F, 0x0F, 0x07, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x61, 0x9F, 0xE3, 0xF0, 0xE0, 0xD8, 0x76, 0x19, 0xC6, 0x33, 0x8C, 0xC3,
  0xB0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0xE3, 0x87, 0xC7, 0x0D, 0x8F, 0x3B,
  0x1E, 0x67, 0x6C, 0xC6, 0xD9, 0x8D, 0x9F, 0x1B, 0x3C, 0x3C, 0x78, 0x38,
  0xF0, 0x70, 0xE0, 0xF1, 0xC6, 0x30, 0xEE, 0x0F, 0x81, 0xE0, 0x1C, 0x07,
  0xC1, 0xD8, 0x33, 0x8E, 0x3B, 0x83, 0x80, 0xE1, 0xDC, 0xE3, 0x30, 0xFC,
  0x1E, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0xBF, 0x81,
  0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x7F, 0xFF, 0xE0, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C,
  0x18, 0x38, 0x30, 0x70, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18,
  0x0E, 0x0D, 0x06, 0xC6, 0x33, 0x1B, 0x06, 0xFF, 0xFC, 0xE3, 0x7C, 0xFD,
  0x18, 0x3F, 0xF8, 0xF1, 0xFF, 0xFA, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xDE, 0x3C, 0xFF, 0x8E, 0x0C, 0x18, 0x38,
  0x7F, 0x7E, 0x03, 0x03, 0x03, 0x3B, 0xFF, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7,
  0xFF, 0x7B, 0x3C, 0x7E, 0xE7, 0xC3, 0xFF, 0xC0, 0xE0, 0x7E, 0x3E, 0x3E,
  0x78, 0xC3, 0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x3B, 0x7F,
  0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0xFF, 0x7B, 0x03, 0x87, 0xFE, 0x7C, 0xE0,
  0xE0, 0xE0, 0xEE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0x39, 0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xDC, 0xE0, 0x70, 0x38, 0x1C, 0x7E, 0x77, 0x73, 0xF1, 0xF8, 0xFC,
  0x77, 0x39, 0xDC, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0x77, 0xFF,
  0xF9, 0xE7, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C, 0x63, 0xE3, 0x18,
  0xDE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3C, 0x7E, 0xE7,
  0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xDE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3,
  0xE3, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3,
  0xC3, 0xE7, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x03, 0xCF, 0x7F, 0x38, 0xE3,
  0x8E, 0x38, 0xE0, 0x7F, 0xFC, 0x38, 0x78, 0x70, 0xFF, 0xF8, 0x30, 0xC7,
  0xFF, 0x71, 0xC7, 0x1C, 0x30, 0xF3, 0xC0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE7, 0xFF, 0x7B, 0xE1, 0xF1, 0xD8, 0xCE, 0x63, 0x71, 0xB0, 0xD8,
  0x38, 0x1C, 0x00, 0xE7, 0x1D, 0x9C, 0x66, 0x79, 0x99, 0x6E, 0x7D, 0xB0,
  0xF2, 0xC3, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0xB9, 0x8D, 0xC7, 0xC1,
  0xC1, 0xF0, 0xDC, 0xE6, 0xE3, 0x80, 0xE1, 0xF1, 0xD8, 0xCE, 0x63, 0x71,
  0xB0, 0xF8, 0x38, 0x1C, 0x0E, 0x06, 0x0F, 0x06, 0x00, 0x7E, 0xFC, 0x38,
  0xE1, 0x87, 0x1C, 0x3F, 0xFE, 0x1C, 0xE3, 0x0C, 0x31, 0xCC, 0x3C, 0x30,
  0xC3, 0x0E, 0x3C, 0x10, 0xFF, 0xFF, 0xE3, 0x18, 0xC6, 0x38, 0x6F, 0x63,
  0x18, 0xCE, 0x40, 0xF3, 0xFE, 0x30,
};

const GFXglyph NotoSans_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 5, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 8, 13, 9, 1, -12 },
  { 36, 14, 12, 14, 0, -12 },
  { 57, 11, 12, 12, 1, -12 },
  { 74, 2, 4, 4, 1, -11 },
  { 75, 4, 14, 5, 1, -11 },
  { 82, 5, 14, 5, 0, -11 },
  { 91, 8, 7, 9, 0, -12 },
  { 98, 7, 8, 9, 1, -10 },
  { 105, 4, 4, 5, 0, -2 },
  { 107, 5, 2, 5, 0, -5 },
  { 109, 3, 2, 5, 1, -2 },
  { 110, 7, 12, 7, 0, -12 },
  { 121, 8, 12, 9, 1, -12 },
  { 133, 6, 11, 9, 1, -11 },
  { 142, 8, 12, 9, 1, -12 },
  { 154, 8, 12, 9, 1, -12 },
  { 166, 9, 11, 9, 0, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 8, 12, 9, 1, -12 },
  { 201, 9, 11, 9, 0, -11 },
  { 214, 8, 12, 9, 1, -12 },
  { 226, 8, 12, 9, 1, -12 },
  { 238, 3, 9, 5, 1, -9 },
  { 242, 4, 11, 5, 0, -9 },
  { 248, 7, 8, 9, 1, -10 },
  { 255, 7, 5, 9, 1, -8 },
  { 260, 7, 8, 9, 1, -10 },
  { 267, 7, 12, 8, 0, -12 },
  { 278, 13, 13, 14, 1, -12 },
  { 300, 11, 11, 11, 0, -11 },
  { 316, 9, 11, 11, 1, -11 },
  { 329, 9, 12, 10, 1, -12 },
  { 343, 10, 11, 12, 1, -11 },
  { 357, 7, 11, 9, 1, -11 },
  { 367, 7, 11, 9, 1, -11 },
  { 377, 9, 12, 12, 1, -12 },
  { 391, 10, 11, 12, 1, -11 },
  { 405, 5, 11, 6, 1, -11 },
  { 412, 5, 14, 5, -1, -11 },
  { 421, 10, 11, 11, 1, -11 },
  { 435, 7, 11, 9, 1, -11 },
  { 445, 13, 11, 15, 1, -11 },
  { 463, 11, 11, 13, 1, -11 },
  { 479, 11, 12, 13, 1, -12 },
  { 496, 8, 11, 10, 1, -11 },
  { 507, 11, 15, 13, 1, -12 },
  { 528, 10, 11, 11, 1, -11 },
  { 542, 7, 12, 9, 1, -12 },
  { 553, 9, 11, 9, 0, -11 },
  { 566, 10, 11, 12, 1, -11 },
  { 580, 10, 11, 10, 0, -11 },
  { 594, 15, 11, 15, 0, -11 },
  { 615, 11, 11, 11, 0, -11 },
  { 631, 10, 11, 10, 0, -11 },
  { 645, 9, 11, 9, 0, -11 },
  { 658, 4, 14, 5, 1, -11 },
  { 665, 7, 12, 7, 0, -12 },
  { 676, 4, 14, 5, 0, -11 },
  { 683, 9, 7, 9, 0, -11 },
  { 691, 7, 2, 7, 0, 1 },
  { 693, 4, 2, 6, 1, -12 },
  { 694, 7, 9, 10, 1, -9 },
  { 702, 8, 12, 10, 1, -12 },
  { 714, 7, 9, 8, 1, -9 },
  { 722, 8, 12, 10, 1, -12 },
  { 734, 8, 9, 10, 1, -9 },
  { 743, 7, 12, 6, 0, -12 },
  { 754, 8, 13, 10, 1, -9 },
  { 767, 8, 12, 10, 1, -12 },
  { 779, 3, 12, 5, 1, -12 },
  { 784, 5, 16, 5, -1, -12 },
  { 794, 9, 12, 10, 1, -12 },
  { 808, 3, 12, 5, 1, -12 },
  { 813, 13, 9, 16, 1, -9 },
  { 828, 8, 9, 10, 1, -9 },
  { 837, 8, 9, 10, 1, -9 },
  { 846, 8, 13, 10, 1, -9 },
  { 859, 8, 13, 10, 1, -9 },
  { 872, 6, 9, 7, 1, -9 },
  { 879, 6, 9, 8, 1, -9 },
  { 886, 6, 11, 7, 0, -11 },
  { 895, 8, 9, 10, 1, -9 },
  { 904, 9, 9, 9, 0, -9 },
  { 915, 14, 9, 14, 0, -9 },
  { 931, 9, 9, 9, 0, -9 },
  { 942, 9, 13, 9, 0, -9 },
  { 957, 7, 9, 8, 0, -9 },
  { 965, 6, 14, 6, 0, -11 },
  { 976, 1, 16, 9, 4, -12 },
  { 978, 5, 14, 6, 1, -11 },
  { 987, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_Bold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold16pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_BOLD16PT7B_H_
