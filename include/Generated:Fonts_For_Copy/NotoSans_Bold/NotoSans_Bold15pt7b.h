#ifndef _NOTOSANS_BOLD15PT7B_H_
#define _NOTOSANS_BOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xB0, 0x09, 0x0D, 0x86, 0xCF, 0xF7,
  0xF8, 0x90, 0xD9, 0xFF, 0x36, 0x12, 0x09, 0x00, 0x10, 0xFF, 0xF6, 0x8F,
  0x0F, 0x87, 0x8B, 0xDF, 0xF8, 0x40, 0x80, 0x30, 0x63, 0xC6, 0x12, 0x21,
  0x9B, 0x04, 0xB2, 0x3D, 0xFC, 0xDB, 0x60, 0xDB, 0x0C, 0xD8, 0x66, 0xC6,
  0x1C, 0x38, 0x1F, 0x06, 0x61, 0xB0, 0x7C, 0x1E, 0x7F, 0xDB, 0x3E, 0xC7,
  0x3F, 0xE7, 0xDC, 0xFF, 0x36, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x70, 0xC6,
  0x33, 0x33, 0x11, 0x33, 0x33, 0xE0, 0x18, 0x18, 0x7F, 0xBC, 0x3C, 0x76,
  0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x6D, 0xE0, 0xFF, 0xF0,
  0x0C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x61, 0x8C, 0x00, 0x39, 0xFB, 0x3E,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xF9, 0xE0, 0x19, 0xDF, 0xB1, 0x8C, 0x63,
  0x18, 0xC6, 0x79, 0xFB, 0x38, 0x30, 0xC3, 0x8E, 0x38, 0x61, 0xFF, 0xF8,
  0x79, 0xFA, 0x38, 0x71, 0xCF, 0x03, 0x83, 0x0F, 0xFF, 0xF0, 0x06, 0x0E,
  0x1E, 0x1E, 0x36, 0x66, 0x66, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x06,
  0x0F, 0x9F, 0x83, 0x83, 0x0F, 0xFB, 0xE0, 0x1C, 0xFB, 0x86, 0x0F, 0xDF,
  0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xFF, 0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x79, 0xFB, 0x1E, 0x7F, 0xCF, 0x3F, 0x63, 0xC7,
  0xFD, 0xF0, 0x3C, 0x7E, 0x67, 0xE3, 0x63, 0x77, 0x7F, 0x03, 0x06, 0x7E,
  0x7C, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x06, 0x3D, 0xC6, 0x0F, 0x07,
  0x81, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xE0, 0x71, 0xDE,
  0x30, 0x40, 0x79, 0xFD, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x0F, 0x03, 0xFC, 0x60, 0x6C, 0xFA, 0xD9, 0xB9, 0x9B, 0x91, 0xB9, 0xBA,
  0xDF, 0xEC, 0x00, 0x70, 0x83, 0xF8, 0x0E, 0x07, 0x81, 0xE0, 0x6C, 0x3B,
  0x0C, 0xC3, 0x19, 0xFE, 0x61, 0x98, 0x7E, 0x0C, 0xFC, 0xFF, 0xE7, 0xE3,
  0xE6, 0xFE, 0xE7, 0xE3, 0xE3, 0xFF, 0xFE, 0x1E, 0x7F, 0x61, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0x87, 0x0F, 0xDF,
  0xB8, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xF8, 0xE3,
  0x8E, 0x00, 0x1F, 0xBF, 0x9C, 0x5C, 0x0C, 0x06, 0x7F, 0x3F, 0x87, 0xE3,
  0xBF, 0xCF, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x60, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0xFE, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x70, 0xE3, 0xF3, 0xB9, 0x9D,
  0x8F, 0xC7, 0xC3, 0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xE0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xF0, 0x7F, 0x0F, 0xF0, 0xFD,
  0x0B, 0xD9, 0xBD, 0x9B, 0xD9, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0xC6, 0x30,
  0xE0, 0xFC, 0x3F, 0x0F, 0x63, 0xDC, 0xF3, 0x3C, 0xEF, 0x1B, 0xC3, 0xF0,
  0xFC, 0x1C, 0x1E, 0x1F, 0xEE, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x87,
  0xE1, 0x9F, 0xE3, 0xF0, 0xF8, 0xFE, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xEE, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F,
  0x87, 0xE1, 0x9F, 0xE3, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0xF8, 0x7F, 0x39,
  0xDC, 0xEE, 0x77, 0xF3, 0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xE0, 0x3D, 0xFF,
  0x16, 0x0E, 0x0F, 0x07, 0x07, 0x8F, 0xFB, 0xE0, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xBF, 0x8F, 0x80, 0xC1, 0xF8, 0x66, 0x19,
  0x8E, 0x73, 0x0C, 0xC3, 0x70, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0xC3, 0x0F,
  0xC7, 0x19, 0x8E, 0x33, 0x3C, 0x66, 0x69, 0x8C, 0xDB, 0x0D, 0x36, 0x1E,
  0x6C, 0x3C, 0x70, 0x78, 0xE0, 0x61, 0xC0, 0xE1, 0xDC, 0xE3, 0x30, 0xFC,
  0x1E, 0x03, 0x01, 0xE0, 0xFC, 0x33, 0x1C, 0xEE, 0x1C, 0xE1, 0xB1, 0xDC,
  0xC6, 0xE3, 0xE0, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xFF, 0xFF,
  0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xF0, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x70,
  0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x1C, 0x34,
  0x26, 0x62, 0xC3, 0xFC, 0xE3, 0xFC, 0x9C, 0x1B, 0xFC, 0x78, 0xFF, 0xFB,
  0xC0, 0xC0, 0xC0, 0xDE, 0xFE, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0xDC, 0x7F,
  0xBC, 0x30, 0xC3, 0x0F, 0xDF, 0x06, 0x0C, 0x1B, 0xFE, 0xF8, 0xF1, 0xE3,
  0xC7, 0xFD, 0xF8, 0x7D, 0xDF, 0x1F, 0xFC, 0x18, 0x3F, 0xBF, 0x3C, 0xD3,
  0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0xDF, 0x1E, 0x3C, 0x78,
  0xFF, 0xBF, 0x07, 0x1F, 0xF9, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xF7, 0xE7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0x60, 0xC0, 0xC0, 0xC0, 0xC7, 0xCE, 0xDC, 0xF8, 0xFC,
  0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFC, 0xDE, 0xF7, 0xFF, 0xB9, 0xCF, 0x8C,
  0x7C, 0x63, 0xE3, 0x1F, 0x18, 0xF8, 0xC7, 0xDE, 0xF7, 0xE7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0x7C, 0xEE, 0xC6, 0xC7, 0xC7, 0xC6, 0xFE, 0x7C, 0xDE,
  0xFE, 0xE7, 0xC7, 0xC7, 0xE7, 0xFE, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F,
  0xDF, 0x1E, 0x3C, 0x78, 0xFF, 0xBF, 0x06, 0x0C, 0x18, 0x30, 0xDF, 0xEE,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x2C, 0x3E, 0x3C, 0x3F, 0xFE, 0x30, 0xCF,
  0xDC, 0x71, 0xC7, 0x1C, 0x3C, 0xF0, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xFF, 0x7B, 0xE3, 0xB1, 0x99, 0xCE, 0xC3, 0x61, 0xE0, 0x70, 0x38, 0xE7,
  0x3B, 0x39, 0x99, 0x4C, 0xDB, 0x67, 0xDE, 0x1C, 0xF0, 0xE3, 0x87, 0x18,
  0xE3, 0x3B, 0x0F, 0x83, 0x83, 0xC1, 0xB1, 0xDD, 0xC7, 0xE3, 0xB1, 0x99,
  0xCE, 0xC3, 0x61, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x00, 0x7E,
  0xFC, 0x30, 0xC3, 0x0E, 0x1F, 0xFF, 0x19, 0xCC, 0x63, 0x1B, 0x9E, 0x31,
  0x8C, 0x63, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x30, 0xEF,
  0x63, 0x18, 0xCE, 0x00, 0x43, 0xFE, 0x78,
};

const GFXglyph NotoSans_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 10, 0, -11 },
  { 20, 7, 12, 9, 1, -11 },
  { 31, 13, 11, 14, 0, -11 },
  { 49, 10, 11, 11, 1, -11 },
  { 63, 2, 4, 4, 1, -11 },
  { 64, 4, 13, 5, 1, -11 },
  { 71, 4, 13, 5, 0, -11 },
  { 78, 8, 7, 8, 0, -11 },
  { 85, 7, 7, 9, 1, -9 },
  { 92, 3, 4, 4, 0, -2 },
  { 94, 4, 2, 5, 0, -5 },
  { 95, 2, 2, 4, 1, -2 },
  { 96, 6, 11, 6, 0, -11 },
  { 105, 7, 11, 9, 1, -11 },
  { 115, 5, 11, 9, 1, -11 },
  { 122, 7, 11, 9, 1, -11 },
  { 132, 7, 11, 9, 1, -11 },
  { 142, 8, 11, 9, 0, -11 },
  { 153, 7, 11, 9, 1, -11 },
  { 163, 7, 11, 9, 1, -11 },
  { 173, 8, 11, 9, 0, -11 },
  { 184, 7, 11, 9, 1, -11 },
  { 194, 8, 11, 9, 0, -11 },
  { 205, 2, 8, 4, 1, -8 },
  { 207, 3, 10, 4, 0, -8 },
  { 211, 7, 8, 9, 1, -9 },
  { 218, 7, 5, 9, 1, -8 },
  { 223, 7, 8, 9, 1, -9 },
  { 230, 7, 11, 7, 0, -11 },
  { 240, 12, 12, 13, 1, -11 },
  { 258, 10, 11, 10, 0, -11 },
  { 272, 8, 11, 10, 1, -11 },
  { 283, 8, 11, 10, 1, -11 },
  { 294, 9, 11, 11, 1, -11 },
  { 307, 7, 11, 8, 1, -11 },
  { 317, 6, 11, 8, 1, -11 },
  { 326, 9, 11, 11, 1, -11 },
  { 339, 9, 11, 11, 1, -11 },
  { 352, 5, 11, 6, 0, -11 },
  { 359, 5, 14, 5, -1, -11 },
  { 368, 9, 11, 10, 1, -11 },
  { 381, 7, 11, 8, 1, -11 },
  { 391, 12, 11, 14, 1, -11 },
  { 408, 10, 11, 12, 1, -11 },
  { 422, 10, 11, 12, 1, -11 },
  { 436, 8, 11, 9, 1, -11 },
  { 447, 10, 14, 12, 1, -11 },
  { 465, 9, 11, 10, 1, -11 },
  { 478, 7, 11, 8, 1, -11 },
  { 488, 8, 11, 9, 0, -11 },
  { 499, 9, 11, 11, 1, -11 },
  { 512, 10, 11, 10, 0, -11 },
  { 526, 15, 11, 15, 0, -11 },
  { 547, 10, 11, 10, 0, -11 },
  { 561, 9, 11, 9, 0, -11 },
  { 574, 8, 11, 9, 0, -11 },
  { 585, 4, 13, 5, 1, -11 },
  { 592, 6, 11, 6, 0, -11 },
  { 601, 4, 13, 5, 0, -11 },
  { 608, 8, 7, 9, 0, -11 },
  { 615, 6, 1, 6, 0, 1 },
  { 616, 4, 2, 5, 1, -11 },
  { 617, 7, 8, 9, 1, -8 },
  { 624, 8, 11, 9, 1, -11 },
  { 635, 6, 8, 8, 1, -8 },
  { 641, 7, 11, 9, 1, -11 },
  { 651, 7, 8, 9, 1, -8 },
  { 658, 6, 11, 6, 0, -11 },
  { 667, 7, 12, 9, 1, -8 },
  { 678, 8, 11, 10, 1, -11 },
  { 689, 2, 11, 4, 1, -11 },
  { 692, 4, 15, 4, -1, -11 },
  { 700, 8, 11, 9, 1, -11 },
  { 711, 2, 11, 4, 1, -11 },
  { 714, 13, 8, 15, 1, -8 },
  { 727, 8, 8, 10, 1, -8 },
  { 735, 8, 8, 9, 1, -8 },
  { 743, 8, 12, 9, 1, -8 },
  { 755, 7, 12, 9, 1, -8 },
  { 766, 6, 8, 7, 1, -8 },
  { 772, 6, 8, 8, 1, -8 },
  { 778, 6, 10, 7, 0, -10 },
  { 786, 8, 8, 10, 1, -8 },
  { 794, 9, 8, 9, 0, -8 },
  { 803, 13, 8, 13, 0, -8 },
  { 816, 9, 8, 9, 0, -8 },
  { 825, 9, 12, 9, 0, -8 },
  { 839, 7, 8, 7, 0, -8 },
  { 846, 5, 13, 6, 0, -11 },
  { 855, 2, 14, 8, 3, -11 },
  { 859, 5, 13, 6, 1, -11 },
  { 868, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_Bold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold15pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_BOLD15PT7B_H_
