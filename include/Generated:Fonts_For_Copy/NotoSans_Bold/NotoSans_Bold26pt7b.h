#ifndef _NOTOSANS_BOLD26PT7B_H_
#define _NOTOSANS_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDE, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1B, 0x8C, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0C, 0x70, 0x38, 0xC0, 0x73, 0x87, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x8E,
  0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x00, 0x02, 0x00, 0x10,
  0x03, 0xF0, 0x7F, 0xF7, 0xFF, 0x7D, 0x7B, 0xC8, 0x1E, 0x40, 0xFE, 0x03,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0x3C, 0x09, 0xFC, 0x5F, 0xFF,
  0xF7, 0xFF, 0x0F, 0xF0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1C, 0x03, 0x81,
  0xF8, 0x0E, 0x0F, 0xF0, 0x70, 0x39, 0xC1, 0xC0, 0xE7, 0x8E, 0x03, 0x8E,
  0x78, 0x0E, 0x39, 0xC0, 0x39, 0xEE, 0x00, 0xE7, 0x3B, 0xF3, 0xFD, 0xCF,
  0xE7, 0xE7, 0x7B, 0x87, 0x39, 0xCE, 0x00, 0xE7, 0x1C, 0x07, 0x1C, 0x70,
  0x3C, 0x71, 0xC0, 0xE1, 0xCE, 0x07, 0x07, 0xB8, 0x1C, 0x0F, 0xE0, 0xE0,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x78, 0x03,
  0x87, 0x00, 0x71, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x79, 0xFF, 0x1E, 0x3D, 0xF3, 0xCF, 0x1F, 0xF1, 0xE1, 0xFE, 0x3C,
  0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x9F, 0x80,
  0xFF, 0xFF, 0xF8, 0x0E, 0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x80,
  0xE1, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x38, 0x00, 0x0F, 0x00, 0xF0,
  0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xDC,
  0x79, 0xE3, 0x8C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x7B, 0x9D, 0xEE, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFE, 0xF0,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFB, 0xE7, 0x8F, 0x78,
  0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xC3, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x07, 0x87,
  0xC7, 0xE7, 0xFF, 0xFF, 0xBD, 0x9E, 0x8F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x81, 0xFF, 0x3F,
  0xFC, 0xFB, 0xE6, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xF3, 0xE4, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x1F, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x00, 0x70,
  0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC,
  0x1C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x88, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xD8, 0x1E, 0xFF, 0xF7,
  0xFF, 0x1F, 0xE0, 0x01, 0xF0, 0x7F, 0x87, 0xFC, 0x7E, 0x27, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xF7, 0xFF, 0xBE, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xEF, 0x1F, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x07, 0x38, 0x39, 0xE3, 0xCF, 0xBC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0xF3,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xF3, 0xFF, 0x8F, 0xF0,
  0x0F, 0x01, 0xFE, 0x1F, 0xF9, 0xFB, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xDF, 0xFE, 0x7E, 0xF0, 0x47, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x7F, 0xDE, 0xE0, 0x00, 0x00,
  0x00, 0x1D, 0xFF, 0xBC, 0x7F, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7,
  0x3B, 0xDC, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x81, 0xE0, 0x0C, 0x00, 0x00,
  0x0F, 0x87, 0xFC, 0xFF, 0xE7, 0xBF, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x0F, 0x1C, 0x3F, 0x39, 0xC7, 0xFC, 0xEE,
  0x7D, 0xE7, 0x63, 0x87, 0x3F, 0x3C, 0x39, 0xF9, 0xC1, 0xCF, 0xCE, 0x1C,
  0x7E, 0x70, 0xE3, 0xF1, 0xCF, 0xB9, 0xCF, 0xEF, 0xCE, 0x3E, 0x78, 0x78,
  0x00, 0x01, 0xE0, 0x04, 0x07, 0xE3, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xCE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3C, 0xFE, 0x03, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xE3, 0xC0, 0x4F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x06,
  0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFD, 0xE7, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x0F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3F, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFC, 0xF0,
  0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0x87, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0,
  0x7B, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xDF, 0x0F, 0x1E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7B, 0xC0, 0xF8, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x77, 0xFF, 0x07, 0x7F, 0x70, 0x77,
  0xF7, 0x0E, 0x7F, 0x78, 0xE7, 0xF3, 0x8E, 0x7F, 0x39, 0xC7, 0xF3, 0x9C,
  0x7F, 0x3D, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F,
  0x07, 0xF0, 0xF0, 0x70, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xDE, 0x1F, 0xEF, 0x0F, 0xF3, 0xC7, 0xF9,
  0xF3, 0xFC, 0x79, 0xFE, 0x3E, 0xFF, 0x0F, 0x7F, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80,
  0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F,
  0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF8, 0x7E, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0x8F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0xFE, 0x7C, 0x0F, 0x9E, 0x01,
  0xE7, 0x80, 0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF8, 0x7E, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x07,
  0xFE, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0,
  0x7B, 0xC0, 0xF8, 0x0F, 0x83, 0xFF, 0x7F, 0xF7, 0xDE, 0xF0, 0x2F, 0x00,
  0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F,
  0x80, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xBE, 0x1F, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0xF8, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xF7, 0x80,
  0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x1C, 0x07, 0xF8, 0x1F, 0x03, 0xDC, 0x0F, 0x81, 0xEF, 0x07,
  0xC0, 0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xB8, 0x78, 0xE1, 0xDC, 0x3C, 0x78,
  0xEE, 0x1C, 0x3C, 0x77, 0x9E, 0x1E, 0x7B, 0xCF, 0x07, 0x38, 0xE7, 0x83,
  0x9C, 0x73, 0x81, 0xEE, 0x3B, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC7, 0xC3, 0xC1, 0xE3, 0xC0,
  0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x78, 0xF0, 0x7C, 0x3C, 0x3C,
  0x1F, 0x3C, 0x07, 0xBE, 0x03, 0xE0, 0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x1E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1F,
  0x01, 0xF8, 0x0E, 0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D,
  0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0x70, 0x3F, 0xE1, 0xFF,
  0x8F, 0x7C, 0x00, 0xF0, 0x07, 0x87, 0xFC, 0xFF, 0xEF, 0xCF, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0x9F, 0x9C, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x9F, 0xFE, 0xFF, 0xF7, 0xC7,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF,
  0xFF, 0xBF, 0xFD, 0xCF, 0xC0, 0x1F, 0xF3, 0xFE, 0x7F, 0xE7, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x27, 0xFE, 0x3F,
  0xE1, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF1, 0xFB, 0xCF, 0xFF, 0x7F, 0xFD, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFB, 0xC7,
  0xCF, 0x1F, 0xE1, 0xFF, 0x9F, 0x3E, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1E, 0x02, 0xFF, 0xF3, 0xFF, 0x87, 0xF8,
  0x0F, 0x87, 0xF3, 0xFC, 0xF1, 0x3C, 0x0F, 0x0F, 0xFB, 0xFE, 0xFF, 0x8F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F, 0xBC,
  0x7C, 0xF0, 0x03, 0xC0, 0x1E, 0x40, 0x79, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x9F,
  0xFE, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x6F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xFF, 0xFD, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xCF, 0x0F,
  0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xBC, 0x3C, 0xF8, 0xF1, 0xF3,
  0xC3, 0xCF, 0x07, 0xBC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xE7, 0xF3, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBE,
  0x3E, 0x1E, 0xF0, 0x78, 0x7B, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xE7, 0xE7, 0x7F, 0xBF, 0xFF, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0xE7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F,
  0xFF, 0xEF, 0xFF, 0x7B, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDE, 0x1F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xFF,
  0x3F, 0xBC, 0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF, 0x8F, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x3F, 0xEF, 0xFB, 0xE7, 0x78, 0x0F,
  0x80, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0x00, 0x18, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xFE, 0x7F, 0x1F, 0x80, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xF7, 0xFB, 0x9F, 0x9C, 0xF0, 0x3E, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C, 0x0F, 0x78,
  0x1E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x78, 0x3D, 0xE1, 0xF0, 0xF7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x38,
  0xEC, 0x78, 0xF3, 0x39, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x1D, 0xCE,
  0xF0, 0x77, 0x1B, 0x81, 0xD8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x0F, 0x00, 0xF8, 0x3E, 0xF8, 0xF8, 0xF1, 0xE0, 0xF7, 0x81, 0xFF,
  0x01, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3D, 0xE0, 0xFB, 0xE1,
  0xE3, 0xC7, 0x83, 0xDF, 0x07, 0xC0, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x1E, 0xF0, 0x1D,
  0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x87, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x1E, 0x0F, 0x3F, 0x1F, 0x0F, 0xC1, 0xF0, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xF8, 0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x07, 0xE1, 0xF1, 0xF9, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x8F, 0xC7, 0xC3, 0xC0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0,
};

const GFXglyph NotoSans_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 9, 7, 12, 2, -19 },
  { 21, 15, 19, 17, 1, -19 },
  { 57, 13, 22, 15, 1, -20 },
  { 93, 22, 19, 23, 1, -19 },
  { 146, 19, 19, 20, 1, -19 },
  { 192, 3, 7, 7, 2, -19 },
  { 195, 7, 23, 9, 1, -19 },
  { 216, 7, 23, 9, 1, -19 },
  { 237, 12, 12, 14, 1, -20 },
  { 255, 13, 13, 15, 1, -16 },
  { 277, 5, 6, 7, 1, -3 },
  { 281, 7, 4, 8, 1, -9 },
  { 285, 5, 4, 7, 1, -4 },
  { 288, 11, 19, 11, 0, -19 },
  { 315, 13, 19, 15, 1, -19 },
  { 346, 9, 19, 15, 2, -19 },
  { 368, 13, 19, 15, 1, -19 },
  { 399, 13, 19, 15, 1, -19 },
  { 430, 14, 19, 15, 0, -19 },
  { 464, 13, 19, 15, 1, -19 },
  { 495, 13, 19, 15, 1, -19 },
  { 526, 13, 19, 15, 1, -19 },
  { 557, 13, 19, 15, 1, -19 },
  { 588, 13, 19, 15, 1, -19 },
  { 619, 5, 14, 7, 1, -14 },
  { 628, 5, 17, 7, 1, -14 },
  { 639, 13, 13, 15, 1, -16 },
  { 661, 13, 8, 15, 1, -13 },
  { 674, 13, 13, 15, 1, -16 },
  { 696, 12, 19, 12, 0, -19 },
  { 725, 21, 21, 23, 1, -19 },
  { 781, 18, 19, 18, 0, -19 },
  { 824, 14, 19, 17, 2, -19 },
  { 858, 15, 19, 17, 1, -19 },
  { 894, 16, 19, 19, 2, -19 },
  { 932, 11, 19, 15, 2, -19 },
  { 959, 11, 19, 14, 2, -19 },
  { 986, 15, 19, 19, 2, -19 },
  { 1022, 16, 19, 20, 2, -19 },
  { 1060, 8, 19, 10, 1, -19 },
  { 1079, 8, 24, 9, -2, -19 },
  { 1103, 15, 19, 17, 2, -19 },
  { 1139, 12, 19, 15, 2, -19 },
  { 1168, 20, 19, 25, 2, -19 },
  { 1216, 17, 19, 21, 2, -19 },
  { 1257, 18, 19, 21, 1, -19 },
  { 1300, 13, 19, 16, 2, -19 },
  { 1331, 18, 23, 21, 1, -19 },
  { 1383, 15, 19, 17, 2, -19 },
  { 1419, 12, 19, 14, 1, -19 },
  { 1448, 15, 19, 15, 0, -19 },
  { 1484, 15, 19, 20, 2, -19 },
  { 1520, 17, 19, 17, 0, -19 },
  { 1561, 25, 19, 25, 0, -19 },
  { 1621, 17, 19, 17, 0, -19 },
  { 1662, 16, 19, 16, 0, -19 },
  { 1700, 13, 19, 15, 1, -19 },
  { 1731, 6, 23, 9, 2, -19 },
  { 1749, 11, 19, 11, 0, -19 },
  { 1776, 6, 23, 9, 1, -19 },
  { 1794, 13, 12, 15, 1, -19 },
  { 1814, 11, 2, 11, 0, 2 },
  { 1817, 7, 4, 9, 1, -20 },
  { 1821, 13, 14, 16, 1, -14 },
  { 1844, 13, 20, 16, 2, -20 },
  { 1877, 12, 14, 13, 1, -14 },
  { 1898, 14, 20, 16, 1, -20 },
  { 1933, 13, 14, 16, 1, -14 },
  { 1956, 10, 20, 10, 1, -20 },
  { 1981, 14, 20, 16, 1, -14 },
  { 2016, 13, 20, 17, 2, -20 },
  { 2049, 4, 20, 8, 2, -20 },
  { 2059, 7, 26, 8, -1, -20 },
  { 2082, 14, 20, 16, 2, -20 },
  { 2117, 4, 20, 8, 2, -20 },
  { 2127, 22, 14, 25, 2, -14 },
  { 2166, 13, 14, 17, 2, -14 },
  { 2189, 14, 14, 16, 1, -14 },
  { 2214, 13, 20, 16, 2, -14 },
  { 2247, 14, 20, 16, 1, -14 },
  { 2282, 9, 14, 12, 2, -14 },
  { 2298, 11, 14, 13, 1, -14 },
  { 2318, 9, 17, 11, 1, -17 },
  { 2338, 13, 14, 17, 2, -14 },
  { 2361, 15, 14, 15, 0, -14 },
  { 2388, 22, 14, 22, 0, -14 },
  { 2427, 15, 14, 15, 0, -14 },
  { 2454, 15, 20, 15, 0, -14 },
  { 2492, 11, 14, 13, 1, -14 },
  { 2512, 9, 23, 10, 0, -19 },
  { 2538, 3, 26, 14, 6, -20 },
  { 2548, 9, 23, 10, 1, -19 },
  { 2574, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_Bold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold26pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_BOLD26PT7B_H_
