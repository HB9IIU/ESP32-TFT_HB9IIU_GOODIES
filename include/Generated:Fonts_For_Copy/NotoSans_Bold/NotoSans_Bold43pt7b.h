#ifndef _NOTOSANS_BOLD43PT7B_H_
#define _NOTOSANS_BOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF0, 0x7B, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xC0, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xE0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xF3,
  0x87, 0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0xB8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3B, 0xFC, 0x01, 0xCF, 0xE0,
  0x0E, 0x3F, 0x80, 0x73, 0xFF, 0x83, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0x00,
  0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x3E, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE3, 0xE1, 0xE0, 0x3E, 0x3E,
  0x3E, 0x3F, 0xC1, 0xF1, 0xF3, 0xF3, 0xFF, 0x07, 0xFF, 0x9F, 0x3F, 0xFC,
  0x3F, 0xF9, 0xF1, 0xFB, 0xF0, 0xFF, 0x8F, 0x9F, 0x8F, 0x83, 0xF8, 0xF8,
  0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x7C,
  0x3E, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE,
  0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x3F, 0xFE,
  0x03, 0xF1, 0xFF, 0xFC, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3,
  0xF8, 0xFE, 0x0F, 0xEF, 0xE3, 0xF8, 0x1F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC,
  0x3F, 0x80, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x9F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0xFB, 0xEF, 0x80, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x81, 0xE0,
  0xCF, 0xCF, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xF0,
  0x0F, 0x8F, 0xC0, 0xFC, 0x7F, 0x03, 0xE1, 0xE0, 0x06, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xC7, 0xF1, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7E, 0x7E, 0x07, 0xF3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0xF9, 0xFD, 0xE3, 0xF9, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0x87, 0xF8, 0xF0,
  0x1F, 0xC6, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x07, 0xF8, 0xC0, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F,
  0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x80, 0x07, 0xF7, 0x80, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0xE1, 0xFB, 0xFF, 0xC7, 0xDF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0,
  0x7F, 0x3F, 0x01, 0xFC, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC3, 0xF8, 0xFF, 0x1F, 0xC0, 0xFE, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xFC,
  0x7F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE,
  0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFB, 0xF1, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x08, 0x1E, 0x1F, 0x8F, 0xEF, 0xF3, 0xF9, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0x87, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xE0, 0xFE, 0x30, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x01,
  0xFE, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0xF8, 0xF8, 0x7F, 0xFF, 0x1F, 0x3E,
  0x1F, 0xFF, 0xE1, 0xE7, 0xC3, 0xF0, 0x7C, 0x3C, 0xF0, 0xFC, 0x0F, 0x07,
  0xFE, 0x1F, 0x01, 0xE0, 0xFF, 0xC3, 0xE0, 0x3C, 0x1F, 0xF8, 0x78, 0x0F,
  0x83, 0xFF, 0x1F, 0x01, 0xF0, 0x7B, 0xE3, 0xE0, 0x3E, 0x0F, 0x7C, 0x3C,
  0x07, 0xC3, 0xEF, 0x87, 0xC0, 0xF8, 0x7D, 0xF0, 0xF8, 0x3F, 0x1F, 0x3E,
  0x1F, 0xFF, 0xFF, 0xE3, 0xC1, 0xFF, 0xDF, 0xF8, 0x7C, 0x1F, 0xF1, 0xFE,
  0x0F, 0x81, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xF0, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x1F,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7E, 0x1F, 0xE0, 0x04,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x02, 0x1F, 0xF0, 0x1E, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F, 0xF9, 0xF8, 0x03,
  0xFE, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x03, 0xFD,
  0xF8, 0x01, 0xFC, 0xFC, 0x03, 0xFE, 0x7E, 0x1F, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x8F,
  0xC1, 0xFF, 0x00, 0x30, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xDF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xC7, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0x8F,
  0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xE0,
  0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFF, 0x1F,
  0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xFB, 0xF0, 0x01, 0xFE,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xFB,
  0xE0, 0x07, 0xDF, 0xFD, 0xF8, 0x03, 0xEF, 0xFE, 0x7C, 0x03, 0xF7, 0xFF,
  0xBE, 0x01, 0xF3, 0xFF, 0xDF, 0x80, 0xF9, 0xFF, 0xEF, 0xC0, 0xFC, 0xFF,
  0xF3, 0xE0, 0x7C, 0x7F, 0xF9, 0xF0, 0x3E, 0x3F, 0xFC, 0xFC, 0x3F, 0x1F,
  0xFE, 0x3E, 0x1F, 0x0F, 0xFF, 0x1F, 0x0F, 0x87, 0xFF, 0x8F, 0xC7, 0xC3,
  0xFF, 0xC3, 0xE7, 0xC1, 0xFF, 0xE1, 0xF3, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFB, 0xF8, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0xE7, 0xF0, 0x1F, 0xFC,
  0x7F, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xF8, 0xFE, 0x0F, 0xFF, 0x1F, 0xC1,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x83, 0xF8, 0xFF, 0xF0,
  0x3F, 0x9F, 0xFE, 0x07, 0xF3, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x0F, 0xEF,
  0xFF, 0x00, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xDF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFB, 0xF0, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8,
  0xFC, 0x7E, 0x00, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0xFF, 0x9F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x7F, 0x0F,
  0xE0, 0x7D, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xDF, 0x81, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x8F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xE1, 0xF1, 0xF8, 0x03, 0xF1, 0xF8, 0x7C, 0x7E, 0x00, 0x7E,
  0x7C, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0,
  0xF9, 0xF0, 0x01, 0xFB, 0xF0, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x0F, 0xBF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0x03, 0xF8, 0x20, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFC, 0xFF, 0xE3, 0xE3, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x0F,
  0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8,
  0xFF, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF, 0x3F, 0x3F, 0xF8,
  0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0x8F, 0x1F, 0xC0, 0x23, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x05, 0xFE, 0x03,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xC3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7,
  0xF0, 0x1F, 0xDF, 0xE0, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xEF, 0xC3, 0xFF, 0x3F, 0x07, 0xF8, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x0F, 0xE7,
  0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0x0F,
  0xFC, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xF8, 0x41, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xD0, 0x00, 0x7F, 0x70, 0x07, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xE7, 0xFE, 0x3F, 0x7F, 0xFC, 0xFD,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x39, 0xFB, 0xFF,
  0xFF, 0xFF, 0x86, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x02, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x7F, 0xF9, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x83, 0xE3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFE, 0x03,
  0xF9, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xF1, 0xFF, 0x0F,
  0xDF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0xEF, 0xF0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xF8, 0x7F, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0x8F, 0xCF, 0xFE, 0x3F, 0x9F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xF7, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xFC, 0xFE, 0xFD, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0x01, 0xCF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xF9, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFE, 0xFC, 0xFF, 0xF3, 0xF0, 0xFF, 0x87, 0xC0, 0xFE, 0x00, 0x7F, 0xBF,
  0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0xC0, 0x3F, 0x7F, 0x03, 0xFE, 0x07, 0xF3, 0xF0, 0x3F,
  0xE0, 0x7E, 0x3F, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x7D, 0xE0, 0xFE, 0x3F,
  0x87, 0xDF, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0, 0xFC, 0x1F, 0x87, 0x9F, 0x0F,
  0xC1, 0xF8, 0xF8, 0xF1, 0xFC, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8,
  0xF9, 0xF8, 0x0F, 0xCF, 0x0F, 0x9F, 0x80, 0xFC, 0xF0, 0x79, 0xF0, 0x07,
  0xDF, 0x07, 0xBF, 0x00, 0x7D, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x07,
  0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x07,
  0xFC, 0x3F, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0B, 0xFF, 0x00,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFA, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 15, 11, 21, 3, -31 },
  { 54, 26, 31, 28, 1, -31 },
  { 155, 21, 36, 25, 2, -33 },
  { 250, 37, 31, 39, 1, -31 },
  { 394, 30, 31, 32, 2, -31 },
  { 511, 6, 11, 11, 3, -31 },
  { 520, 11, 38, 15, 2, -31 },
  { 573, 12, 38, 15, 1, -31 },
  { 630, 21, 20, 23, 1, -33 },
  { 683, 21, 21, 25, 2, -26 },
  { 739, 9, 11, 12, 1, -5 },
  { 752, 12, 5, 14, 1, -14 },
  { 760, 8, 8, 12, 2, -7 },
  { 768, 18, 31, 18, 0, -31 },
  { 838, 21, 31, 25, 2, -31 },
  { 920, 15, 31, 25, 3, -31 },
  { 979, 21, 31, 25, 2, -31 },
  { 1061, 21, 31, 25, 2, -31 },
  { 1143, 23, 31, 25, 1, -31 },
  { 1233, 21, 31, 25, 2, -31 },
  { 1315, 22, 31, 25, 1, -31 },
  { 1401, 22, 31, 25, 1, -31 },
  { 1487, 22, 31, 25, 1, -31 },
  { 1573, 22, 31, 25, 1, -31 },
  { 1659, 8, 25, 12, 2, -24 },
  { 1684, 9, 30, 12, 1, -24 },
  { 1718, 21, 23, 25, 2, -27 },
  { 1779, 21, 13, 25, 2, -22 },
  { 1814, 21, 23, 25, 2, -27 },
  { 1875, 20, 32, 21, 0, -31 },
  { 1955, 35, 34, 39, 2, -31 },
  { 2104, 30, 31, 30, 0, -31 },
  { 2221, 22, 31, 29, 4, -31 },
  { 2307, 24, 31, 28, 2, -31 },
  { 2400, 25, 31, 31, 4, -31 },
  { 2497, 18, 31, 24, 4, -31 },
  { 2567, 17, 31, 24, 4, -31 },
  { 2633, 26, 31, 31, 2, -31 },
  { 2734, 25, 31, 33, 4, -31 },
  { 2831, 14, 31, 17, 1, -31 },
  { 2886, 13, 40, 14, -3, -31 },
  { 2951, 25, 31, 29, 4, -31 },
  { 3048, 19, 31, 24, 4, -31 },
  { 3122, 33, 31, 41, 4, -31 },
  { 3250, 27, 31, 35, 4, -31 },
  { 3355, 30, 31, 34, 2, -31 },
  { 3472, 21, 31, 27, 4, -31 },
  { 3554, 30, 38, 34, 2, -31 },
  { 3697, 24, 31, 28, 4, -31 },
  { 3790, 20, 31, 24, 2, -31 },
  { 3868, 23, 31, 25, 1, -31 },
  { 3958, 25, 31, 33, 4, -31 },
  { 4055, 28, 31, 28, 0, -31 },
  { 4164, 42, 31, 42, 0, -31 },
  { 4327, 29, 31, 29, 0, -31 },
  { 4440, 27, 31, 27, 0, -31 },
  { 4545, 23, 31, 25, 1, -31 },
  { 4635, 10, 38, 14, 3, -31 },
  { 4683, 18, 31, 18, 0, -31 },
  { 4753, 10, 38, 14, 1, -31 },
  { 4801, 23, 20, 25, 1, -31 },
  { 4859, 18, 3, 18, 0, 4 },
  { 4866, 12, 7, 16, 2, -33 },
  { 4877, 21, 24, 26, 2, -24 },
  { 4940, 22, 33, 27, 3, -33 },
  { 5031, 19, 24, 22, 2, -24 },
  { 5088, 22, 33, 27, 2, -33 },
  { 5179, 22, 24, 26, 2, -24 },
  { 5245, 18, 33, 17, 1, -33 },
  { 5320, 22, 34, 27, 2, -24 },
  { 5414, 22, 33, 28, 3, -33 },
  { 5505, 7, 33, 13, 3, -33 },
  { 5534, 12, 43, 13, -2, -33 },
  { 5599, 24, 33, 27, 3, -33 },
  { 5698, 7, 33, 13, 3, -33 },
  { 5727, 36, 24, 42, 3, -24 },
  { 5835, 22, 24, 28, 3, -24 },
  { 5901, 23, 24, 27, 2, -24 },
  { 5970, 22, 34, 27, 3, -24 },
  { 6064, 22, 34, 27, 2, -24 },
  { 6158, 16, 24, 19, 3, -24 },
  { 6206, 18, 24, 22, 2, -24 },
  { 6260, 16, 28, 19, 1, -28 },
  { 6316, 22, 23, 28, 3, -23 },
  { 6380, 25, 23, 25, 0, -23 },
  { 6452, 36, 23, 37, 0, -23 },
  { 6556, 25, 23, 25, 0, -23 },
  { 6628, 25, 33, 25, 0, -23 },
  { 6732, 19, 23, 21, 1, -23 },
  { 6787, 14, 38, 17, 1, -31 },
  { 6854, 4, 43, 24, 10, -33 },
  { 6876, 14, 38, 17, 2, -31 },
  { 6943, 21, 7, 25, 2, -19 },
};

const GFXfont NotoSans_Bold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold43pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_BOLD43PT7B_H_
