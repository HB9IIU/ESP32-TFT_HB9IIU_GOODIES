#ifndef _NOTOSANS_BOLD40PT7B_H_
#define _NOTOSANS_BOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC2, 0x00, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0x79, 0xE0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1,
  0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC,
  0xE0, 0x9F, 0x9C, 0x03, 0xF3, 0x80, 0x7F, 0x70, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x77, 0xF0, 0x0E, 0x7E, 0x01, 0xCF, 0xF0, 0x39, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x1F,
  0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x87, 0xC1,
  0xF0, 0x03, 0xE1, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x1F, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x03, 0xE1, 0xF3, 0xE0, 0xC0, 0x78,
  0x78, 0xF9, 0xFE, 0x1F, 0x3E, 0x7C, 0xFF, 0xC7, 0xFF, 0x9E, 0x7F, 0xF8,
  0xFF, 0xCF, 0x9F, 0xBE, 0x1F, 0xE3, 0xC7, 0xC7, 0x81, 0xE1, 0xF3, 0xE1,
  0xF0, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0xF8,
  0x1E, 0x1F, 0x00, 0x7C, 0x07, 0xC7, 0x80, 0x1E, 0x01, 0xFF, 0xE0, 0x0F,
  0x80, 0x3F, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x0F, 0xE3, 0xFF, 0xC0, 0xFC, 0x7F, 0xFE, 0x0F, 0xCF,
  0xE7, 0xF1, 0xF8, 0xFE, 0x3F, 0x9F, 0x8F, 0xC1, 0xFF, 0xF8, 0xFC, 0x0F,
  0xFF, 0x0F, 0xC0, 0x7F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xF9, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0x80, 0x07, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x0F, 0x0E, 0x7E, 0xF7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x0F,
  0x9F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x00, 0x60, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7F, 0x07,
  0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x7E,
  0x7E, 0x78, 0xFC, 0x43, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xE1, 0xFC, 0x38, 0x0F, 0xE2, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xF0, 0x3F, 0x88, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xFC, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xEF,
  0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F,
  0x87, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0x00, 0xF9, 0xFF, 0x07, 0xDF,
  0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xF0, 0xFE, 0xFE, 0x03, 0xF7,
  0xF0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01,
  0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0xDF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE3,
  0xF0, 0x7E, 0x3F, 0x8F, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x07,
  0xF7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xE0,
  0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0,
  0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x07,
  0xF1, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x30, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00,
  0x3E, 0x3F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE,
  0x07, 0xF2, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x07, 0xFE, 0x3E, 0x3C, 0x1F, 0xFF, 0x1E,
  0x7C, 0x3F, 0xFF, 0x1F, 0x78, 0x7E, 0x1F, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F,
  0xF8, 0xF8, 0x1F, 0x0F, 0xF0, 0xF8, 0x1F, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F,
  0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x1F, 0xF0, 0xF0, 0x3E, 0x1E,
  0xF0, 0xF8, 0x3E, 0x1E, 0xF8, 0xFC, 0x7F, 0x3E, 0xF8, 0x7F, 0xFF, 0xFC,
  0x78, 0x3F, 0xE7, 0xF8, 0x7C, 0x1F, 0xC3, 0xF0, 0x7C, 0x02, 0x00, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xD0,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xF8, 0x3F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFE, 0x3F, 0xF3, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xBF, 0x80, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0x81, 0xE3, 0xFC,
  0x00, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x06,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x1C, 0x3F, 0xC0, 0x04, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0,
  0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0,
  0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x07,
  0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8,
  0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x07,
  0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xDF, 0xFF, 0xC0, 0x1F, 0x7F, 0xEF, 0x80, 0x7D,
  0xFF, 0xBE, 0x01, 0xE7, 0xFE, 0xF8, 0x0F, 0x9F, 0xF9, 0xF0, 0x3E, 0x7F,
  0xE7, 0xC0, 0xF3, 0xFF, 0x9F, 0x07, 0xCF, 0xFE, 0x3E, 0x1F, 0x3F, 0xF8,
  0xF8, 0x78, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0x8F, 0x8F, 0x8F, 0xFE, 0x1F,
  0x3C, 0x3F, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xFF, 0x83, 0xFE,
  0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xFC,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF8, 0x0F, 0xFE, 0x7E, 0x07, 0xFF, 0x3F,
  0x83, 0xFF, 0x8F, 0xC1, 0xFF, 0xC7, 0xF0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0,
  0xFE, 0x1F, 0xF8, 0x3F, 0x8F, 0xFC, 0x0F, 0xC7, 0xFE, 0x07, 0xF3, 0xFF,
  0x01, 0xF9, 0xFF, 0x80, 0xFE, 0xFF, 0xC0, 0x3F, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE3, 0xFE,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xC3, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFE,
  0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF1,
  0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xC1, 0xEF, 0xC0, 0x0B, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xEF, 0x01, 0xF8, 0x7E, 0x07, 0xDF,
  0x03, 0xE0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0x81,
  0xF8, 0x7C, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0xF8, 0x7C, 0x03, 0xE1, 0xF1,
  0xF1, 0xF8, 0x07, 0xC3, 0xE3, 0xE3, 0xF0, 0x0F, 0xCF, 0x87, 0xC7, 0xE0,
  0x1F, 0x9F, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x3D, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xF3, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0,
  0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80,
  0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x78,
  0x07, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xF1, 0xFE,
  0x20, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xE1, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xF7,
  0xFF, 0x3E, 0x3F, 0xC3, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x7F, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xC0, 0x4F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF3, 0xF1, 0xFF, 0xBF, 0x3F,
  0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x07,
  0xF7, 0xFD, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0xFF,
  0x1F, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0x0F, 0xE7, 0xE0, 0x3E, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x27, 0xF8, 0x1E, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x30, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xC2, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xF1,
  0xF1, 0xFF, 0x9F, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF4, 0x00, 0x7F, 0x7C, 0x0F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x7F, 0x0F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0xFF, 0xEF, 0xFD, 0xFF,
  0x3F, 0xC1, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0x07, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFD,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFD, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0xFF, 0x03, 0xFC, 0x7C, 0xFF, 0xE7, 0xFF, 0x3E, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x07,
  0xF0, 0x1F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80,
  0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xF0,
  0x0F, 0xC0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x1F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7E, 0x03, 0xFF,
  0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0xF8, 0x7F, 0x0F, 0x9F,
  0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFD, 0xFE, 0x3F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0xF8, 0x7F, 0x0F, 0x9F, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xF1,
  0xFF, 0x9F, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0x7E, 0x07, 0xF7, 0xFC, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFB, 0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFC, 0x1E, 0xFC, 0x02, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0xC7, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xFB, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1, 0xFF, 0x1F,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x03,
  0xE7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x3E, 0x07, 0xF8,
  0x1F, 0x8F, 0xC3, 0xFF, 0x07, 0xC3, 0xF0, 0xFB, 0xC3, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x1F, 0x0F, 0x3C, 0x3E, 0x07, 0xE7, 0xCF, 0x9F, 0x81, 0xF9,
  0xF1, 0xE7, 0xE0, 0x3E, 0x78, 0x79, 0xF8, 0x0F, 0x9E, 0x1E, 0x7C, 0x03,
  0xF7, 0x87, 0xDF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xF7, 0xF0,
  0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC, 0x0F, 0xC7,
  0xF0, 0x1F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x18, 0x0F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x1F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 30, 11, 2, -29 },
  { 28, 15, 11, 19, 2, -29 },
  { 49, 24, 29, 26, 1, -29 },
  { 136, 19, 32, 23, 2, -30 },
  { 212, 34, 29, 36, 1, -29 },
  { 336, 28, 29, 30, 2, -29 },
  { 438, 6, 11, 11, 2, -29 },
  { 447, 10, 35, 14, 2, -29 },
  { 491, 11, 35, 14, 1, -29 },
  { 540, 20, 18, 22, 1, -30 },
  { 585, 19, 20, 23, 2, -24 },
  { 633, 8, 10, 11, 1, -5 },
  { 643, 11, 5, 13, 1, -13 },
  { 650, 7, 7, 11, 2, -6 },
  { 657, 16, 29, 17, 0, -29 },
  { 715, 20, 29, 23, 1, -29 },
  { 788, 15, 29, 23, 2, -29 },
  { 843, 20, 29, 23, 2, -29 },
  { 916, 19, 29, 23, 2, -29 },
  { 985, 21, 29, 23, 1, -29 },
  { 1062, 19, 29, 23, 2, -29 },
  { 1131, 21, 29, 23, 1, -29 },
  { 1208, 21, 29, 23, 1, -29 },
  { 1285, 20, 29, 23, 1, -29 },
  { 1358, 20, 29, 23, 1, -29 },
  { 1431, 7, 23, 11, 2, -22 },
  { 1452, 8, 27, 11, 1, -22 },
  { 1479, 19, 21, 23, 2, -25 },
  { 1529, 19, 12, 23, 2, -20 },
  { 1558, 19, 21, 23, 2, -25 },
  { 1608, 18, 30, 19, 0, -29 },
  { 1676, 32, 32, 36, 2, -29 },
  { 1804, 28, 29, 28, 0, -29 },
  { 1906, 22, 29, 27, 3, -29 },
  { 1986, 22, 29, 26, 2, -29 },
  { 2066, 24, 29, 29, 3, -29 },
  { 2153, 16, 29, 22, 4, -29 },
  { 2211, 16, 29, 22, 4, -29 },
  { 2269, 24, 29, 29, 2, -29 },
  { 2356, 23, 29, 31, 4, -29 },
  { 2440, 13, 29, 16, 1, -29 },
  { 2488, 13, 37, 13, -3, -29 },
  { 2549, 23, 29, 27, 4, -29 },
  { 2633, 18, 29, 22, 3, -29 },
  { 2699, 30, 29, 38, 4, -29 },
  { 2808, 25, 29, 33, 4, -29 },
  { 2899, 27, 29, 32, 2, -29 },
  { 2997, 20, 29, 25, 3, -29 },
  { 3070, 27, 36, 32, 2, -29 },
  { 3192, 23, 29, 26, 3, -29 },
  { 3276, 18, 29, 22, 2, -29 },
  { 3342, 21, 29, 23, 1, -29 },
  { 3419, 24, 29, 30, 3, -29 },
  { 3506, 26, 29, 26, 0, -29 },
  { 3601, 39, 29, 39, 0, -29 },
  { 3743, 27, 29, 27, 0, -29 },
  { 3841, 25, 29, 25, 0, -29 },
  { 3932, 21, 29, 23, 1, -29 },
  { 4009, 9, 35, 13, 3, -29 },
  { 4049, 16, 29, 17, 0, -29 },
  { 4107, 9, 35, 13, 1, -29 },
  { 4147, 21, 19, 23, 1, -29 },
  { 4197, 17, 2, 16, 0, 4 },
  { 4202, 11, 7, 15, 2, -31 },
  { 4212, 19, 22, 24, 2, -22 },
  { 4265, 20, 30, 25, 3, -30 },
  { 4340, 18, 22, 21, 2, -22 },
  { 4390, 20, 30, 25, 2, -30 },
  { 4465, 20, 22, 24, 2, -22 },
  { 4520, 16, 31, 15, 1, -31 },
  { 4582, 20, 32, 25, 2, -22 },
  { 4662, 20, 30, 26, 3, -30 },
  { 4737, 6, 30, 12, 3, -30 },
  { 4760, 11, 40, 12, -2, -30 },
  { 4815, 22, 30, 25, 3, -30 },
  { 4898, 6, 30, 12, 3, -30 },
  { 4921, 33, 22, 39, 3, -22 },
  { 5012, 20, 22, 26, 3, -22 },
  { 5067, 21, 22, 25, 2, -22 },
  { 5125, 20, 32, 25, 3, -22 },
  { 5205, 20, 32, 25, 2, -22 },
  { 5285, 14, 22, 18, 3, -22 },
  { 5324, 16, 22, 20, 2, -22 },
  { 5368, 15, 26, 17, 1, -26 },
  { 5417, 20, 22, 26, 3, -22 },
  { 5472, 23, 22, 23, 0, -22 },
  { 5536, 34, 22, 34, 0, -22 },
  { 5630, 23, 22, 23, 0, -22 },
  { 5694, 23, 32, 23, 0, -22 },
  { 5786, 17, 22, 20, 1, -22 },
  { 5833, 13, 35, 16, 1, -29 },
  { 5890, 4, 39, 22, 9, -30 },
  { 5910, 13, 35, 16, 2, -29 },
  { 5967, 19, 6, 23, 2, -17 },
};

const GFXfont NotoSans_Bold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold40pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_BOLD40PT7B_H_
