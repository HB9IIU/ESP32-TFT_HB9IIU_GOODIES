#ifndef _NOTOSANS_BOLD12PT7B_H_
#define _NOTOSANS_BOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA3, 0xC0, 0xBB, 0xB9, 0x16, 0x28, 0xD3, 0xF2, 0xDF, 0xFF,
  0xB4, 0x68, 0x27, 0xEB, 0xCF, 0x1E, 0xBF, 0x21, 0x00, 0x61, 0x14, 0xCD,
  0x23, 0x58, 0x55, 0xCB, 0xD0, 0xB4, 0x65, 0x31, 0xC0, 0x18, 0x3E, 0x1B,
  0x05, 0x83, 0x1B, 0xDB, 0x3C, 0xCC, 0x7F, 0x80, 0xF0, 0x32, 0x64, 0x4C,
  0x44, 0x46, 0x30, 0xC6, 0x62, 0x33, 0x32, 0x26, 0xC0, 0x32, 0x5F, 0xCE,
  0x68, 0xA0, 0x21, 0x3E, 0x42, 0x10, 0x6B, 0x00, 0xFC, 0xF0, 0x18, 0xCC,
  0x62, 0x31, 0x88, 0xC0, 0x39, 0xF4, 0xD1, 0xC7, 0x14, 0xDB, 0x38, 0x37,
  0xFB, 0x33, 0x33, 0x30, 0x3B, 0xF4, 0xC3, 0x0C, 0x63, 0x1F, 0xFC, 0x3B,
  0xF0, 0xC3, 0x30, 0x30, 0xE3, 0xF8, 0x0C, 0x38, 0x71, 0x66, 0xC9, 0xBF,
  0x86, 0x0C, 0xFF, 0xF1, 0x8F, 0x8C, 0x73, 0xF0, 0x1C, 0xF6, 0x16, 0xFF,
  0x14, 0x5B, 0x3C, 0xFF, 0xF0, 0xC3, 0x18, 0x63, 0x0C, 0x60, 0x39, 0xF4,
  0xDB, 0x39, 0xBC, 0x53, 0x7C, 0x31, 0xFC, 0xF1, 0x6D, 0xD0, 0xC7, 0x78,
  0xB0, 0x3C, 0x4C, 0x00, 0x1A, 0xC0, 0x08, 0xDD, 0x8E, 0x1C, 0x20, 0xF8,
  0x3F, 0xF0, 0x86, 0x1C, 0x33, 0xF2, 0x00, 0x77, 0xC2, 0x33, 0x10, 0x04,
  0x70, 0x1C, 0x3B, 0xB0, 0x73, 0xDA, 0x6D, 0x36, 0xDF, 0x36, 0x42, 0x1F,
  0x00, 0x18, 0x1C, 0x3C, 0x34, 0x26, 0x7E, 0x7E, 0x43, 0xC3, 0xF3, 0xFC,
  0xF3, 0xFB, 0x3C, 0xF3, 0xF8, 0x39, 0xFC, 0x30, 0xC3, 0x0C, 0x39, 0x7C,
  0xF1, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0xF8, 0xFF, 0xF1, 0x8F, 0xE3,
  0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC0, 0x1C, 0xFF, 0x06, 0x0D,
  0xFB, 0xF1, 0xF3, 0x7E, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3, 0xC6,
  0xFF, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE4, 0xC7,
  0x9B, 0x66, 0xCF, 0x1F, 0x36, 0x66, 0xC6, 0xC6, 0x31, 0x8C, 0x63, 0x1F,
  0xF8, 0xE1, 0xF1, 0xF8, 0xFC, 0x5F, 0x6E, 0xB7, 0x53, 0xB9, 0xCC, 0x80,
  0xC3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xC7, 0xC7, 0x38, 0x7E, 0xC6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xEE, 0x7C, 0xF3, 0xFC, 0xF3, 0xFF, 0xEC, 0x30,
  0xC0, 0x38, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xEE, 0x7C, 0x0C, 0x07,
  0xF1, 0xFB, 0x36, 0x6F, 0x9F, 0x36, 0x66, 0xCE, 0x77, 0xE1, 0x8F, 0x1C,
  0x73, 0xF0, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7C, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x2C,
  0x3C, 0x38, 0x18, 0xC6, 0x3C, 0x62, 0x4E, 0x64, 0xE6, 0x6B, 0x66, 0xB4,
  0x39, 0xC3, 0x9C, 0x31, 0xC0, 0xC3, 0x66, 0x24, 0x3C, 0x18, 0x3C, 0x3C,
  0x66, 0xC3, 0xC7, 0x66, 0x6C, 0x2C, 0x38, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFC, 0x30, 0xC1, 0x86, 0x18, 0x3F, 0xFE, 0xFE, 0x49, 0x24, 0x93, 0x80,
  0xC6, 0x10, 0xC2, 0x18, 0xC2, 0x18, 0xFC, 0x92, 0x49, 0x27, 0x80, 0x10,
  0x60, 0xE3, 0x44, 0xD8, 0xC0, 0xF8, 0xE3, 0x39, 0xF0, 0x5F, 0x47, 0x37,
  0x40, 0xC3, 0x0D, 0x3F, 0xCF, 0x3C, 0xF3, 0xB8, 0x37, 0xF1, 0x08, 0x65,
  0xE0, 0x0C, 0x36, 0xFF, 0xCE, 0x38, 0xF7, 0xFC, 0x33, 0xEC, 0xFF, 0x83,
  0x27, 0x80, 0x3B, 0x1F, 0xF6, 0x31, 0x8C, 0x60, 0x6F, 0xFC, 0xE3, 0x8F,
  0x7F, 0xC3, 0xFB, 0xC0, 0xC3, 0x0D, 0xBF, 0xCF, 0x3C, 0xF3, 0xCC, 0xEF,
  0xFF, 0xC0, 0x32, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0x0C, 0xF6, 0xF3,
  0xCD, 0xB6, 0xCC, 0xFF, 0xFF, 0xC0, 0x99, 0xBF, 0xFC, 0xCF, 0x33, 0xCC,
  0xF3, 0x3C, 0xCC, 0x9B, 0xFC, 0xF3, 0xCF, 0x3C, 0xC0, 0x33, 0xEC, 0xE3,
  0x8F, 0x37, 0x80, 0x93, 0xFC, 0xF3, 0xCF, 0x3F, 0xB0, 0xC3, 0x00, 0x6F,
  0xFC, 0xE3, 0x8F, 0x7F, 0xC3, 0x0C, 0x30, 0x9F, 0xCC, 0xCC, 0xC0, 0x67,
  0xB1, 0xE3, 0x4F, 0xC0, 0x23, 0xFE, 0xC6, 0x31, 0xA7, 0xCF, 0x3C, 0xF3,
  0xCF, 0x7F, 0xC0, 0xC7, 0x89, 0xB3, 0x62, 0x87, 0x0E, 0x00, 0xCC, 0xF3,
  0x34, 0xED, 0xEA, 0x73, 0x8C, 0xE3, 0x30, 0xC6, 0xD8, 0xE1, 0xC3, 0x8D,
  0xB1, 0x80, 0xC7, 0x89, 0xB3, 0x62, 0x87, 0x0E, 0x18, 0xF1, 0xC0, 0x79,
  0xE1, 0x8C, 0x61, 0x8F, 0xC0, 0x13, 0x22, 0x2C, 0x62, 0x23, 0x30, 0xFF,
  0xF0, 0xC7, 0x18, 0xC2, 0x1C, 0xCC, 0x63, 0x38, 0xFC, 0xC0,
};

const GFXglyph NotoSans_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 5, 10, 7, 1, -9 },
  { 21, 10, 9, 11, 0, -9 },
  { 33, 9, 9, 9, 0, -9 },
  { 44, 1, 4, 3, 1, -9 },
  { 45, 4, 11, 4, 0, -9 },
  { 51, 4, 11, 4, 0, -9 },
  { 57, 6, 6, 7, 0, -9 },
  { 62, 5, 6, 7, 1, -7 },
  { 66, 3, 3, 3, 0, -1 },
  { 68, 3, 2, 4, 0, -4 },
  { 69, 2, 2, 3, 1, -2 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 6, 9, 7, 0, -9 },
  { 83, 4, 9, 7, 1, -9 },
  { 88, 6, 9, 7, 0, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 5, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 0, -9 },
  { 123, 6, 9, 7, 0, -9 },
  { 130, 6, 9, 7, 0, -9 },
  { 137, 6, 9, 7, 0, -9 },
  { 144, 2, 7, 3, 1, -7 },
  { 146, 3, 9, 3, 0, -7 },
  { 150, 5, 7, 7, 1, -8 },
  { 155, 5, 4, 7, 1, -6 },
  { 158, 5, 7, 7, 1, -8 },
  { 163, 5, 9, 6, 0, -9 },
  { 169, 9, 10, 11, 1, -9 },
  { 181, 8, 9, 8, 0, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 7, 9, 9, 1, -9 },
  { 212, 5, 9, 7, 1, -9 },
  { 218, 5, 9, 7, 1, -9 },
  { 224, 7, 9, 9, 1, -9 },
  { 232, 7, 9, 9, 1, -9 },
  { 240, 4, 9, 5, 0, -9 },
  { 245, 4, 12, 4, -1, -9 },
  { 251, 7, 9, 8, 1, -9 },
  { 259, 5, 9, 7, 1, -9 },
  { 265, 9, 9, 11, 1, -9 },
  { 276, 8, 9, 10, 1, -9 },
  { 285, 8, 9, 9, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 8, 11, 9, 1, -9 },
  { 312, 7, 9, 8, 1, -9 },
  { 320, 5, 9, 7, 1, -9 },
  { 326, 7, 9, 7, 0, -9 },
  { 334, 7, 9, 9, 1, -9 },
  { 342, 8, 9, 8, 0, -9 },
  { 351, 12, 9, 12, 0, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 8, 9, 8, 0, -9 },
  { 383, 7, 9, 7, 0, -9 },
  { 391, 3, 11, 4, 1, -9 },
  { 396, 5, 9, 5, 0, -9 },
  { 402, 3, 11, 4, 0, -9 },
  { 407, 7, 6, 7, 0, -9 },
  { 413, 5, 1, 5, 0, 1 },
  { 414, 4, 2, 4, 0, -9 },
  { 415, 6, 7, 7, 0, -7 },
  { 421, 6, 9, 8, 1, -9 },
  { 428, 5, 7, 6, 1, -7 },
  { 433, 6, 9, 8, 1, -9 },
  { 440, 6, 7, 7, 1, -7 },
  { 446, 5, 9, 5, 0, -9 },
  { 452, 6, 10, 8, 1, -7 },
  { 460, 6, 9, 8, 1, -9 },
  { 467, 2, 9, 4, 1, -9 },
  { 470, 4, 12, 4, -1, -9 },
  { 476, 6, 9, 7, 1, -9 },
  { 483, 2, 9, 4, 1, -9 },
  { 486, 10, 7, 12, 1, -7 },
  { 495, 6, 7, 8, 1, -7 },
  { 501, 6, 7, 8, 1, -7 },
  { 507, 6, 10, 8, 1, -7 },
  { 515, 6, 10, 8, 1, -7 },
  { 523, 4, 7, 5, 1, -7 },
  { 527, 5, 7, 6, 1, -7 },
  { 532, 5, 8, 5, 0, -8 },
  { 537, 6, 7, 8, 1, -7 },
  { 543, 7, 7, 7, 0, -7 },
  { 550, 10, 7, 10, 0, -7 },
  { 559, 7, 7, 7, 0, -7 },
  { 566, 7, 10, 7, 0, -7 },
  { 575, 6, 7, 6, 0, -7 },
  { 581, 4, 11, 5, 0, -9 },
  { 587, 1, 12, 7, 3, -9 },
  { 589, 5, 11, 5, 0, -9 },
  { 596, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_Bold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold12pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_BOLD12PT7B_H_
