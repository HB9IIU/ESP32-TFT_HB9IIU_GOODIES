#ifndef _NOTOSANS_BOLD21PT7B_H_
#define _NOTOSANS_BOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x66, 0x66, 0x00, 0xFF, 0xF0, 0xE7, 0xE7, 0xE7,
  0x66, 0x66, 0x06, 0x60, 0x33, 0x03, 0x98, 0x1C, 0xC7, 0xFF, 0xBF, 0xFC,
  0x33, 0x01, 0x98, 0x1C, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01, 0x98, 0x1C,
  0xC0, 0xCE, 0x00, 0x0C, 0x03, 0x07, 0xFF, 0xFF, 0xEC, 0xBB, 0x0F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0xFC, 0x37, 0xEF, 0xFF, 0xEF, 0xF0, 0x30, 0x0C,
  0x00, 0x78, 0x1C, 0x7E, 0x0C, 0x33, 0x8C, 0x19, 0xCE, 0x0C, 0xE6, 0x06,
  0x77, 0x03, 0x3B, 0x3D, 0xFB, 0xBF, 0x79, 0xB9, 0x81, 0xDC, 0xC0, 0xCE,
  0x60, 0xC7, 0x30, 0xE3, 0x98, 0x60, 0xFC, 0x70, 0x3C, 0x1F, 0x00, 0x7F,
  0x01, 0xCF, 0x03, 0x8E, 0x07, 0x38, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x0E,
  0xFF, 0x3D, 0xCF, 0x73, 0x8F, 0xE7, 0x0F, 0x8F, 0xBF, 0x0F, 0xFF, 0x0F,
  0xEF, 0x80, 0xFF, 0xB6, 0x19, 0xDC, 0xE6, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x71, 0x8E, 0x31, 0xC0, 0xE3, 0x1C, 0x63, 0x9C, 0xE7, 0x18, 0xCE, 0x73,
  0x9C, 0xCE, 0x67, 0x00, 0x1C, 0x07, 0x00, 0xC3, 0xB7, 0xFF, 0xCF, 0xC3,
  0xE0, 0xDC, 0x73, 0x88, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7E, 0xEC, 0xC0, 0xFF, 0xFE,
  0xFF, 0xF0, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x3F, 0x1F, 0xE7, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F,
  0xE3, 0xF0, 0x0F, 0x1F, 0x3F, 0xF7, 0x67, 0x47, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3F, 0x3F, 0xEF, 0x3D, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x3F, 0xE6, 0x3C, 0x07, 0x01, 0xC0, 0xE3, 0xF0, 0xFC, 0x3F, 0x80,
  0x70, 0x1C, 0x07, 0xC7, 0xFF, 0xEF, 0xF0, 0x01, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0D, 0xC1, 0xDC, 0x19, 0xC3, 0x1C, 0x71, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x60,
  0x3B, 0x0F, 0xFB, 0xFE, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0xE7, 0xFF, 0xEF,
  0xF0, 0x0F, 0x8F, 0xE7, 0xC5, 0xC0, 0xE0, 0x39, 0xCF, 0xFB, 0xFF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x80, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xE1, 0xDE, 0xE3, 0xF0,
  0xFC, 0x7F, 0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0xE3, 0xF0, 0x3E, 0x1F,
  0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0x7F, 0xCF, 0x70, 0x1C,
  0x0E, 0x07, 0x9F, 0xC7, 0xC0, 0x6F, 0xF6, 0x00, 0x00, 0x0F, 0xFF, 0x6F,
  0xF6, 0x00, 0x00, 0x00, 0x7E, 0xEC, 0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C,
  0x78, 0x38, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x70, 0x7C, 0xFC, 0xF8, 0x38, 0x08, 0x00, 0x7F, 0x3F, 0xE6, 0x38,
  0x07, 0x03, 0x80, 0xE0, 0xF0, 0x78, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0x01, 0xC0, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0x03, 0x86, 0x00, 0xE6,
  0x3F, 0xB3, 0x3F, 0x9F, 0x98, 0xC7, 0x9C, 0x63, 0xCE, 0x31, 0xE7, 0x19,
  0xF3, 0x9E, 0xDC, 0xFB, 0xE6, 0x18, 0xC3, 0x80, 0x00, 0xF0, 0x60, 0x3F,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x76, 0x00,
  0xEE, 0x03, 0x9C, 0x07, 0x3C, 0x0E, 0x38, 0x38, 0x70, 0x7F, 0xF0, 0xFF,
  0xE3, 0xC1, 0xC7, 0x03, 0xCE, 0x03, 0xBC, 0x07, 0x80, 0xFF, 0x1F, 0xFB,
  0xFF, 0x70, 0xFE, 0x1D, 0xC3, 0xBF, 0xE7, 0xFC, 0xE3, 0xDC, 0x3F, 0x83,
  0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xE3, 0xFF, 0x3E, 0xE7, 0x80,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x7E, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF,
  0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD,
  0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x0F, 0xF8, 0xFF, 0x8F, 0x9C, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x3F, 0xF1, 0xFF, 0x83, 0xDC, 0x1E, 0xF0, 0xF7, 0xE7, 0x9F, 0xFC, 0x3F,
  0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0xFF, 0xFD, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F,
  0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x1F, 0xFB, 0xE0, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE,
  0x38, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0E, 0x70, 0xE3, 0x8E,
  0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC,
  0x77, 0xEE, 0x77, 0xEE, 0x67, 0xE6, 0xE7, 0xE6, 0xE7, 0xE7, 0xC7, 0xE7,
  0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE3, 0xF7, 0x1F, 0xBC, 0xFC, 0xE7, 0xE7, 0xBF, 0x1D, 0xF8, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xE0, 0x0F, 0xE0, 0xFF, 0xC7, 0xEF, 0x9E,
  0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77,
  0x01, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x3F, 0xEF,
  0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0xFE, 0xFF, 0xBF, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xEF, 0x9E, 0x0F, 0x70,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDE,
  0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3,
  0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0,
  0xF0, 0x3F, 0x9F, 0xFF, 0x3B, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0xF0, 0x1E, 0x07, 0xE7, 0xBF, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0x80, 0xE0, 0x3D, 0xC0, 0xE7, 0x03, 0x9C,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x00,
  0xDC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x70, 0x7E,
  0x0F, 0x07, 0x70, 0xF0, 0x77, 0x0F, 0x8E, 0x71, 0xF8, 0xE7, 0x1F, 0x8E,
  0x39, 0xD8, 0xE3, 0x99, 0xDC, 0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x1F, 0x8D,
  0xC1, 0xF0, 0xD8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0,
  0x3D, 0xE1, 0xE3, 0x87, 0x07, 0x38, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x0F, 0x3C, 0x38, 0x71, 0xE1, 0xEF,
  0x03, 0xC0, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3, 0xDE, 0x0E, 0xE0,
  0x7F, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1E, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1B, 0x83,
  0x98, 0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x07, 0xFF, 0x80, 0xF1, 0xE1, 0xC0,
  0x0E, 0x1F, 0xE3, 0xFD, 0x07, 0x01, 0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8,
  0xFF, 0xFD, 0xF3, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE6, 0x3F, 0xEF, 0xFF,
  0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xFF, 0xFB, 0x3C, 0x0E,
  0x1F, 0xDF, 0xFE, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x3C, 0xDF, 0xE7,
  0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xCE, 0xFD, 0xDF, 0xFF, 0x8F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1E, 0xF7, 0xDF, 0xF9, 0xF7, 0x0E,
  0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x09, 0xFF, 0x0F, 0xE0, 0x0F, 0x8F, 0xCF, 0x47, 0x03, 0x87, 0xFB, 0xFC,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x07,
  0xDD, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEE, 0x3D,
  0xFF, 0x9F, 0x70, 0x0E, 0x03, 0xDC, 0xF3, 0xFE, 0x7F, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE6, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0x70, 0x07, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x1C, 0xF1, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0xFF, 0xFE, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC7, 0xB9, 0xE7, 0x78, 0xEE, 0x1F, 0x83, 0xF8, 0x7F, 0x8E, 0x71,
  0xC7, 0x38, 0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C,
  0x6F, 0xDF, 0xBF, 0xFF, 0xFC, 0x7C, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87,
  0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70,
  0x07, 0x37, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF0, 0xEE, 0x39, 0xFF, 0x0F, 0xC0, 0x06, 0x37, 0xEF, 0xFF,
  0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xFF, 0xFB, 0xFC, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0xDD, 0xFF, 0xF8, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xFE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07, 0xBF, 0xFF, 0x8E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x00, 0x1C, 0x3F, 0xFF, 0xDC, 0x0F, 0x03, 0xF0,
  0xFC, 0x1F, 0x03, 0xE3, 0xFF, 0xDF, 0xC0, 0x18, 0x18, 0x38, 0x7F, 0xFF,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x79, 0xEF, 0xFC, 0xF9,
  0x80, 0xF0, 0xF7, 0x0E, 0x70, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xDC, 0x78, 0xE7, 0x1E,
  0x39, 0xCF, 0xCE, 0x3B, 0x37, 0x0E, 0xCD, 0xC3, 0xB3, 0x70, 0xFC, 0xF8,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0xF3, 0x9E, 0x3F, 0xC1,
  0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x83, 0xFC, 0x39, 0xC7, 0x8E, 0xF0, 0xF0,
  0xF0, 0xF7, 0x0E, 0x70, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7C, 0x07, 0x80,
  0xFF, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF,
  0xE0, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0xF9, 0xE1, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1,
  0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3E, 0x3C, 0xF1, 0x83, 0x06, 0x0C,
  0x38, 0xF1, 0xE0, 0xF8, 0x7F, 0xF8, 0xFC,
};

const GFXglyph NotoSans_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 13, 15, 14, 0, -15 },
  { 39, 10, 17, 12, 1, -16 },
  { 61, 17, 15, 19, 1, -15 },
  { 93, 15, 15, 16, 1, -15 },
  { 122, 3, 5, 6, 1, -15 },
  { 124, 5, 18, 7, 1, -15 },
  { 136, 5, 18, 7, 1, -15 },
  { 148, 10, 10, 11, 1, -16 },
  { 161, 10, 11, 12, 1, -13 },
  { 175, 4, 5, 6, 1, -2 },
  { 178, 5, 3, 7, 1, -7 },
  { 180, 4, 3, 6, 1, -3 },
  { 182, 9, 15, 9, 0, -15 },
  { 199, 10, 15, 12, 1, -15 },
  { 218, 8, 15, 12, 1, -15 },
  { 233, 10, 15, 12, 1, -15 },
  { 252, 10, 15, 12, 1, -15 },
  { 271, 12, 15, 12, 0, -15 },
  { 294, 10, 15, 12, 1, -15 },
  { 313, 10, 15, 12, 1, -15 },
  { 332, 10, 15, 12, 1, -15 },
  { 351, 10, 15, 12, 1, -15 },
  { 370, 10, 15, 12, 1, -15 },
  { 389, 4, 12, 6, 1, -12 },
  { 395, 4, 15, 6, 1, -12 },
  { 403, 10, 11, 12, 1, -13 },
  { 417, 10, 7, 12, 1, -11 },
  { 426, 10, 11, 12, 1, -13 },
  { 440, 10, 15, 10, 0, -15 },
  { 459, 17, 17, 19, 1, -15 },
  { 496, 15, 15, 15, 0, -15 },
  { 525, 11, 15, 14, 2, -15 },
  { 546, 12, 15, 13, 1, -15 },
  { 569, 12, 15, 15, 2, -15 },
  { 592, 9, 15, 12, 2, -15 },
  { 609, 8, 15, 12, 2, -15 },
  { 624, 13, 15, 15, 1, -15 },
  { 649, 12, 15, 16, 2, -15 },
  { 672, 7, 15, 8, 1, -15 },
  { 686, 7, 19, 7, -2, -15 },
  { 703, 12, 15, 14, 2, -15 },
  { 726, 9, 15, 12, 2, -15 },
  { 743, 16, 15, 20, 2, -15 },
  { 773, 13, 15, 17, 2, -15 },
  { 798, 14, 15, 17, 1, -15 },
  { 825, 10, 15, 13, 2, -15 },
  { 844, 14, 19, 17, 1, -15 },
  { 878, 12, 15, 14, 2, -15 },
  { 901, 10, 15, 12, 1, -15 },
  { 920, 12, 15, 12, 0, -15 },
  { 943, 12, 15, 16, 2, -15 },
  { 966, 14, 15, 14, 0, -15 },
  { 993, 20, 15, 20, 0, -15 },
  { 1031, 14, 15, 14, 0, -15 },
  { 1058, 13, 15, 13, 0, -15 },
  { 1083, 12, 15, 12, 0, -15 },
  { 1106, 5, 18, 7, 1, -15 },
  { 1118, 9, 15, 9, 0, -15 },
  { 1135, 4, 18, 7, 1, -15 },
  { 1144, 12, 10, 12, 0, -15 },
  { 1159, 9, 1, 9, 0, 2 },
  { 1161, 6, 3, 8, 1, -16 },
  { 1164, 10, 12, 13, 1, -12 },
  { 1179, 10, 16, 13, 2, -16 },
  { 1199, 9, 12, 11, 1, -12 },
  { 1213, 11, 16, 13, 1, -16 },
  { 1235, 11, 12, 13, 1, -12 },
  { 1252, 9, 16, 8, 0, -16 },
  { 1270, 11, 17, 13, 1, -12 },
  { 1294, 10, 16, 14, 2, -16 },
  { 1314, 4, 16, 6, 1, -16 },
  { 1322, 6, 21, 6, -1, -16 },
  { 1338, 11, 16, 13, 2, -16 },
  { 1360, 3, 16, 6, 2, -16 },
  { 1366, 17, 12, 20, 2, -12 },
  { 1392, 10, 12, 14, 2, -12 },
  { 1407, 11, 12, 13, 1, -12 },
  { 1424, 10, 17, 13, 2, -12 },
  { 1446, 11, 17, 13, 1, -12 },
  { 1470, 7, 12, 9, 2, -12 },
  { 1481, 9, 12, 11, 1, -12 },
  { 1495, 8, 14, 9, 0, -14 },
  { 1509, 11, 11, 14, 1, -11 },
  { 1525, 12, 11, 12, 0, -11 },
  { 1542, 18, 11, 18, 0, -11 },
  { 1567, 12, 11, 12, 0, -11 },
  { 1584, 12, 16, 12, 0, -11 },
  { 1608, 9, 11, 10, 1, -11 },
  { 1621, 7, 18, 8, 0, -15 },
  { 1637, 2, 21, 12, 5, -16 },
  { 1643, 7, 18, 8, 1, -15 },
  { 1659, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_Bold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold21pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_BOLD21PT7B_H_
