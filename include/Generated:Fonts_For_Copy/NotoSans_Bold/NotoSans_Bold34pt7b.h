#ifndef _NOTOSANS_BOLD34PT7B_H_
#define _NOTOSANS_BOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFE, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF0, 0x01, 0xE3, 0xC0,
  0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70,
  0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x01, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC,
  0xF9, 0x8C, 0xF8, 0xC0, 0x3E, 0x60, 0x1F, 0xB0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x67, 0xC0,
  0x33, 0xF8, 0x19, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0xC0, 0xF8, 0x0F,
  0x9E, 0x07, 0x80, 0x78, 0xF0, 0x78, 0x03, 0xC7, 0x83, 0xC0, 0x1E, 0x1E,
  0x3C, 0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x8F, 0x9E, 0x00, 0x3C, 0x78, 0xF3,
  0xE1, 0xF3, 0xCF, 0x3F, 0xC7, 0xFE, 0xFB, 0xFE, 0x3F, 0xE7, 0x9E, 0xF8,
  0xFE, 0x79, 0xE3, 0xC1, 0xC3, 0xCF, 0x1E, 0x00, 0x3C, 0x78, 0x78, 0x01,
  0xE3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0xF0, 0x0F, 0x07,
  0x8F, 0x00, 0xF8, 0x1E, 0x78, 0x07, 0x80, 0xFF, 0xC0, 0x78, 0x03, 0xFC,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xF1, 0xFF, 0xC1, 0xF1,
  0xFF, 0xF1, 0xF8, 0xFC, 0xFC, 0xF8, 0x7C, 0x3F, 0xFC, 0x7E, 0x0F, 0xFC,
  0x3F, 0x03, 0xFE, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x0F, 0xFC, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xBD, 0xCE, 0x70, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x0F, 0x8F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xF1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x1E, 0x3E, 0x04, 0x30, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0xF9, 0xF3,
  0xE7, 0x8F, 0x3E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF,
  0x83, 0xE7, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF7,
  0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xE0, 0xF8, 0x40, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x0F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81,
  0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x8F, 0x03, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x80, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0x71, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x3C, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF8,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03, 0xEF,
  0x81, 0xF7, 0xE1, 0xF9, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0x7E, 0x1F, 0x1F,
  0x9F, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF8,
  0xFC, 0x7E, 0x7C, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFB, 0xFB, 0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0x80,
  0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0xFB, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xF7,
  0xF7, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xDF, 0x02, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x00, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0x80, 0x3C, 0xF9, 0xFB, 0xF7, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0xF9, 0xF3,
  0xC7, 0x9F, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x20, 0x3E, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x81,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x9F, 0x07, 0xF8, 0xF3, 0xC3, 0xFF,
  0x8E, 0x70, 0xFF, 0xF1, 0xFE, 0x3E, 0x1E, 0x3F, 0xC7, 0x83, 0xC7, 0xF9,
  0xF0, 0x78, 0xFE, 0x3C, 0x0F, 0x1F, 0xC7, 0x81, 0xE3, 0xF8, 0xF0, 0x3C,
  0x7F, 0x1E, 0x0F, 0x8E, 0xE1, 0xE1, 0xF3, 0xDE, 0x3F, 0xFF, 0xF3, 0xC3,
  0xFD, 0xFE, 0x3C, 0x3F, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xC0, 0x06, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xEF, 0x80,
  0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFF, 0x3E,
  0x1F, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7E, 0x03, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x1C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F,
  0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF,
  0x87, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xF8, 0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xF7,
  0xE0, 0x1F, 0x3F, 0x81, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x87, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFE,
  0x3F, 0xFF, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0xF8, 0x07, 0xFF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC,
  0x0F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xE0, 0x1F, 0xFF,
  0x78, 0x07, 0xFF, 0xDE, 0x03, 0xDF, 0xFB, 0xC0, 0xF7, 0xFE, 0xF0, 0x3D,
  0xFF, 0xBC, 0x1F, 0x7F, 0xEF, 0x87, 0x9F, 0xF9, 0xE1, 0xE7, 0xFE, 0x78,
  0xF9, 0xFF, 0x9F, 0x3C, 0x7F, 0xE3, 0xCF, 0x1F, 0xF8, 0xF7, 0xC7, 0xFE,
  0x3F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x07,
  0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xF3, 0xF0, 0x7F, 0xE7,
  0xC1, 0xFF, 0x9F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF9,
  0xFF, 0x83, 0xE7, 0xFE, 0x0F, 0xDF, 0xF8, 0x1F, 0x7F, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x83, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xBE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x83,
  0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x03,
  0xE3, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xC7, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x7C, 0x0F,
  0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0x03, 0x80,
  0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x81, 0xBE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0x0F, 0x9F, 0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE,
  0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x3D,
  0xE0, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x0F,
  0xBC, 0x1E, 0x07, 0xC7, 0x9F, 0x1F, 0x03, 0xE3, 0xC7, 0x8F, 0x81, 0xF1,
  0xE3, 0xC7, 0xC0, 0x79, 0xF1, 0xE3, 0xC0, 0x3C, 0xF0, 0xFB, 0xE0, 0x1F,
  0x78, 0x3D, 0xF0, 0x0F, 0xBC, 0x1E, 0xF8, 0x03, 0xDE, 0x0F, 0x78, 0x01,
  0xFE, 0x07, 0xBC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0xF8, 0x7E, 0x01, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF,
  0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x03, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF,
  0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xF3, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7E, 0xFC, 0xFF, 0x7F, 0xFF, 0x9F, 0xF3, 0xC7, 0xF1, 0xE0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xE0, 0xFD, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFC, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF,
  0x87, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFB, 0xFE, 0x3E, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xE1, 0x9F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x83, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x1F, 0x1F, 0x1F, 0xEF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xEF, 0x8F, 0xE3, 0xC0, 0x07, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x04, 0xFF, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x87,
  0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF7,
  0xC7, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFD, 0x80, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF1, 0xF0, 0xFD, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x7E, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x87, 0xE3, 0xE3,
  0xF0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xDF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F,
  0x83, 0xE3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xFC, 0x0F, 0x87, 0xCF, 0xF1, 0xFF,
  0x3E, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xF3, 0xFE, 0x3F, 0x7F,
  0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0x0F,
  0x80, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0x01,
  0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x3E, 0x03, 0xFF,
  0x81, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x03,
  0xE0, 0x3E, 0xF0, 0x7C, 0x3E, 0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF,
  0x1F, 0xBF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7C, 0x03, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x3F, 0x07, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xC1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0xF8, 0xF8, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF,
  0xFE, 0xFF, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF,
  0xE1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0xDF, 0xC3, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7, 0xF3, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F,
  0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC1,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF8, 0x13, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x03, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFD, 0xF1, 0xFE, 0x7C, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F,
  0xBE, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xFB, 0xE0, 0x7E, 0x07, 0x9F, 0x07,
  0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xDC, 0x1F, 0x1F, 0x1E, 0xF1,
  0xF0, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x1E, 0x3C, 0xE3, 0xC0,
  0xFB, 0xC7, 0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x3E, 0xF1, 0xEF, 0x80, 0xF7,
  0x8F, 0x78, 0x07, 0xB8, 0x3B, 0xC0, 0x3D, 0xC1, 0xDE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF9, 0xF8,
  0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xC1,
  0xF8, 0x7C, 0x3E, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x80, 0xF8, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x8F, 0xF1, 0xFC, 0x3C, 0x07,
  0xF0, 0xFF, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x00, 0x1E, 0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 24, 10, 2, -24 },
  { 19, 12, 9, 16, 2, -24 },
  { 33, 20, 24, 22, 1, -24 },
  { 93, 17, 28, 19, 1, -26 },
  { 153, 29, 25, 31, 1, -25 },
  { 244, 25, 25, 26, 1, -25 },
  { 323, 5, 9, 9, 2, -24 },
  { 329, 10, 29, 12, 1, -24 },
  { 366, 9, 29, 12, 1, -24 },
  { 399, 16, 16, 18, 1, -26 },
  { 431, 17, 16, 19, 1, -20 },
  { 465, 7, 8, 10, 1, -4 },
  { 472, 9, 4, 11, 1, -11 },
  { 477, 6, 5, 10, 2, -5 },
  { 481, 14, 24, 14, 0, -24 },
  { 523, 17, 25, 19, 1, -25 },
  { 577, 12, 24, 19, 2, -24 },
  { 613, 17, 25, 19, 1, -25 },
  { 667, 17, 25, 19, 1, -25 },
  { 721, 18, 24, 19, 1, -24 },
  { 775, 16, 24, 19, 2, -24 },
  { 823, 17, 25, 19, 1, -25 },
  { 877, 17, 24, 19, 1, -24 },
  { 928, 17, 25, 19, 1, -25 },
  { 982, 17, 25, 19, 1, -25 },
  { 1036, 6, 19, 10, 2, -19 },
  { 1051, 7, 23, 10, 1, -19 },
  { 1072, 17, 18, 19, 1, -21 },
  { 1111, 17, 10, 19, 1, -17 },
  { 1133, 17, 18, 19, 1, -21 },
  { 1172, 16, 25, 16, 0, -25 },
  { 1222, 27, 27, 31, 2, -24 },
  { 1314, 24, 24, 24, 0, -24 },
  { 1386, 18, 24, 23, 3, -24 },
  { 1440, 19, 25, 22, 2, -25 },
  { 1500, 20, 24, 25, 3, -24 },
  { 1560, 14, 24, 19, 3, -24 },
  { 1602, 14, 24, 19, 3, -24 },
  { 1644, 20, 25, 25, 2, -25 },
  { 1707, 20, 24, 26, 3, -24 },
  { 1767, 11, 24, 13, 1, -24 },
  { 1800, 11, 31, 11, -3, -24 },
  { 1843, 20, 24, 23, 3, -24 },
  { 1903, 15, 24, 19, 3, -24 },
  { 1948, 26, 24, 32, 3, -24 },
  { 2026, 22, 24, 28, 3, -24 },
  { 2092, 23, 25, 27, 2, -25 },
  { 2164, 17, 24, 21, 3, -24 },
  { 2215, 23, 31, 27, 2, -25 },
  { 2305, 19, 24, 22, 3, -24 },
  { 2362, 15, 25, 19, 2, -25 },
  { 2409, 18, 24, 20, 1, -24 },
  { 2463, 20, 24, 26, 3, -24 },
  { 2523, 22, 24, 22, 0, -24 },
  { 2589, 33, 24, 33, 0, -24 },
  { 2688, 23, 24, 23, 0, -24 },
  { 2757, 21, 24, 21, 0, -24 },
  { 2820, 18, 24, 20, 1, -24 },
  { 2874, 8, 29, 11, 2, -24 },
  { 2903, 14, 24, 14, 0, -24 },
  { 2945, 8, 29, 11, 1, -24 },
  { 2974, 18, 15, 19, 1, -24 },
  { 3008, 14, 2, 14, 0, 3 },
  { 3012, 10, 5, 12, 1, -26 },
  { 3019, 17, 19, 20, 1, -19 },
  { 3060, 18, 26, 21, 2, -26 },
  { 3119, 15, 19, 18, 2, -19 },
  { 3155, 17, 26, 21, 2, -26 },
  { 3211, 17, 19, 20, 2, -19 },
  { 3252, 14, 26, 13, 1, -26 },
  { 3298, 17, 27, 21, 2, -19 },
  { 3356, 18, 26, 22, 2, -26 },
  { 3415, 6, 26, 10, 2, -26 },
  { 3435, 10, 34, 10, -2, -26 },
  { 3478, 18, 26, 21, 3, -26 },
  { 3537, 6, 26, 10, 2, -26 },
  { 3557, 29, 19, 33, 2, -19 },
  { 3626, 18, 19, 22, 2, -19 },
  { 3669, 18, 19, 21, 2, -19 },
  { 3712, 18, 27, 21, 2, -19 },
  { 3773, 17, 27, 21, 2, -19 },
  { 3831, 13, 19, 15, 2, -19 },
  { 3862, 14, 19, 17, 2, -19 },
  { 3896, 13, 23, 15, 1, -23 },
  { 3934, 18, 19, 22, 2, -19 },
  { 3977, 19, 19, 19, 0, -19 },
  { 4023, 29, 19, 29, 0, -19 },
  { 4092, 19, 19, 20, 0, -19 },
  { 4138, 19, 27, 19, 0, -19 },
  { 4203, 15, 19, 17, 1, -19 },
  { 4239, 11, 29, 13, 1, -24 },
  { 4279, 3, 34, 19, 8, -26 },
  { 4292, 12, 29, 13, 1, -24 },
  { 4336, 17, 6, 19, 1, -15 },
};

const GFXfont NotoSans_Bold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold34pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_BOLD34PT7B_H_
