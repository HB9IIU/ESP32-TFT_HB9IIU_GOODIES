#ifndef _NOTOSANS_BOLD35PT7B_H_
#define _NOTOSANS_BOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3D, 0xF1, 0xEF, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80,
  0x3C, 0x38, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0x87,
  0x80, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFB, 0x3C, 0x7C,
  0xC1, 0x3F, 0x30, 0x07, 0xCC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x37, 0xE0, 0x0C, 0xFC,
  0x03, 0x3F, 0x60, 0xCF, 0xDF, 0xBF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xFE, 0x03, 0xC0, 0x1E, 0x78,
  0x0F, 0x00, 0xF9, 0xF0, 0x78, 0x03, 0xC3, 0xC1, 0xE0, 0x0F, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x7C, 0x00, 0xF0, 0xF1, 0xE0, 0x03, 0xC3, 0xCF, 0x80,
  0x0F, 0x1F, 0x3C, 0xFE, 0x1E, 0x79, 0xE7, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0,
  0xFF, 0x3C, 0xF9, 0xE1, 0xF8, 0xF3, 0xC7, 0x80, 0x07, 0x8F, 0x1E, 0x00,
  0x3E, 0x3C, 0x78, 0x00, 0xF0, 0xF1, 0xF0, 0x07, 0xC3, 0xC7, 0x80, 0x1E,
  0x0F, 0x1E, 0x00, 0xF0, 0x3C, 0x78, 0x03, 0xC0, 0xF9, 0xE0, 0x1E, 0x01,
  0xFF, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xF1, 0xFF, 0xC1, 0xF9, 0xFF, 0xF0, 0xF8, 0xFC, 0xFC, 0xFC, 0x7C,
  0x3F, 0x7C, 0x7E, 0x0F, 0xFE, 0x3F, 0x03, 0xFE, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFE,
  0x07, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x78, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3C, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E,
  0x1B, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0xF8, 0xF8, 0x1C, 0x70, 0x04, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x1F, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x7E, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF7,
  0x9F, 0x31, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7E, 0x1F, 0x8E, 0x03, 0xE1, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x38, 0x1F, 0x88,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0xE0, 0x3F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8,
  0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x30, 0xFF, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x3F, 0x0F, 0xBF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0x83, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x1F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xF7, 0xF1,
  0xF8, 0x7E, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x0F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFD,
  0xF0, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x3F, 0x9E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFB, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0x80, 0x3C,
  0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x3E, 0xF9, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x78, 0x3F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x07, 0x83, 0xE7, 0x83, 0xFF, 0x9E,
  0x78, 0x7F, 0xF1, 0xEF, 0x0F, 0xCF, 0x0F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1E,
  0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x3E, 0x0F, 0x0F, 0xE3, 0xE0, 0xF0,
  0xFE, 0x1E, 0x0F, 0x0E, 0xF1, 0xE0, 0xF1, 0xEF, 0x1F, 0x1F, 0x9E, 0xF0,
  0xFF, 0xFF, 0xCF, 0x0F, 0xFB, 0xF8, 0x78, 0x3E, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x1F, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x81,
  0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x03,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3E, 0x07,
  0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07,
  0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFC,
  0x1C, 0xFE, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x1C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0x87, 0xFE, 0x7C, 0x07, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x01, 0xFD, 0xF0, 0x1F, 0xCF, 0x87, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFC, 0x0E, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xFF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8,
  0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F,
  0x8F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x80, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F,
  0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xDF, 0xFB, 0xC0, 0x7B, 0xFF, 0x78, 0x0F, 0x7F,
  0xEF, 0x83, 0xCF, 0xFC, 0xF0, 0x79, 0xFF, 0x9E, 0x0F, 0x3F, 0xF3, 0xE3,
  0xC7, 0xFE, 0x7C, 0x78, 0xFF, 0xC7, 0x8F, 0x1F, 0xF8, 0xF3, 0xC3, 0xFF,
  0x1F, 0x78, 0x7F, 0xE1, 0xEF, 0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0x87, 0xF8,
  0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8,
  0x1F, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0xF8,
  0x0F, 0xFB, 0xF0, 0x3F, 0xE7, 0xC0, 0xFF, 0x9F, 0x83, 0xFE, 0x3F, 0x0F,
  0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFF, 0x83, 0xE3, 0xFE, 0x0F, 0xCF, 0xF8,
  0x1F, 0x3F, 0xE0, 0x7E, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC,
  0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x3F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x1E, 0xF8, 0x02, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x03, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xE7, 0xC0,
  0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0x3E, 0x7C, 0x07, 0xF8, 0x0F, 0x9F,
  0x01, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x3F, 0xE0, 0x7C,
  0x3E, 0x0F, 0x7C, 0x1F, 0x0F, 0x83, 0xCF, 0x0F, 0x81, 0xF0, 0xF3, 0xC3,
  0xE0, 0x7C, 0x7C, 0xF0, 0xF8, 0x1F, 0x1F, 0x3E, 0x3E, 0x07, 0xC7, 0x8F,
  0x9F, 0x00, 0xF9, 0xE1, 0xE7, 0xC0, 0x3E, 0xF8, 0x79, 0xF0, 0x0F, 0xBE,
  0x1F, 0x7C, 0x03, 0xEF, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0xFE, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0xF7,
  0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x3C,
  0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xF7, 0xF0, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x07, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xC3, 0xEF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xFB, 0xC7, 0xF0, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xFC, 0x7D,
  0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7B, 0xFF, 0x3C,
  0x7E, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xE0, 0x5F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x81, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0xEF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD,
  0xF0, 0xFC, 0x7C, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xE7, 0xE7,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x04, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x1F, 0x98, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0xF3,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0xE7, 0xCF, 0xFD,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE6, 0x01, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF9, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x31, 0xFF, 0xFF, 0x7C, 0x40,
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x03, 0x01, 0xF0, 0xFC, 0x3F, 0x07, 0xC0, 0x40,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xF3,
  0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xCF, 0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x9F,
  0x01, 0xFB, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0xFC,
  0x3F, 0xC7, 0xBF, 0xF3, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xC1, 0xFC, 0x3F, 0x7E, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF,
  0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07,
  0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7E, 0xF1, 0xFE, 0x7B, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0,
  0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0xBF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xF1, 0xFC, 0x7B, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3E, 0x7E, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE7, 0xCF, 0xFD, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFC, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0x1E, 0xF8, 0x0B, 0xE0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFC, 0xF1, 0xFE, 0x3C, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F,
  0x03, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x3E, 0x1F, 0xE1,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xE3, 0xCF, 0x1F, 0x07, 0xCF, 0x3C, 0xF8,
  0x1F, 0x3C, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF, 0x81, 0xF3, 0x87, 0x3E, 0x03,
  0xDE, 0x1E, 0xF0, 0x0F, 0x78, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF3, 0xE0, 0x7E, 0x3F,
  0x0F, 0xC1, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x3F, 0x07,
  0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFE, 0x3F, 0x87, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFF,
  0x07, 0xF0, 0x1F, 0x07, 0xF0, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0,
  0x80, 0x00, 0x3F, 0x80, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x00, 0x40,
};

const GFXglyph NotoSans_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 25, 10, 2, -25 },
  { 20, 13, 9, 17, 2, -25 },
  { 35, 21, 25, 23, 1, -25 },
  { 101, 18, 29, 20, 1, -27 },
  { 167, 30, 25, 32, 1, -25 },
  { 261, 25, 25, 26, 1, -25 },
  { 340, 5, 9, 9, 2, -25 },
  { 346, 10, 31, 12, 1, -25 },
  { 385, 9, 31, 12, 1, -25 },
  { 420, 17, 17, 19, 1, -27 },
  { 457, 17, 17, 20, 1, -21 },
  { 494, 7, 9, 10, 1, -4 },
  { 502, 9, 5, 11, 1, -12 },
  { 508, 6, 5, 10, 2, -5 },
  { 512, 14, 25, 15, 0, -25 },
  { 556, 18, 25, 20, 1, -25 },
  { 613, 12, 25, 20, 2, -25 },
  { 651, 18, 25, 20, 1, -25 },
  { 708, 18, 25, 20, 1, -25 },
  { 765, 18, 25, 20, 1, -25 },
  { 822, 16, 25, 20, 2, -25 },
  { 872, 18, 25, 20, 1, -25 },
  { 929, 18, 25, 20, 1, -25 },
  { 986, 18, 25, 20, 1, -25 },
  { 1043, 18, 25, 20, 1, -25 },
  { 1100, 6, 19, 10, 2, -19 },
  { 1115, 7, 24, 10, 1, -19 },
  { 1136, 17, 19, 20, 1, -22 },
  { 1177, 17, 11, 20, 1, -18 },
  { 1201, 17, 19, 20, 1, -22 },
  { 1242, 16, 25, 17, 0, -25 },
  { 1292, 28, 28, 31, 2, -25 },
  { 1390, 24, 25, 24, 0, -25 },
  { 1465, 19, 25, 23, 3, -25 },
  { 1525, 19, 25, 22, 2, -25 },
  { 1585, 21, 25, 26, 3, -25 },
  { 1651, 15, 25, 20, 3, -25 },
  { 1698, 14, 25, 19, 3, -25 },
  { 1742, 21, 25, 25, 2, -25 },
  { 1808, 21, 25, 27, 3, -25 },
  { 1874, 12, 25, 14, 1, -25 },
  { 1912, 11, 32, 12, -3, -25 },
  { 1956, 20, 25, 23, 3, -25 },
  { 2019, 15, 25, 20, 3, -25 },
  { 2066, 27, 25, 33, 3, -25 },
  { 2151, 22, 25, 28, 3, -25 },
  { 2220, 24, 25, 28, 2, -25 },
  { 2295, 17, 25, 22, 3, -25 },
  { 2349, 24, 31, 28, 2, -25 },
  { 2442, 20, 25, 23, 3, -25 },
  { 2505, 16, 25, 19, 2, -25 },
  { 2555, 19, 25, 20, 1, -25 },
  { 2615, 20, 25, 26, 3, -25 },
  { 2678, 23, 25, 23, 0, -25 },
  { 2750, 34, 25, 34, 0, -25 },
  { 2857, 23, 25, 23, 0, -25 },
  { 2929, 22, 25, 22, 0, -25 },
  { 2998, 18, 25, 20, 1, -25 },
  { 3055, 9, 31, 12, 2, -25 },
  { 3090, 14, 25, 15, 0, -25 },
  { 3134, 8, 31, 12, 1, -25 },
  { 3165, 18, 16, 20, 1, -25 },
  { 3201, 14, 3, 14, 0, 3 },
  { 3207, 10, 6, 13, 1, -27 },
  { 3215, 17, 19, 21, 1, -19 },
  { 3256, 17, 27, 22, 3, -27 },
  { 3314, 15, 19, 18, 2, -19 },
  { 3350, 18, 27, 22, 2, -27 },
  { 3411, 17, 19, 21, 2, -19 },
  { 3452, 14, 27, 14, 1, -27 },
  { 3500, 18, 27, 22, 2, -19 },
  { 3561, 17, 27, 23, 3, -27 },
  { 3619, 6, 27, 10, 2, -27 },
  { 3640, 10, 35, 10, -2, -27 },
  { 3684, 19, 27, 22, 3, -27 },
  { 3749, 5, 27, 10, 3, -27 },
  { 3766, 29, 19, 34, 3, -19 },
  { 3835, 17, 19, 23, 3, -19 },
  { 3876, 18, 19, 22, 2, -19 },
  { 3919, 17, 27, 22, 3, -19 },
  { 3977, 18, 27, 22, 2, -19 },
  { 4038, 12, 19, 16, 3, -19 },
  { 4067, 14, 19, 18, 2, -19 },
  { 4101, 13, 23, 15, 1, -23 },
  { 4139, 18, 19, 23, 2, -19 },
  { 4182, 20, 19, 20, 0, -19 },
  { 4230, 30, 19, 30, 0, -19 },
  { 4302, 20, 19, 20, 0, -19 },
  { 4350, 20, 27, 20, 0, -19 },
  { 4418, 15, 19, 17, 1, -19 },
  { 4454, 11, 31, 14, 1, -25 },
  { 4497, 4, 35, 19, 8, -27 },
  { 4515, 12, 31, 14, 1, -25 },
  { 4562, 17, 6, 20, 1, -15 },
};

const GFXfont NotoSans_Bold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold35pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_BOLD35PT7B_H_
