#ifndef _NOTOSANS_BOLD19PT7B_H_
#define _NOTOSANS_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEC, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7E, 0x60,
  0x0E, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98,
  0xFF, 0xEF, 0xFE, 0x1B, 0x03, 0x30, 0x33, 0x03, 0x30, 0x08, 0x1F, 0xBF,
  0xFD, 0x2E, 0x87, 0xC1, 0xF0, 0x7E, 0x0F, 0x85, 0xE2, 0xFF, 0xFF, 0xF0,
  0x40, 0x20, 0x70, 0x30, 0xF8, 0x30, 0xDC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0,
  0xCD, 0xC0, 0xDD, 0xBC, 0xFB, 0xBE, 0x33, 0x66, 0x06, 0x67, 0x06, 0x67,
  0x0C, 0x66, 0x1C, 0x3E, 0x18, 0x3C, 0x1E, 0x01, 0xF8, 0x1D, 0xE0, 0xE7,
  0x07, 0x30, 0x1F, 0x80, 0xF8, 0x0F, 0xC7, 0xFF, 0x77, 0x3F, 0xB8, 0xF9,
  0xE7, 0xCF, 0xFF, 0x1F, 0xBC, 0xFF, 0xFE, 0x39, 0x9C, 0xCE, 0x73, 0x18,
  0xC6, 0x31, 0xCE, 0x31, 0x8E, 0x38, 0xC7, 0x18, 0xE3, 0x18, 0xE7, 0x39,
  0xCE, 0x63, 0x39, 0xCC, 0xC0, 0x18, 0x0C, 0x36, 0x5F, 0xF3, 0xE1, 0xE1,
  0xD8, 0xCE, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0xFF, 0x60, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x06, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0x1C, 0x3F, 0x9F,
  0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xF7, 0xF1,
  0xF0, 0x0E, 0x3C, 0xFF, 0xF6, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0x1C, 0x3F, 0xBF, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0x3C, 0x7F, 0xBF, 0xE8, 0x70, 0x38,
  0x38, 0xF8, 0x7E, 0x07, 0x81, 0xC0, 0xF0, 0xFF, 0xF7, 0xF0, 0x03, 0x80,
  0x70, 0x1E, 0x07, 0xC0, 0xF8, 0x37, 0x0C, 0xE3, 0x9C, 0x63, 0x9F, 0xFF,
  0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x3F, 0x9F, 0xDC, 0x0E, 0x07,
  0xE3, 0xFD, 0xFF, 0x03, 0x81, 0xC0, 0xF0, 0xFF, 0xF7, 0xF0, 0x0F, 0x1F,
  0x9F, 0xCC, 0x0E, 0x06, 0x73, 0x7D, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x77,
  0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0x03, 0x83, 0x80, 0x1C, 0x3F, 0xBD, 0xFC, 0x7E, 0x3B,
  0xB8, 0xF8, 0xFC, 0xF7, 0x71, 0xF0, 0x7C, 0x7F, 0xFB, 0xF0, 0x1C, 0x3F,
  0xBF, 0xDC, 0x7C, 0x3E, 0x1F, 0x8F, 0xFF, 0x7F, 0x81, 0xC0, 0xC0, 0xE7,
  0xE3, 0xE0, 0x5F, 0xA0, 0x00, 0xFF, 0x80, 0x5F, 0xA0, 0x00, 0x1F, 0xEC,
  0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x07, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0x40,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0,
  0xF8, 0x1C, 0x7C, 0xF8, 0xE0, 0x40, 0x00, 0x3C, 0x7F, 0x9F, 0xC0, 0x70,
  0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0x03,
  0xC0, 0x1F, 0xE0, 0xF0, 0xF3, 0x80, 0x66, 0x7E, 0x7D, 0xFC, 0xF3, 0x19,
  0xE6, 0x33, 0xCC, 0x67, 0x99, 0xCF, 0x3F, 0xF7, 0x39, 0xC6, 0x00, 0x07,
  0x06, 0x07, 0xFC, 0x00, 0x80, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x01,
  0xDC, 0x0E, 0xE0, 0x63, 0x87, 0x1C, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC, 0xE0,
  0xE7, 0x03, 0xF0, 0x1C, 0xF8, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEF,
  0xF3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1F, 0x8E, 0xFF, 0xBF, 0x80, 0x07, 0x87,
  0xFD, 0xFF, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x23, 0xFC, 0x3F, 0x80, 0xF8, 0x1F, 0xE3, 0xFE, 0x71, 0xEE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x73, 0xEF, 0xF9,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF, 0xFF,
  0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0xBC, 0x07, 0x01,
  0xC0, 0x38, 0xFF, 0x1F, 0xE3, 0xFC, 0x1D, 0xC3, 0xBC, 0x73, 0xFE, 0x3F,
  0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0xFF, 0xF7, 0x9C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xAE, 0xFB, 0xC0, 0xE1, 0xFC,
  0x3B, 0x8E, 0x73, 0x8E, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xEE, 0x1C, 0xE3,
  0x9C, 0x71, 0xCE, 0x3D, 0xC3, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x1F, 0xD8, 0x6F, 0x61, 0xBD, 0x8E, 0xF7, 0x33, 0xCC, 0xCF,
  0x37, 0x3C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x30, 0xE0, 0x7F, 0x07,
  0xF8, 0x7F, 0x87, 0xDC, 0x7D, 0xC7, 0xCE, 0x7C, 0xE7, 0xC7, 0x7C, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0,
  0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x1C,
  0xF1, 0xE3, 0xFE, 0x0F, 0xE0, 0xF8, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F,
  0x9F, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0x81, 0xFF,
  0x1F, 0xFC, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xDC, 0x1C, 0xF1, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0xF8, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEE, 0xF3, 0xFC, 0xFE,
  0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xF8, 0x70, 0x1E, 0x3F, 0xFF, 0xDC, 0x0E,
  0x07, 0x81, 0xF0, 0x7E, 0x0F, 0x01, 0xC0, 0xF8, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0xE7,
  0xFC, 0x7E, 0x00, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE3, 0x8E,
  0x38, 0xC3, 0x9C, 0x19, 0xC1, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0xE0, 0xE0, 0xF8, 0x38, 0x76, 0x1E, 0x1D, 0xC7, 0x87, 0x71, 0xF1, 0x9C,
  0x6C, 0xE3, 0x3B, 0x38, 0xCC, 0xCE, 0x3B, 0x3B, 0x0E, 0xCF, 0xC1, 0xF1,
  0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x73, 0x87, 0x8E,
  0x38, 0x73, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xEE,
  0x0E, 0x70, 0x71, 0xC7, 0x0F, 0x78, 0x3C, 0xE0, 0x77, 0x0E, 0x70, 0xE3,
  0x9C, 0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x06,
  0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8,
  0x0C, 0x03, 0x00, 0xE0, 0x78, 0x1B, 0x0C, 0xE3, 0x19, 0x87, 0xE0, 0xC0,
  0xFF, 0xE3, 0x8E, 0x0C, 0x3F, 0x9F, 0xE0, 0x70, 0x3B, 0xFF, 0xCF, 0xC7,
  0xE3, 0xFF, 0xDF, 0x60, 0xE0, 0x38, 0x0E, 0x03, 0x98, 0xEF, 0xBF, 0xEF,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xFF, 0xBB, 0xC0, 0x0C, 0x3F,
  0x7F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0x7F, 0x3F, 0x01, 0xC0, 0x70,
  0x1C, 0x67, 0x7D, 0xDF, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF,
  0x7F, 0xCF, 0x70, 0x0C, 0x1F, 0x9F, 0xFC, 0x3E, 0x1F, 0xFF, 0xFF, 0xC0,
  0xF0, 0xBF, 0xCF, 0xE0, 0x04, 0x1F, 0x3F, 0x38, 0x38, 0xFE, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F, 0x77, 0xFF, 0x8F,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x83, 0xBF,
  0xEF, 0xF0, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x88, 0xEF, 0xBF, 0xFF, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x39, 0xC0, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0xFF, 0xD8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x1D, 0xC7, 0x39,
  0xC7, 0x70, 0xFE, 0x1F, 0xC3, 0xDC, 0x71, 0xCE, 0x3D, 0xC3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x08, 0xFF, 0xBE, 0xFF, 0xFF, 0xF1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0x02, 0x3B, 0xEF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x0C, 0x0F, 0xC7, 0xFB, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF3, 0x9F, 0xE3, 0xF0, 0x06, 0x3B, 0xEF, 0xFB, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xFF, 0xEE, 0xF3, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x18, 0x1F, 0x77, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xDF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x18, 0x7F, 0xE6,
  0xE0, 0xF0, 0x7E, 0x1E, 0x07, 0x87, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x7F,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0xCF, 0x30, 0xE0, 0xEE,
  0x39, 0xC7, 0x38, 0xC3, 0xB8, 0x77, 0x06, 0xC0, 0xF8, 0x1E, 0x01, 0xC0,
  0xE3, 0xC7, 0x63, 0xC7, 0x73, 0xC6, 0x73, 0x6E, 0x36, 0x6E, 0x36, 0x6C,
  0x3E, 0x6C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1C, 0x38, 0xF1, 0xE7, 0x70, 0xEE,
  0x0F, 0x81, 0xE0, 0x3E, 0x0E, 0xE1, 0xDC, 0x71, 0xDE, 0x3C, 0xE0, 0xEE,
  0x39, 0xC7, 0x18, 0xC3, 0xB8, 0x77, 0x06, 0xC0, 0xF8, 0x0F, 0x01, 0xC0,
  0x38, 0x0E, 0x07, 0xC0, 0xF0, 0x18, 0x00, 0xFF, 0xFF, 0x0E, 0x1C, 0x38,
  0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x06, 0x3C, 0x78, 0xC1, 0x83, 0x06, 0x3C,
  0xF1, 0xF0, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x83, 0x8F, 0x1C, 0x71, 0xC7, 0x0E, 0x1C, 0xF7, 0x1C, 0x71, 0xC7,
  0x3C, 0xE0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 12, 14, 12, 0, -14 },
  { 33, 9, 15, 11, 1, -14 },
  { 50, 16, 14, 17, 1, -14 },
  { 78, 13, 14, 14, 1, -14 },
  { 101, 3, 5, 5, 1, -14 },
  { 103, 5, 17, 6, 1, -14 },
  { 114, 5, 17, 6, 1, -14 },
  { 125, 9, 8, 10, 1, -14 },
  { 134, 9, 9, 11, 1, -11 },
  { 145, 3, 4, 5, 1, -2 },
  { 147, 5, 2, 6, 1, -6 },
  { 149, 3, 3, 5, 1, -3 },
  { 151, 8, 14, 8, 0, -14 },
  { 165, 9, 14, 11, 1, -14 },
  { 181, 7, 14, 11, 1, -14 },
  { 194, 9, 14, 11, 1, -14 },
  { 210, 9, 14, 11, 1, -14 },
  { 226, 11, 14, 11, 0, -14 },
  { 246, 9, 14, 11, 1, -14 },
  { 262, 9, 14, 11, 1, -14 },
  { 278, 9, 14, 11, 1, -14 },
  { 294, 9, 14, 11, 1, -14 },
  { 310, 9, 14, 11, 1, -14 },
  { 326, 3, 11, 5, 1, -11 },
  { 331, 3, 13, 5, 1, -11 },
  { 336, 9, 10, 11, 1, -12 },
  { 348, 9, 6, 11, 1, -10 },
  { 355, 9, 10, 11, 1, -12 },
  { 367, 9, 14, 9, 0, -14 },
  { 383, 15, 16, 17, 1, -14 },
  { 413, 13, 14, 13, 0, -14 },
  { 436, 10, 14, 13, 2, -14 },
  { 454, 11, 14, 12, 1, -14 },
  { 474, 11, 14, 14, 2, -14 },
  { 494, 8, 14, 11, 2, -14 },
  { 508, 7, 14, 10, 2, -14 },
  { 521, 11, 14, 14, 1, -14 },
  { 541, 11, 14, 15, 2, -14 },
  { 561, 6, 14, 7, 1, -14 },
  { 572, 6, 18, 6, -1, -14 },
  { 586, 11, 14, 13, 2, -14 },
  { 606, 8, 14, 11, 2, -14 },
  { 620, 14, 14, 18, 2, -14 },
  { 645, 12, 14, 15, 2, -14 },
  { 666, 13, 14, 15, 1, -14 },
  { 689, 9, 14, 12, 2, -14 },
  { 705, 13, 17, 15, 1, -14 },
  { 733, 10, 14, 12, 2, -14 },
  { 751, 9, 14, 10, 1, -14 },
  { 767, 11, 14, 11, 0, -14 },
  { 787, 11, 14, 14, 2, -14 },
  { 807, 12, 14, 12, 0, -14 },
  { 828, 18, 14, 18, 0, -14 },
  { 860, 13, 14, 13, 0, -14 },
  { 883, 12, 14, 12, 0, -14 },
  { 904, 11, 14, 11, 0, -14 },
  { 924, 5, 17, 6, 1, -14 },
  { 935, 8, 14, 8, 0, -14 },
  { 949, 5, 17, 6, 0, -14 },
  { 960, 10, 9, 11, 0, -14 },
  { 972, 8, 1, 8, 0, 2 },
  { 973, 5, 3, 7, 1, -15 },
  { 975, 9, 11, 11, 1, -11 },
  { 988, 10, 14, 12, 1, -14 },
  { 1006, 8, 11, 10, 1, -11 },
  { 1017, 10, 14, 12, 1, -14 },
  { 1035, 9, 11, 11, 1, -11 },
  { 1048, 8, 15, 7, 0, -15 },
  { 1063, 10, 16, 12, 1, -11 },
  { 1083, 10, 14, 12, 1, -14 },
  { 1101, 3, 14, 6, 1, -14 },
  { 1107, 5, 19, 6, -1, -14 },
  { 1119, 11, 14, 12, 1, -14 },
  { 1139, 3, 14, 6, 1, -14 },
  { 1145, 16, 11, 19, 1, -11 },
  { 1167, 10, 11, 12, 1, -11 },
  { 1181, 10, 11, 12, 1, -11 },
  { 1195, 10, 16, 12, 1, -11 },
  { 1215, 10, 16, 12, 1, -11 },
  { 1235, 7, 11, 9, 1, -11 },
  { 1245, 8, 11, 10, 1, -11 },
  { 1256, 8, 13, 8, 0, -13 },
  { 1269, 10, 10, 12, 1, -10 },
  { 1282, 11, 10, 11, 0, -10 },
  { 1296, 16, 10, 16, 0, -10 },
  { 1316, 11, 10, 11, 0, -10 },
  { 1330, 11, 15, 11, 0, -10 },
  { 1351, 8, 10, 9, 1, -10 },
  { 1361, 7, 17, 7, 0, -14 },
  { 1376, 2, 18, 10, 4, -14 },
  { 1381, 6, 17, 7, 1, -14 },
  { 1394, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_Bold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold19pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_BOLD19PT7B_H_
