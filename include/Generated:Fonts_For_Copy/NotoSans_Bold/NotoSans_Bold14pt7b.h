#ifndef _NOTOSANS_BOLD14PT7B_H_
#define _NOTOSANS_BOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x04, 0x8F, 0xF3,
  0x61, 0xB3, 0xFC, 0x48, 0x24, 0x36, 0x00, 0x10, 0xEF, 0xF5, 0xD3, 0xC3,
  0xC7, 0x9F, 0xF1, 0x04, 0x70, 0xC5, 0x98, 0xC9, 0x8C, 0xB0, 0x5A, 0xE7,
  0x6B, 0x05, 0x90, 0xD9, 0x08, 0xB1, 0x8E, 0x78, 0x1B, 0x0C, 0xC1, 0xF0,
  0x78, 0x3E, 0x6D, 0xF3, 0x3C, 0xFF, 0x1F, 0xF0, 0xFF, 0x6B, 0x6D, 0x24,
  0xD9, 0x30, 0xE6, 0x33, 0x33, 0x33, 0x33, 0x6E, 0x18, 0x31, 0x4F, 0xF3,
  0x8D, 0x89, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0x60, 0xFF, 0xF0,
  0x0C, 0x61, 0x84, 0x30, 0xC6, 0x18, 0x63, 0x00, 0x3C, 0xFD, 0x9B, 0x36,
  0x7C, 0xD9, 0xB3, 0x7E, 0x78, 0x3B, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC0,
  0x79, 0xFA, 0x30, 0x61, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0xFB, 0xF0, 0xC3,
  0x79, 0xF0, 0xC3, 0xFF, 0xE0, 0x0E, 0x0E, 0x16, 0x36, 0x26, 0x66, 0xFF,
  0xFF, 0x06, 0x06, 0xFF, 0xFC, 0x30, 0xFE, 0x70, 0xC3, 0xFF, 0xE0, 0x1E,
  0x3E, 0x60, 0x68, 0x5E, 0xE6, 0x67, 0x66, 0x7E, 0x3C, 0xFF, 0xFE, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x3C, 0x66, 0x66, 0x66, 0x3C,
  0x7E, 0x66, 0xC3, 0x66, 0x3C, 0x3C, 0x7E, 0x66, 0xC6, 0x67, 0x7A, 0x16,
  0x06, 0x7C, 0x78, 0xF8, 0x0F, 0x6D, 0x00, 0x1B, 0x58, 0x04, 0x33, 0xB8,
  0xE0, 0xE0, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x1D, 0xCC, 0x20,
  0xFF, 0xF0, 0xC3, 0x18, 0xC3, 0x00, 0x30, 0xC0, 0x1F, 0x0E, 0x39, 0x01,
  0x6F, 0xB9, 0x37, 0x66, 0xEC, 0xDC, 0xFE, 0xC0, 0x0C, 0x20, 0xFC, 0x00,
  0x1C, 0x07, 0x81, 0xE0, 0xD8, 0x33, 0x0C, 0xC7, 0xF1, 0xFE, 0x61, 0xB0,
  0x70, 0xFC, 0xFE, 0xC6, 0xC6, 0xFC, 0xFE, 0xC7, 0xC7, 0xFE, 0xFC, 0x3F,
  0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7E, 0x3E, 0xFC, 0xFE, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xFC, 0x30, 0xFF, 0xFC,
  0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xFF, 0xFC, 0x30, 0xC3, 0x00, 0x3F,
  0x7F, 0xE0, 0xC0, 0xCF, 0xCF, 0xC3, 0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xFB, 0x8C, 0x63, 0x18, 0xC6,
  0x77, 0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC3, 0xC6, 0xCC,
  0xDC, 0xF8, 0xF8, 0xCC, 0xCE, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xF0, 0xE0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFD, 0x97, 0xB6, 0xF6,
  0xDE, 0x53, 0xCE, 0x79, 0xCC, 0xE1, 0xF8, 0xFC, 0x7B, 0x3D, 0xDE, 0x6F,
  0x3F, 0x8F, 0xC3, 0xE1, 0xC0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0xC7, 0x7F, 0x1F, 0x00, 0xFD, 0xFF, 0x1E, 0x3C, 0xFF, 0xB0, 0x60,
  0xC1, 0x80, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0x7F,
  0x1F, 0x01, 0xC0, 0x70, 0xFC, 0xFE, 0xC6, 0xC6, 0xCE, 0xFC, 0xCC, 0xCE,
  0xC6, 0xC7, 0x7F, 0xFC, 0x30, 0xF0, 0xF0, 0xC3, 0xFF, 0xE0, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0xC1, 0xB1, 0xD8, 0xCC, 0x63, 0x31,
  0xB0, 0xD8, 0x2C, 0x1C, 0x0E, 0x00, 0xC3, 0x1F, 0x1C, 0x66, 0x71, 0x99,
  0xE6, 0x65, 0xB1, 0xB6, 0xC3, 0xCB, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x80,
  0xE3, 0xB9, 0x8D, 0xC7, 0xC1, 0xC0, 0xE0, 0xF8, 0x6E, 0x63, 0x70, 0xC0,
  0xE3, 0xB1, 0x9D, 0x86, 0xC3, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x00,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFB, 0x6D,
  0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x30, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x18, 0x3C, 0x24, 0x66, 0xC3, 0xFC,
  0xC6, 0x30, 0x7B, 0xF0, 0xDF, 0xFF, 0x3D, 0xFD, 0xC1, 0x83, 0x06, 0xEF,
  0xF8, 0xF1, 0xE3, 0xC7, 0xFF, 0xF0, 0x3B, 0xFC, 0x30, 0xC3, 0x0F, 0xDF,
  0x06, 0x0C, 0x1B, 0xBF, 0xF8, 0xF1, 0xE3, 0xC7, 0xFD, 0xD8, 0x39, 0xFB,
  0x1F, 0xFF, 0xF8, 0x39, 0x3E, 0x1C, 0xF7, 0x1E, 0xF9, 0xC7, 0x1C, 0x71,
  0xC7, 0x00, 0x77, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0x07, 0x1F, 0xF0,
  0xC1, 0x83, 0x06, 0xEF, 0xFC, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF3, 0xFF,
  0xFC, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xC0, 0xC0, 0xC0, 0xC7,
  0xCC, 0xDC, 0xF8, 0xF8, 0xDC, 0xCE, 0xC7, 0xFF, 0xFF, 0xFC, 0xDC, 0xCF,
  0xFE, 0xC6, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xDD, 0xFF,
  0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0x39, 0xFB, 0x1E, 0x3C, 0x78, 0xFB, 0xBE,
  0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xFE, 0xC1, 0x83, 0x00, 0x77, 0xFF,
  0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0x06, 0x0C, 0x18, 0xDF, 0xF9, 0x8C, 0x63,
  0x18, 0x7F, 0xF1, 0xE7, 0x8E, 0x7F, 0x21, 0xFF, 0xD8, 0x61, 0x86, 0x1F,
  0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xBF, 0xC3, 0xE7, 0x66, 0x66,
  0x3C, 0x3C, 0x3C, 0x18, 0xC6, 0x3E, 0x67, 0x6F, 0x66, 0xF6, 0x69, 0x62,
  0x94, 0x39, 0xC3, 0x9C, 0xE7, 0x66, 0x3C, 0x3C, 0x3C, 0x3C, 0x66, 0xE7,
  0xC3, 0xE7, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x38, 0xF0, 0x7D,
  0xF0, 0xC6, 0x31, 0xC7, 0xFF, 0x39, 0xCC, 0x63, 0x73, 0x86, 0x31, 0x8C,
  0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xCE, 0x66, 0x67, 0x76, 0x66, 0xEC, 0xF6,
  0xF0,
};

const GFXglyph NotoSans_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 6, 12, 8, 1, -11 },
  { 28, 12, 10, 13, 0, -10 },
  { 43, 10, 10, 11, 1, -10 },
  { 56, 2, 4, 4, 1, -10 },
  { 57, 3, 12, 5, 1, -10 },
  { 62, 4, 12, 5, 0, -10 },
  { 68, 7, 7, 8, 0, -11 },
  { 75, 6, 6, 8, 1, -8 },
  { 80, 3, 4, 4, 0, -2 },
  { 82, 4, 2, 4, 0, -5 },
  { 83, 2, 2, 4, 1, -2 },
  { 84, 6, 10, 6, 0, -10 },
  { 92, 7, 10, 8, 0, -10 },
  { 101, 5, 10, 8, 1, -10 },
  { 108, 7, 10, 8, 1, -10 },
  { 117, 6, 10, 8, 1, -10 },
  { 125, 8, 10, 8, 0, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 8, 10, 8, 0, -10 },
  { 153, 8, 10, 8, 0, -10 },
  { 163, 8, 10, 8, 0, -10 },
  { 173, 8, 10, 8, 0, -10 },
  { 183, 2, 8, 4, 1, -8 },
  { 185, 3, 10, 4, 0, -8 },
  { 189, 6, 8, 8, 1, -9 },
  { 195, 6, 4, 8, 1, -7 },
  { 198, 6, 8, 8, 1, -9 },
  { 204, 6, 10, 7, 0, -10 },
  { 212, 11, 11, 13, 1, -10 },
  { 228, 10, 10, 10, 0, -10 },
  { 241, 8, 10, 9, 1, -10 },
  { 251, 8, 10, 9, 1, -10 },
  { 261, 8, 10, 10, 1, -10 },
  { 271, 6, 10, 8, 1, -10 },
  { 279, 6, 10, 8, 1, -10 },
  { 287, 8, 10, 10, 1, -10 },
  { 297, 8, 10, 11, 1, -10 },
  { 307, 5, 10, 5, 0, -10 },
  { 314, 4, 13, 5, -1, -10 },
  { 321, 8, 10, 9, 1, -10 },
  { 331, 6, 10, 8, 1, -10 },
  { 339, 11, 10, 13, 1, -10 },
  { 353, 9, 10, 11, 1, -10 },
  { 365, 9, 10, 11, 1, -10 },
  { 377, 7, 10, 9, 1, -10 },
  { 386, 9, 12, 11, 1, -10 },
  { 400, 8, 10, 9, 1, -10 },
  { 410, 6, 10, 8, 1, -10 },
  { 418, 8, 10, 8, 0, -10 },
  { 428, 8, 10, 11, 1, -10 },
  { 438, 9, 10, 9, 0, -10 },
  { 450, 14, 10, 14, 0, -10 },
  { 468, 9, 10, 9, 0, -10 },
  { 480, 9, 10, 9, 0, -10 },
  { 492, 8, 10, 8, 0, -10 },
  { 502, 3, 12, 5, 1, -10 },
  { 507, 6, 10, 6, 0, -10 },
  { 515, 4, 12, 5, 0, -10 },
  { 521, 8, 6, 8, 0, -10 },
  { 527, 6, 1, 6, 0, 1 },
  { 528, 4, 3, 5, 1, -11 },
  { 530, 6, 8, 8, 1, -8 },
  { 536, 7, 11, 9, 1, -11 },
  { 546, 6, 8, 7, 1, -8 },
  { 552, 7, 11, 9, 1, -11 },
  { 562, 7, 8, 8, 1, -8 },
  { 569, 6, 11, 5, 0, -11 },
  { 578, 7, 11, 9, 1, -8 },
  { 588, 7, 11, 9, 1, -11 },
  { 598, 2, 11, 4, 1, -11 },
  { 601, 4, 14, 4, -1, -11 },
  { 608, 8, 11, 9, 1, -11 },
  { 619, 2, 11, 4, 1, -11 },
  { 622, 12, 8, 14, 1, -8 },
  { 634, 7, 8, 9, 1, -8 },
  { 641, 7, 8, 9, 1, -8 },
  { 648, 7, 11, 9, 1, -8 },
  { 658, 7, 11, 9, 1, -8 },
  { 668, 5, 8, 6, 1, -8 },
  { 673, 5, 8, 7, 1, -8 },
  { 678, 6, 9, 6, 0, -9 },
  { 685, 7, 8, 9, 1, -8 },
  { 692, 8, 8, 8, 0, -8 },
  { 700, 12, 8, 12, 0, -8 },
  { 712, 8, 8, 8, 0, -8 },
  { 720, 8, 11, 8, 0, -8 },
  { 731, 6, 8, 7, 0, -8 },
  { 737, 5, 12, 6, 0, -10 },
  { 745, 2, 14, 8, 3, -11 },
  { 749, 4, 12, 6, 1, -10 },
  { 755, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Bold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold14pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_BOLD14PT7B_H_
