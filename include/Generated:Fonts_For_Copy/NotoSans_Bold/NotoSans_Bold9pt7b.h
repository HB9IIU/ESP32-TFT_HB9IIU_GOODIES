#ifndef _NOTOSANS_BOLD9PT7B_H_
#define _NOTOSANS_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF4, 0x29, 0xF3, 0x3E, 0x51, 0x40, 0x23, 0xF8, 0xE3,
  0xFD, 0xC4, 0x40, 0xE4, 0xA8, 0xEE, 0x55, 0x15, 0x26, 0x20, 0xF1, 0x43,
  0x8D, 0x59, 0x9F, 0x80, 0xC0, 0x6B, 0x6C, 0x98, 0xC9, 0x96, 0xB0, 0x25,
  0x5C, 0xA0, 0x27, 0xC8, 0x40, 0x70, 0xE0, 0xC0, 0x32, 0x64, 0x48, 0x23,
  0xB7, 0xBD, 0xAD, 0xC0, 0xFD, 0xB6, 0xC0, 0x27, 0xC6, 0x22, 0x23, 0xE0,
  0x27, 0xC6, 0xE1, 0x8F, 0xC0, 0x31, 0x95, 0x2F, 0x88, 0x72, 0x1C, 0x31,
  0xF8, 0x13, 0x91, 0xED, 0xED, 0xC0, 0xF8, 0x84, 0x62, 0x30, 0x22, 0xD6,
  0xE5, 0xE5, 0xC0, 0x23, 0xB7, 0xB6, 0x89, 0xC0, 0xD0, 0xC0, 0x40, 0x70,
  0x09, 0xF0, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0x2F, 0x12,
  0x40, 0x60, 0x3E, 0x5E, 0xA5, 0xA5, 0x5E, 0x42, 0x3C, 0x30, 0xE6, 0x9E,
  0x4F, 0x10, 0xF4, 0xBD, 0x29, 0xF8, 0x15, 0xE4, 0x30, 0x41, 0x03, 0x80,
  0xF4, 0xE3, 0x19, 0xF8, 0xF8, 0xE8, 0x8F, 0xF3, 0xC9, 0x00, 0x27, 0xE1,
  0x7B, 0xCD, 0xE0, 0x8C, 0x7F, 0x18, 0xC4, 0xE9, 0x25, 0xC0, 0x24, 0x92,
  0x4E, 0x9D, 0x39, 0x4B, 0x4C, 0x88, 0x88, 0x8F, 0xC7, 0x9F, 0xBD, 0x7B,
  0x76, 0xC0, 0xCF, 0xBA, 0xEF, 0x9E, 0x70, 0x10, 0xF9, 0x16, 0x34, 0x68,
  0x8F, 0x00, 0xF9, 0xBE, 0x88, 0x10, 0xF9, 0x16, 0x34, 0x68, 0x8F, 0x06,
  0x06, 0xF4, 0xBD, 0xCB, 0x4C, 0x23, 0xF0, 0xC1, 0x4F, 0xC0, 0xF9, 0x08,
  0x42, 0x10, 0x8C, 0x63, 0x19, 0xF8, 0xCD, 0x24, 0x9E, 0x30, 0xC0, 0xD9,
  0xEE, 0x95, 0x4A, 0xE5, 0x61, 0x30, 0xCD, 0xE3, 0x0C, 0x5B, 0x30, 0xCD,
  0x63, 0x0C, 0x30, 0xC0, 0xF8, 0x88, 0xC4, 0x7C, 0xEA, 0xAC, 0xC4, 0x42,
  0x23, 0xD5, 0x5C, 0x22, 0x95, 0x10, 0xF0, 0xC4, 0x70, 0xDF, 0xB6, 0x80,
  0x88, 0xF9, 0x99, 0xF0, 0x74, 0xC4, 0x70, 0x08, 0x5E, 0x9C, 0xA5, 0xE0,
  0x72, 0x7E, 0x87, 0x80, 0x74, 0xE4, 0x44, 0x40, 0x7A, 0x72, 0x97, 0x85,
  0xE0, 0x88, 0xF9, 0x99, 0x90, 0xBE, 0x45, 0x55, 0xC0, 0x84, 0x25, 0x4E,
  0x52, 0x60, 0xFE, 0xFF, 0x26, 0x4C, 0x99, 0x20, 0xF9, 0x99, 0x90, 0x72,
  0x72, 0x97, 0x00, 0xF9, 0x99, 0xF8, 0x80, 0x7A, 0x72, 0x97, 0x84, 0x20,
  0xF2, 0x48, 0x7C, 0x71, 0xF0, 0x4F, 0x44, 0x47, 0x99, 0x99, 0xF0, 0xCA,
  0xD4, 0xA2, 0x00, 0xDB, 0xDA, 0x5A, 0x6E, 0x64, 0xDA, 0x88, 0xAD, 0x80,
  0xCA, 0xD4, 0xE2, 0x13, 0x80, 0xF3, 0x24, 0xF0, 0x69, 0x44, 0x98, 0xFF,
  0x80, 0xC9, 0x14, 0xB0, 0xEC, 0x80,
};

const GFXglyph NotoSans_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 3, 2, 4, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 1, 2, 2, 1, -6 },
  { 29, 3, 7, 3, 0, -6 },
  { 32, 3, 7, 3, 0, -6 },
  { 35, 5, 4, 5, 0, -7 },
  { 38, 5, 4, 5, 0, -5 },
  { 41, 2, 2, 3, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 2, 1, 3, 0, -1 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 5, 7, 5, 0, -7 },
  { 52, 3, 6, 5, 1, -6 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 5, 6, 5, 0, -6 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 2, 5, 3, 0, -5 },
  { 94, 2, 6, 3, 0, -5 },
  { 96, 5, 5, 5, 0, -6 },
  { 100, 5, 3, 5, 0, -5 },
  { 102, 5, 5, 5, 0, -6 },
  { 106, 4, 7, 4, 0, -7 },
  { 110, 8, 7, 8, 0, -6 },
  { 117, 6, 6, 6, 0, -6 },
  { 122, 5, 6, 6, 1, -6 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 5, 6, 7, 1, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 3, 6, 5, 1, -6 },
  { 142, 5, 7, 7, 1, -7 },
  { 147, 5, 6, 7, 1, -6 },
  { 151, 3, 6, 4, 0, -6 },
  { 154, 3, 8, 3, -1, -6 },
  { 157, 5, 6, 6, 1, -6 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 7, 6, 8, 1, -6 },
  { 170, 6, 6, 7, 1, -6 },
  { 175, 7, 7, 7, 0, -7 },
  { 182, 4, 6, 6, 1, -6 },
  { 185, 7, 9, 7, 0, -7 },
  { 193, 5, 6, 6, 1, -6 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 6, 5, 0, -6 },
  { 206, 5, 6, 7, 1, -6 },
  { 210, 6, 6, 6, 0, -6 },
  { 215, 9, 6, 9, 0, -6 },
  { 222, 6, 6, 6, 0, -6 },
  { 227, 6, 6, 6, 0, -6 },
  { 232, 5, 6, 5, 0, -6 },
  { 236, 2, 7, 3, 1, -6 },
  { 238, 4, 6, 4, 0, -6 },
  { 241, 2, 7, 3, 0, -6 },
  { 243, 5, 4, 5, 0, -6 },
  { 246, 4, 1, 4, 0, 1 },
  { 247, 3, 2, 3, 0, -7 },
  { 248, 5, 5, 5, 0, -5 },
  { 252, 4, 7, 6, 1, -7 },
  { 256, 4, 5, 5, 0, -5 },
  { 259, 5, 7, 6, 0, -7 },
  { 264, 5, 5, 5, 0, -5 },
  { 268, 4, 7, 3, 0, -7 },
  { 272, 5, 7, 6, 0, -5 },
  { 277, 4, 7, 6, 1, -7 },
  { 281, 1, 7, 3, 1, -7 },
  { 282, 2, 9, 3, 0, -7 },
  { 285, 5, 7, 6, 1, -7 },
  { 290, 1, 7, 3, 1, -7 },
  { 291, 7, 5, 9, 1, -5 },
  { 296, 4, 5, 6, 1, -5 },
  { 299, 5, 5, 6, 0, -5 },
  { 303, 4, 7, 6, 1, -5 },
  { 307, 5, 7, 6, 0, -5 },
  { 312, 3, 5, 4, 1, -5 },
  { 314, 4, 5, 5, 0, -5 },
  { 317, 4, 6, 4, 0, -6 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 8, 5, 8, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 5, 7, 5, 0, -5 },
  { 341, 4, 5, 4, 0, -5 },
  { 344, 3, 7, 4, 0, -6 },
  { 347, 1, 9, 5, 2, -7 },
  { 349, 3, 7, 4, 0, -6 },
  { 352, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Bold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold9pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_BOLD9PT7B_H_
