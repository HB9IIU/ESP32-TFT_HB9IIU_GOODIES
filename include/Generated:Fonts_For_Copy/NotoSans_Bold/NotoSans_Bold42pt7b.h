#ifndef _NOTOSANS_BOLD42PT7B_H_
#define _NOTOSANS_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0x7E, 0x10, 0xFC, 0x7F, 0xF8, 0xFB,
  0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0x67, 0xEF, 0xC6, 0x04, 0xFC, 0x60, 0x0F, 0xC6, 0x00, 0xFE, 0x60, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x6F, 0xF0, 0x06, 0x3F, 0x00, 0x63,
  0xF8, 0x06, 0x3F, 0xE0, 0x63, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x7C, 0x7C,
  0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x7C, 0x7F, 0x07, 0xC7, 0xCF, 0x8F, 0xF8, 0x7F, 0xFC, 0xF9, 0xFF, 0xC3,
  0xFF, 0x9F, 0x3F, 0xFE, 0x1F, 0xF1, 0xF3, 0xE3, 0xE0, 0xFE, 0x3E, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC1, 0xE0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x0F,
  0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x3C, 0x3E, 0x00, 0x3E, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x3E,
  0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0x81, 0xFC, 0x7F, 0xFF, 0x07, 0xE1, 0xFD,
  0xFE, 0x1F, 0x8F, 0xE3, 0xFC, 0xFE, 0x3F, 0x87, 0xFB, 0xF0, 0xFC, 0x0F,
  0xFF, 0xC3, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F, 0x80, 0x7F,
  0xC0, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x07, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x78, 0x09,
  0xE3, 0xC3, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x01,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x01, 0xC1, 0xC0, 0x02, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xFE, 0xFE, 0xFF,
  0xFE, 0x7E, 0x10, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07,
  0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0x7E, 0x7E, 0x78, 0xFC, 0x61, 0xF8, 0x83, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0x07, 0xF8, 0xE0,
  0x1F, 0xC2, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0x80, 0xFE, 0x20, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x01,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x10, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x9F, 0xE0, 0x7C, 0xFF, 0xE1, 0xF7, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xF3, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xDF,
  0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0,
  0x7E, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFE,
  0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x80,
  0x7E, 0x7E, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFE, 0xF8, 0x7F, 0xF3, 0xE0, 0xFF, 0x9F, 0x80, 0x20, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFE, 0xFF,
  0xFE, 0x7E, 0x10, 0x3F, 0x1F, 0x9F, 0xEF, 0xF3, 0xF1, 0xF8, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x70, 0x1F, 0xC8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x07, 0xFF, 0x0F, 0x8F,
  0x83, 0xFF, 0xE3, 0xE7, 0xC1, 0xFF, 0xF8, 0x79, 0xF0, 0xFE, 0x3E, 0x1E,
  0x78, 0x7E, 0x0F, 0x87, 0xFE, 0x1F, 0x03, 0xE1, 0xFF, 0x8F, 0x80, 0xF8,
  0x7F, 0xE3, 0xE0, 0x3E, 0x1F, 0xF8, 0xF8, 0x0F, 0x87, 0xFE, 0x3E, 0x03,
  0xE1, 0xEF, 0x8F, 0x80, 0xF8, 0x7B, 0xE3, 0xE0, 0x7E, 0x3E, 0xF8, 0x7C,
  0x1F, 0x8F, 0xBE, 0x1F, 0xFF, 0xFF, 0xCF, 0x83, 0xFF, 0xFF, 0xE1, 0xF0,
  0xFF, 0xCF, 0xF8, 0x7C, 0x0F, 0xE1, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF0, 0x1F, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0x3F, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x3C,
  0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x02, 0x3F, 0xF0, 0x1C, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x03, 0xFC,
  0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x70, 0xFF, 0x80, 0x08,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xDF, 0x80,
  0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x7F, 0x80, 0x3F, 0x1F, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F,
  0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC,
  0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFF, 0x00,
  0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFB, 0xE0, 0x07,
  0xFF, 0xFB, 0xE0, 0x0F, 0xBF, 0xFB, 0xE0, 0x0F, 0xBF, 0xFB, 0xF0, 0x0F,
  0xBF, 0xF9, 0xF0, 0x1F, 0x3F, 0xF9, 0xF0, 0x1F, 0x3F, 0xF9, 0xF8, 0x1F,
  0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0xFC, 0x3E,
  0x3F, 0xF8, 0x7C, 0x7C, 0x3F, 0xF8, 0x7C, 0x7C, 0x3F, 0xF8, 0x7C, 0x7C,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFB, 0xF8, 0x07, 0xFE, 0x7E,
  0x01, 0xFF, 0x9F, 0xC0, 0x7F, 0xE3, 0xF0, 0x1F, 0xF8, 0xFE, 0x07, 0xFE,
  0x1F, 0xC1, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xFE, 0x1F, 0xF8, 0x1F, 0x87,
  0xFE, 0x07, 0xF1, 0xFF, 0x80, 0xFE, 0x7F, 0xE0, 0x3F, 0x9F, 0xF8, 0x07,
  0xF7, 0xFE, 0x01, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFE, 0x07, 0xBF, 0x80,
  0x17, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xFF, 0x00, 0xFC,
  0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x1F, 0x80, 0xFB, 0xE0, 0x7E, 0x07, 0xE0,
  0x7D, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0,
  0x1F, 0x8F, 0xC7, 0xC3, 0xF0, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0x07, 0xE3,
  0xE0, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x3E,
  0x7E, 0x00, 0x7E, 0xF8, 0x1F, 0x3E, 0x00, 0x3F, 0x7C, 0x07, 0xFF, 0x00,
  0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x03,
  0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0x0F, 0xF0, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xE3,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0x9F, 0x1F,
  0xE0, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xDF, 0xFC, 0x3E, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0x03, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x19, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xF3, 0xE0, 0xFE,
  0x1F, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x8F, 0xF8, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0xF8, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0x81, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x1F, 0xE7, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xD0, 0x00, 0xFE, 0xF0, 0x0F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x79, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03,
  0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0xFF,
  0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0xF8, 0x7F, 0x87,
  0xC7, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3,
  0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xF8, 0x7F, 0x83, 0xF3, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E,
  0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x03,
  0xFB, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xF7, 0xFF, 0x0F, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xF8,
  0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x81,
  0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x1F, 0xE7, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0xF7, 0xE0, 0x13, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF,
  0x9F, 0xFE, 0x7C, 0x3F, 0xC3, 0xE0, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x7E,
  0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x07, 0xFE,
  0x0F, 0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x3F, 0x07, 0xBE, 0x0F, 0xC1, 0xF8,
  0x79, 0xE1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8,
  0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xFC, 0xF0, 0xF3, 0xF0, 0x0F, 0xDF, 0x0F,
  0x3F, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xDF, 0x0F, 0xBE, 0x00, 0x7D,
  0xE0, 0xFB, 0xE0, 0x07, 0xDE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFE, 0x80, 0x07, 0x80,
};

const GFXglyph NotoSans_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 31, 12, 2, -30 },
  { 32, 15, 11, 20, 3, -30 },
  { 53, 25, 30, 27, 1, -30 },
  { 147, 20, 34, 24, 2, -32 },
  { 232, 36, 30, 38, 1, -30 },
  { 367, 30, 30, 32, 2, -30 },
  { 480, 6, 11, 11, 3, -30 },
  { 489, 11, 37, 14, 2, -30 },
  { 540, 12, 37, 14, 1, -30 },
  { 596, 21, 20, 23, 1, -32 },
  { 649, 20, 20, 24, 2, -25 },
  { 699, 8, 10, 12, 1, -5 },
  { 709, 11, 5, 13, 1, -14 },
  { 716, 8, 7, 12, 2, -6 },
  { 723, 17, 30, 17, 0, -30 },
  { 787, 20, 30, 24, 2, -30 },
  { 862, 15, 30, 24, 2, -30 },
  { 919, 21, 30, 24, 2, -30 },
  { 998, 20, 30, 24, 2, -30 },
  { 1073, 22, 30, 24, 1, -30 },
  { 1156, 20, 30, 24, 2, -30 },
  { 1231, 22, 30, 24, 1, -30 },
  { 1314, 22, 30, 24, 1, -30 },
  { 1397, 22, 30, 24, 1, -30 },
  { 1480, 22, 30, 24, 1, -30 },
  { 1563, 8, 24, 12, 2, -23 },
  { 1587, 9, 28, 12, 1, -23 },
  { 1619, 20, 22, 24, 2, -26 },
  { 1674, 20, 12, 24, 2, -21 },
  { 1704, 20, 22, 24, 2, -26 },
  { 1759, 19, 31, 20, 0, -30 },
  { 1833, 34, 33, 38, 2, -30 },
  { 1974, 29, 30, 29, 0, -30 },
  { 2083, 22, 30, 28, 4, -30 },
  { 2166, 24, 30, 27, 2, -30 },
  { 2256, 24, 30, 31, 4, -30 },
  { 2346, 17, 30, 24, 4, -30 },
  { 2410, 17, 30, 23, 4, -30 },
  { 2474, 25, 30, 30, 2, -30 },
  { 2568, 24, 30, 32, 4, -30 },
  { 2658, 14, 30, 16, 1, -30 },
  { 2711, 13, 39, 14, -3, -30 },
  { 2775, 24, 30, 28, 4, -30 },
  { 2865, 18, 30, 23, 4, -30 },
  { 2933, 32, 30, 40, 4, -30 },
  { 3053, 26, 30, 34, 4, -30 },
  { 3151, 29, 30, 33, 2, -30 },
  { 3260, 20, 30, 26, 4, -30 },
  { 3335, 29, 37, 33, 2, -30 },
  { 3470, 24, 30, 28, 4, -30 },
  { 3560, 19, 30, 23, 2, -30 },
  { 3632, 22, 30, 24, 1, -30 },
  { 3715, 24, 30, 32, 4, -30 },
  { 3805, 27, 30, 27, 0, -30 },
  { 3907, 41, 30, 41, 0, -30 },
  { 4061, 28, 30, 28, 0, -30 },
  { 4166, 26, 30, 26, 0, -30 },
  { 4264, 22, 30, 24, 1, -30 },
  { 4347, 10, 37, 14, 3, -30 },
  { 4394, 17, 30, 17, 0, -30 },
  { 4458, 10, 37, 14, 1, -30 },
  { 4505, 22, 19, 24, 1, -30 },
  { 4558, 17, 3, 17, 0, 4 },
  { 4565, 12, 7, 15, 2, -32 },
  { 4576, 20, 23, 25, 2, -23 },
  { 4634, 22, 32, 27, 3, -32 },
  { 4722, 19, 23, 22, 2, -23 },
  { 4777, 21, 32, 27, 2, -32 },
  { 4861, 21, 23, 25, 2, -23 },
  { 4922, 17, 32, 16, 1, -32 },
  { 4990, 21, 33, 27, 2, -23 },
  { 5077, 21, 32, 27, 3, -32 },
  { 5161, 7, 32, 13, 3, -32 },
  { 5189, 12, 42, 13, -2, -32 },
  { 5252, 23, 32, 26, 3, -32 },
  { 5344, 6, 32, 13, 3, -32 },
  { 5368, 35, 23, 41, 3, -23 },
  { 5469, 21, 23, 27, 3, -23 },
  { 5530, 22, 23, 26, 2, -23 },
  { 5594, 22, 33, 27, 3, -23 },
  { 5685, 21, 33, 27, 2, -23 },
  { 5772, 15, 23, 19, 3, -23 },
  { 5816, 17, 23, 21, 2, -23 },
  { 5865, 16, 28, 18, 1, -28 },
  { 5921, 21, 23, 27, 3, -23 },
  { 5982, 24, 23, 24, 0, -23 },
  { 6051, 36, 23, 36, 0, -23 },
  { 6155, 24, 23, 24, 0, -23 },
  { 6224, 24, 33, 24, 0, -23 },
  { 6323, 18, 23, 21, 1, -23 },
  { 6375, 14, 37, 17, 1, -30 },
  { 6440, 5, 42, 23, 9, -32 },
  { 6467, 14, 37, 17, 2, -30 },
  { 6532, 20, 7, 24, 2, -18 },
};

const GFXfont NotoSans_Bold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold42pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_BOLD42PT7B_H_
