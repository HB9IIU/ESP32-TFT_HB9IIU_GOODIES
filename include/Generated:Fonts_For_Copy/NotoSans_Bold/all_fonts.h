#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Bold
// Headers: 67

#include "NotoSans_Bold6pt7b.h"
#include "NotoSans_Bold7pt7b.h"
#include "NotoSans_Bold8pt7b.h"
#include "NotoSans_Bold9pt7b.h"
#include "NotoSans_Bold10pt7b.h"
#include "NotoSans_Bold11pt7b.h"
#include "NotoSans_Bold12pt7b.h"
#include "NotoSans_Bold13pt7b.h"
#include "NotoSans_Bold14pt7b.h"
#include "NotoSans_Bold15pt7b.h"
#include "NotoSans_Bold16pt7b.h"
#include "NotoSans_Bold17pt7b.h"
#include "NotoSans_Bold18pt7b.h"
#include "NotoSans_Bold19pt7b.h"
#include "NotoSans_Bold20pt7b.h"
#include "NotoSans_Bold21pt7b.h"
#include "NotoSans_Bold22pt7b.h"
#include "NotoSans_Bold23pt7b.h"
#include "NotoSans_Bold24pt7b.h"
#include "NotoSans_Bold25pt7b.h"
#include "NotoSans_Bold26pt7b.h"
#include "NotoSans_Bold27pt7b.h"
#include "NotoSans_Bold28pt7b.h"
#include "NotoSans_Bold29pt7b.h"
#include "NotoSans_Bold30pt7b.h"
#include "NotoSans_Bold31pt7b.h"
#include "NotoSans_Bold32pt7b.h"
#include "NotoSans_Bold33pt7b.h"
#include "NotoSans_Bold34pt7b.h"
#include "NotoSans_Bold35pt7b.h"
#include "NotoSans_Bold36pt7b.h"
#include "NotoSans_Bold37pt7b.h"
#include "NotoSans_Bold38pt7b.h"
#include "NotoSans_Bold39pt7b.h"
#include "NotoSans_Bold40pt7b.h"
#include "NotoSans_Bold41pt7b.h"
#include "NotoSans_Bold42pt7b.h"
#include "NotoSans_Bold43pt7b.h"
#include "NotoSans_Bold44pt7b.h"
#include "NotoSans_Bold45pt7b.h"
#include "NotoSans_Bold46pt7b.h"
#include "NotoSans_Bold47pt7b.h"
#include "NotoSans_Bold48pt7b.h"
#include "NotoSans_Bold49pt7b.h"
#include "NotoSans_Bold50pt7b.h"
#include "NotoSans_Bold51pt7b.h"
#include "NotoSans_Bold52pt7b.h"
#include "NotoSans_Bold53pt7b.h"
#include "NotoSans_Bold54pt7b.h"
#include "NotoSans_Bold55pt7b.h"
#include "NotoSans_Bold56pt7b.h"
#include "NotoSans_Bold57pt7b.h"
#include "NotoSans_Bold58pt7b.h"
#include "NotoSans_Bold59pt7b.h"
#include "NotoSans_Bold60pt7b.h"
#include "NotoSans_Bold61pt7b.h"
#include "NotoSans_Bold62pt7b.h"
#include "NotoSans_Bold63pt7b.h"
#include "NotoSans_Bold64pt7b.h"
#include "NotoSans_Bold65pt7b.h"
#include "NotoSans_Bold66pt7b.h"
#include "NotoSans_Bold67pt7b.h"
#include "NotoSans_Bold68pt7b.h"
#include "NotoSans_Bold69pt7b.h"
#include "NotoSans_Bold70pt7b.h"
#include "NotoSans_Bold71pt7b.h"
#include "NotoSans_Bold72pt7b.h"
