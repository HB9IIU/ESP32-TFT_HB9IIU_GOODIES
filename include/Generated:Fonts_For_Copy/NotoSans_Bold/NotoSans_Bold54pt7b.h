#ifndef _NOTOSANS_BOLD54PT7B_H_
#define _NOTOSANS_BOLD54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x38, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0x03, 0x8F, 0xF0, 0xE0, 0x11, 0xFE, 0x1C,
  0x00, 0x3F, 0xE3, 0x80, 0x03, 0xFC, 0x70, 0x00, 0x7F, 0xEE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3B, 0xFF, 0x00, 0x07, 0x1F,
  0xF0, 0x00, 0xE1, 0xFE, 0x00, 0x1C, 0x3F, 0xF0, 0x03, 0x87, 0xFF, 0xC0,
  0x71, 0xFE, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE1, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0xFE, 0x07,
  0x80, 0xFC, 0x1F, 0xC7, 0xE1, 0xFF, 0x07, 0xF0, 0xFC, 0x7F, 0x1F, 0xFE,
  0x1F, 0xCF, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xCF, 0xE1, 0xF8, 0x3F,
  0xF0, 0xFC, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x7F,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x3F,
  0xE1, 0xFF, 0x03, 0xFF, 0x7F, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03, 0x80, 0xF8, 0x06,
  0xFC, 0x3E, 0x1F, 0xBF, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F,
  0xC0, 0x0F, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xF0,
  0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0xCF,
  0xF3, 0xF1, 0xFE, 0x38, 0x3F, 0xC2, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xFE, 0x1E, 0x00, 0x7F, 0xC1,
  0x80, 0x07, 0xF8, 0x20, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x07, 0xFC, 0x18, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF6, 0x00, 0x07, 0xFE, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xF3, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x87,
  0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x70, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0,
  0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0xFC, 0x07,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0xC0, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x07, 0xF9, 0xFF, 0xE0, 0xFF, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80,
  0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFE, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF7, 0xF8, 0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0x1F, 0xC0, 0x06,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x70,
  0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFE, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F,
  0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7C, 0x01, 0xFE, 0x10, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x0F, 0xE3, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC,
  0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0x9F, 0x81, 0xFF, 0xFF, 0xC1, 0xF3, 0xF0,
  0x7F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xFF, 0x83, 0xF8,
  0x0F, 0xE0, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0x3F,
  0x03, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x00, 0xFC, 0x0F,
  0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0xF8,
  0x3F, 0x00, 0x7E, 0x07, 0xDF, 0x87, 0xF0, 0x1F, 0xC1, 0xFB, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0xFF, 0x8F, 0xCF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xF3, 0xFF,
  0x83, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xCF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0xFF, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x7C, 0x1F, 0xF8, 0x00, 0x30, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0C,
  0x1F, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x08, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x68, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0xCF,
  0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xDF, 0xFF, 0xFF, 0x00, 0x07,
  0xEF, 0xFF, 0xDF, 0x80, 0x07, 0xF7, 0xFF, 0xEF, 0xE0, 0x03, 0xF3, 0xFF,
  0xF7, 0xF0, 0x01, 0xF9, 0xFF, 0xF9, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0xFE,
  0x00, 0xFC, 0x7F, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0xFF, 0x1F, 0x80, 0x7F,
  0x3F, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0xFF, 0xC7, 0xF0, 0x1F, 0x8F, 0xFF,
  0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0xF0, 0xFC, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F,
  0x07, 0xE1, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFB, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xF0, 0x07,
  0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xE0,
  0x1F, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xE1, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0x1F, 0xFF,
  0x80, 0x3F, 0xE7, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0x7F,
  0xFE, 0x00, 0x3F, 0xDF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xEF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF4, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xF0, 0xFF,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0x8F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x78, 0x7F, 0xC0,
  0x02, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFB, 0xE0, 0x03, 0xFE, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xF9, 0xF8, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x7E, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0xCF, 0xE0, 0x3F, 0x3F, 0xC0, 0x01, 0xFC, 0xFC, 0x03, 0xFB,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x30, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xF1, 0xFF, 0xF8, 0xFE,
  0x1F, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x1F, 0xFC, 0x0F, 0xF3, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0,
  0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F,
  0xE3, 0xFF, 0xE0, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xF0, 0x0C, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x01, 0xBF, 0xF8, 0x1F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0xF1, 0xFE,
  0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF,
  0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0x7F, 0x03, 0xFE, 0x07, 0xE0, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8,
  0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x23, 0xFF, 0x00, 0x1C, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC1, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFF, 0x3F, 0x8F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xEF, 0xF0, 0xFF, 0xF9, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x08, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFD, 0x00,
  0x00, 0xFF, 0xBC, 0x00, 0x3F, 0xE7, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF1,
  0xFF, 0xE1, 0xFE, 0x7F, 0xFE, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x00,
  0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF1, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xFC,
  0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0xDF, 0xE0, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0x9F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0x83, 0xFF, 0xC3, 0xF9, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE1, 0xFF,
  0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF0, 0xFF, 0x3F, 0xFE, 0x0F,
  0xF1, 0xFF, 0x80, 0xFF, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F,
  0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F,
  0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xEF, 0xF0,
  0xFF, 0xF9, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x08, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xE0, 0x1E, 0x7F,
  0x80, 0x08, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xD0, 0x00, 0x7F, 0xB8, 0x01, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x04, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xC7, 0xF0, 0x7F, 0xF0,
  0x7E, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0x87, 0xF8, 0x1F, 0xBF, 0x03, 0xF8, 0x3F, 0xC1, 0xF9, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xCF, 0xC1, 0xFE, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x0F, 0xC7, 0xF8, 0x07,
  0xF1, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x01, 0xFE,
  0x7E, 0x1F, 0x8F, 0xE0, 0x0F, 0xF3, 0xE0, 0x7E, 0xFF, 0x00, 0x3F, 0xBF,
  0x03, 0xF7, 0xF8, 0x01, 0xFD, 0xF8, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0,
  0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x03, 0xEF, 0xE0, 0x01, 0xFB, 0xE0, 0x1F,
  0x7E, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x23, 0xFF, 0x00, 0x0D, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x80, 0x03, 0xFF, 0x00,
};

const GFXglyph NotoSans_Bold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 40, 15, 3, -39 },
  { 46, 20, 14, 26, 3, -39 },
  { 81, 33, 39, 35, 1, -39 },
  { 242, 27, 44, 31, 2, -41 },
  { 391, 45, 39, 49, 2, -39 },
  { 611, 39, 40, 41, 2, -39 },
  { 806, 8, 14, 14, 3, -39 },
  { 820, 15, 48, 18, 2, -39 },
  { 910, 14, 48, 18, 2, -39 },
  { 994, 26, 25, 29, 2, -41 },
  { 1076, 27, 26, 31, 2, -32 },
  { 1164, 10, 13, 15, 2, -6 },
  { 1181, 14, 7, 17, 2, -18 },
  { 1194, 9, 9, 15, 3, -8 },
  { 1205, 22, 39, 22, 0, -39 },
  { 1313, 27, 40, 31, 2, -39 },
  { 1448, 19, 39, 31, 3, -39 },
  { 1541, 27, 39, 31, 2, -39 },
  { 1673, 27, 40, 31, 2, -39 },
  { 1808, 29, 39, 31, 1, -39 },
  { 1950, 25, 40, 31, 3, -39 },
  { 2075, 27, 40, 31, 2, -39 },
  { 2210, 28, 39, 31, 1, -39 },
  { 2347, 27, 40, 31, 2, -39 },
  { 2482, 27, 40, 31, 2, -39 },
  { 2617, 9, 31, 15, 3, -30 },
  { 2652, 10, 37, 15, 2, -30 },
  { 2699, 27, 29, 31, 2, -34 },
  { 2797, 27, 16, 31, 2, -27 },
  { 2851, 27, 29, 31, 2, -34 },
  { 2949, 25, 40, 26, 0, -39 },
  { 3074, 43, 43, 48, 3, -39 },
  { 3306, 37, 39, 37, 0, -39 },
  { 3487, 28, 39, 36, 5, -39 },
  { 3624, 30, 40, 35, 3, -39 },
  { 3774, 32, 39, 40, 5, -39 },
  { 3930, 22, 39, 30, 5, -39 },
  { 4038, 22, 39, 30, 5, -39 },
  { 4146, 32, 40, 39, 3, -39 },
  { 4306, 31, 39, 41, 5, -39 },
  { 4458, 17, 39, 21, 2, -39 },
  { 4541, 17, 50, 18, -4, -39 },
  { 4648, 31, 39, 36, 5, -39 },
  { 4800, 23, 39, 30, 5, -39 },
  { 4913, 41, 39, 51, 5, -39 },
  { 5113, 34, 39, 44, 5, -39 },
  { 5279, 37, 40, 43, 3, -39 },
  { 5464, 26, 39, 34, 5, -39 },
  { 5591, 37, 48, 43, 3, -39 },
  { 5813, 30, 39, 35, 5, -39 },
  { 5960, 26, 40, 30, 2, -39 },
  { 6090, 29, 39, 31, 1, -39 },
  { 6232, 31, 40, 41, 5, -39 },
  { 6387, 35, 39, 35, 0, -39 },
  { 6558, 52, 39, 52, 0, -39 },
  { 6812, 36, 39, 36, 0, -39 },
  { 6988, 34, 39, 34, 0, -39 },
  { 7154, 29, 39, 31, 1, -39 },
  { 7296, 13, 48, 18, 4, -39 },
  { 7374, 22, 39, 22, 0, -39 },
  { 7482, 13, 48, 18, 1, -39 },
  { 7560, 29, 25, 31, 1, -39 },
  { 7651, 22, 4, 22, 0, 5 },
  { 7662, 16, 8, 20, 2, -41 },
  { 7678, 27, 31, 32, 2, -30 },
  { 7783, 28, 42, 34, 4, -41 },
  { 7930, 23, 31, 28, 3, -30 },
  { 8020, 27, 42, 34, 3, -41 },
  { 8162, 27, 31, 32, 3, -30 },
  { 8267, 22, 41, 21, 1, -41 },
  { 8380, 27, 43, 34, 3, -30 },
  { 8526, 27, 41, 35, 4, -41 },
  { 8665, 9, 41, 16, 4, -41 },
  { 8712, 16, 54, 16, -3, -41 },
  { 8820, 29, 41, 33, 4, -41 },
  { 8969, 8, 41, 16, 4, -41 },
  { 9010, 45, 30, 53, 4, -30 },
  { 9179, 27, 30, 35, 4, -30 },
  { 9281, 28, 31, 34, 3, -30 },
  { 9390, 28, 43, 34, 4, -30 },
  { 9541, 27, 43, 34, 3, -30 },
  { 9687, 19, 30, 24, 4, -30 },
  { 9759, 23, 31, 27, 2, -30 },
  { 9849, 21, 37, 23, 1, -36 },
  { 9947, 27, 30, 35, 4, -29 },
  { 10049, 31, 29, 31, 0, -29 },
  { 10162, 45, 29, 46, 1, -29 },
  { 10326, 31, 29, 31, 0, -29 },
  { 10439, 31, 42, 31, 0, -29 },
  { 10602, 23, 29, 27, 2, -29 },
  { 10686, 18, 48, 21, 1, -39 },
  { 10794, 6, 53, 30, 12, -41 },
  { 10834, 18, 48, 21, 2, -39 },
  { 10942, 27, 9, 31, 2, -24 },
};

const GFXfont NotoSans_Bold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold54pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_BOLD54PT7B_H_
