#ifndef _NOTOSANS_BOLD41PT7B_H_
#define _NOTOSANS_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC2, 0x00, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xFB, 0xE1, 0xF7,
  0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFE, 0xE1, 0xCF, 0xCE, 0x00, 0xFC, 0xE0, 0x0F, 0xCE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xE7, 0xF0, 0x0E,
  0x3F, 0x80, 0xE3, 0xFE, 0x0E, 0x7F, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0xFC, 0x01, 0xE0, 0x07, 0xEF,
  0x80, 0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x07,
  0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC7,
  0x87, 0xC0, 0xF8, 0xF9, 0xF3, 0xFE, 0x1F, 0x3E, 0x7C, 0xFF, 0xE1, 0xFF,
  0xCF, 0x9F, 0xFE, 0x3F, 0xF3, 0xE7, 0xE7, 0xC3, 0xFC, 0x7C, 0xF8, 0xF8,
  0x1E, 0x1F, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x3E, 0x00, 0x1E, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0xF8, 0x01, 0xF0,
  0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0xF8, 0xF8, 0x01,
  0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF0,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xC3,
  0xFF, 0x80, 0xFC, 0x7F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF8, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF1, 0xFC, 0x3F, 0xBF, 0x8F, 0xC0, 0xFF, 0xF8, 0x7E, 0x03, 0xFF,
  0xC3, 0xF0, 0x0F, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0xFE, 0x03, 0xFF, 0x83, 0xFC, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF0, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0x7C, 0xF3, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F, 0x0F, 0xC0, 0xF0,
  0xF0, 0x03, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C,
  0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D,
  0xFF, 0xFF, 0xFF, 0xEF, 0xC4, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xE7, 0xF0, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0x7C, 0x7E, 0x70, 0xFC,
  0x41, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFB, 0xFE, 0x7C, 0x0F, 0xE3, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xE3, 0xFE, 0x30, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xFC,
  0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0x87, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x80, 0x07, 0xEE,
  0x01, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF8, 0x10, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x07, 0xCF,
  0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x7F, 0x3F, 0x03, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1,
  0xFE, 0xFF, 0x0F, 0xC1, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0x9F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xEF, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xFC,
  0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xEF, 0xC3, 0xFE, 0x7E,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xC1, 0xCF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x88, 0x1C, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x3F, 0x8C, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x7E, 0x07, 0xF8, 0x3E, 0x3E, 0x0F, 0xFF, 0x1F, 0x3E, 0x0F, 0xFF, 0x87,
  0x9F, 0x0F, 0xFF, 0xC3, 0xEF, 0x0F, 0xC1, 0xE1, 0xFF, 0x87, 0xC0, 0xF0,
  0xFF, 0xC7, 0xC0, 0x78, 0x3F, 0xE3, 0xE0, 0x7C, 0x1F, 0xE1, 0xF0, 0x3E,
  0x1F, 0xF0, 0xF8, 0x1F, 0x0F, 0xF8, 0x7C, 0x0F, 0x87, 0xBC, 0x3E, 0x07,
  0xC3, 0xDF, 0x1F, 0x07, 0xE3, 0xEF, 0x87, 0xC7, 0xFB, 0xE7, 0xC3, 0xFF,
  0xFF, 0xF1, 0xE0, 0xFF, 0xDF, 0xF0, 0xF8, 0x3F, 0xC7, 0xF0, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE,
  0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFE, 0x07, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF8, 0x06, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x1C, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF9,
  0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x06, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xE0, 0x3F, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0xFF,
  0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x1C, 0x00, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F,
  0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF9,
  0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xF3,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3E, 0xFF, 0xEF, 0x80, 0x7D,
  0xFF, 0xCF, 0x80, 0xFB, 0xFF, 0x9F, 0x03, 0xE7, 0xFF, 0x3E, 0x07, 0xCF,
  0xFE, 0x3E, 0x0F, 0x9F, 0xFC, 0x7C, 0x3E, 0x3F, 0xF8, 0xF8, 0x7C, 0x7F,
  0xF0, 0xF8, 0xF8, 0xFF, 0xE1, 0xF3, 0xE1, 0xFF, 0xC3, 0xE7, 0xC3, 0xFF,
  0x87, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xF8, 0x0F, 0xFE, 0x7E, 0x03, 0xFF, 0x9F, 0xC0, 0xFF, 0xE3,
  0xF0, 0x3F, 0xF8, 0xFE, 0x0F, 0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFF,
  0xE0, 0xFE, 0x3F, 0xF8, 0x1F, 0x8F, 0xFE, 0x07, 0xF3, 0xFF, 0x80, 0xFC,
  0xFF, 0xE0, 0x3F, 0xBF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x03, 0xFB, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x80, 0x67, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFF,
  0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0x00, 0xFC,
  0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01,
  0xFF, 0x81, 0xF8, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x83, 0xEF, 0xC1,
  0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF0, 0x0F,
  0x87, 0xE7, 0xC3, 0xF0, 0x0F, 0xC7, 0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3,
  0xE3, 0xF0, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0x07, 0xCF, 0x83, 0xE7, 0xE0,
  0x07, 0xCF, 0x83, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF,
  0x81, 0xF7, 0xC0, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE7, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x8F,
  0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x0F, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF3, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xC0, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0x9F, 0x1F, 0xE1, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xC7, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xF8,
  0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0xFF, 0xE3,
  0xE3, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xE0, 0xE7, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x27, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xC1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F,
  0xFE, 0x7C, 0x1F, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF,
  0xC0, 0x3E, 0xFC, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x01, 0x1F, 0xF0, 0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xC3, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xF7, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x1F, 0xC7,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xD0, 0x00, 0xFC, 0xF0,
  0x1F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x1E, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xC3, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xE0, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE8, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xEF, 0xC0,
  0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC,
  0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0xF0, 0x3E, 0x3F, 0xE0, 0xFF, 0x8F, 0x9F, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x00,
  0x1E, 0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7E, 0x7E, 0x03, 0xF9, 0xFC,
  0x0F, 0xE3, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC7, 0xFC, 0x3F, 0x7F, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xF7, 0xF8, 0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E,
  0xFF, 0xE3, 0xF3, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xCF,
  0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xF7, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xDF, 0x8F, 0xFE, 0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xE0, 0x7F,
  0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0x33, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFB, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFB, 0xF3, 0xFF, 0xDF, 0x87, 0xF8, 0x7C, 0xFE, 0x00, 0x7E, 0xFC,
  0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x1F, 0xF0,
  0x3F, 0x1F, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x7B, 0xC1, 0xF8, 0x7E, 0x0F,
  0x78, 0x3F, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x7D, 0xF0, 0xF8, 0x1F,
  0x8F, 0x1E, 0x3F, 0x03, 0xF1, 0xE3, 0xC7, 0xE0, 0x7E, 0x7C, 0x7C, 0xFC,
  0x07, 0xCF, 0x8F, 0x9F, 0x00, 0xFD, 0xF1, 0xF7, 0xE0, 0x1F, 0xBC, 0x1E,
  0xFC, 0x01, 0xF7, 0x83, 0xDF, 0x00, 0x3E, 0xF0, 0x7B, 0xE0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7,
  0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81,
  0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0x7F,
  0xC3, 0xFF, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x1F, 0x80,
};

const GFXglyph NotoSans_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 30, 12, 2, -29 },
  { 28, 15, 10, 20, 2, -29 },
  { 47, 25, 29, 26, 1, -29 },
  { 138, 20, 33, 23, 2, -31 },
  { 221, 35, 30, 37, 1, -30 },
  { 353, 29, 30, 31, 2, -30 },
  { 462, 6, 10, 11, 2, -29 },
  { 470, 11, 35, 14, 2, -29 },
  { 519, 11, 35, 14, 1, -29 },
  { 568, 20, 19, 22, 1, -31 },
  { 616, 20, 19, 23, 2, -24 },
  { 664, 8, 10, 12, 1, -5 },
  { 674, 11, 6, 13, 1, -14 },
  { 683, 7, 7, 12, 2, -6 },
  { 690, 17, 30, 17, 0, -30 },
  { 754, 21, 30, 23, 1, -30 },
  { 833, 15, 29, 23, 2, -29 },
  { 888, 20, 30, 23, 2, -30 },
  { 963, 20, 30, 23, 2, -30 },
  { 1038, 22, 29, 23, 1, -29 },
  { 1118, 20, 29, 23, 2, -29 },
  { 1191, 21, 30, 23, 1, -30 },
  { 1270, 21, 29, 23, 1, -29 },
  { 1347, 21, 30, 23, 1, -30 },
  { 1426, 21, 30, 23, 1, -30 },
  { 1505, 7, 24, 12, 2, -23 },
  { 1526, 8, 28, 12, 1, -23 },
  { 1554, 20, 22, 23, 2, -26 },
  { 1609, 20, 13, 23, 2, -21 },
  { 1642, 20, 22, 23, 2, -26 },
  { 1697, 19, 31, 20, 0, -30 },
  { 1771, 33, 32, 37, 2, -29 },
  { 1903, 28, 29, 28, 0, -29 },
  { 2005, 22, 29, 27, 3, -29 },
  { 2085, 23, 30, 26, 2, -30 },
  { 2172, 25, 29, 30, 3, -29 },
  { 2263, 17, 29, 23, 4, -29 },
  { 2325, 16, 29, 23, 4, -29 },
  { 2383, 24, 30, 30, 2, -30 },
  { 2473, 24, 29, 31, 4, -29 },
  { 2560, 14, 29, 16, 1, -29 },
  { 2611, 13, 38, 14, -3, -29 },
  { 2673, 23, 29, 27, 4, -29 },
  { 2757, 19, 29, 23, 3, -29 },
  { 2826, 31, 29, 39, 4, -29 },
  { 2939, 26, 29, 33, 4, -29 },
  { 3034, 28, 30, 32, 2, -30 },
  { 3139, 21, 29, 25, 3, -29 },
  { 3216, 28, 37, 32, 2, -30 },
  { 3346, 24, 29, 27, 3, -29 },
  { 3433, 19, 30, 23, 2, -30 },
  { 3505, 22, 29, 24, 1, -29 },
  { 3585, 25, 29, 31, 3, -29 },
  { 3676, 27, 29, 27, 0, -29 },
  { 3774, 40, 29, 40, 0, -29 },
  { 3919, 27, 29, 27, 0, -29 },
  { 4017, 26, 29, 26, 0, -29 },
  { 4112, 22, 29, 24, 1, -29 },
  { 4192, 10, 35, 14, 3, -29 },
  { 4236, 17, 30, 17, 0, -30 },
  { 4300, 10, 35, 14, 1, -29 },
  { 4344, 22, 19, 23, 1, -29 },
  { 4397, 17, 2, 17, 0, 4 },
  { 4402, 11, 6, 15, 2, -31 },
  { 4411, 20, 23, 25, 2, -23 },
  { 4469, 21, 31, 26, 3, -31 },
  { 4551, 18, 23, 21, 2, -23 },
  { 4603, 21, 31, 26, 2, -31 },
  { 4685, 21, 23, 24, 2, -23 },
  { 4746, 17, 31, 16, 1, -31 },
  { 4812, 21, 33, 26, 2, -23 },
  { 4899, 21, 31, 27, 3, -31 },
  { 4981, 7, 31, 12, 3, -31 },
  { 5009, 12, 41, 12, -2, -31 },
  { 5071, 22, 31, 25, 3, -31 },
  { 5157, 6, 31, 12, 3, -31 },
  { 5181, 34, 23, 40, 3, -23 },
  { 5279, 21, 23, 27, 3, -23 },
  { 5340, 22, 23, 26, 2, -23 },
  { 5404, 21, 33, 26, 3, -23 },
  { 5491, 21, 33, 26, 2, -23 },
  { 5578, 15, 23, 18, 3, -23 },
  { 5622, 17, 23, 21, 2, -23 },
  { 5671, 15, 27, 18, 1, -27 },
  { 5722, 21, 22, 27, 3, -22 },
  { 5780, 23, 22, 23, 0, -22 },
  { 5844, 35, 22, 35, 0, -22 },
  { 5941, 24, 22, 24, 0, -22 },
  { 6007, 23, 32, 23, 0, -22 },
  { 6099, 18, 22, 20, 1, -22 },
  { 6149, 14, 35, 16, 1, -29 },
  { 6211, 4, 40, 23, 9, -31 },
  { 6231, 14, 35, 16, 2, -29 },
  { 6293, 20, 7, 23, 2, -18 },
};

const GFXfont NotoSans_Bold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold41pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_BOLD41PT7B_H_
