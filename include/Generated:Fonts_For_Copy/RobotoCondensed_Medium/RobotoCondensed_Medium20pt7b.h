#ifndef _ROBOTOCONDENSED_MEDIUM20PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x60, 0x3E, 0xC0, 0xDE, 0xF5, 0x29, 0x00, 0x1B,
  0x0D, 0x86, 0xC2, 0x67, 0xFB, 0xFC, 0xC8, 0x6C, 0x36, 0x7F, 0xFF, 0xE4,
  0x86, 0x43, 0x60, 0x08, 0x08, 0x3C, 0x7E, 0x67, 0xE3, 0x63, 0x70, 0x7C,
  0x1E, 0x07, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x1B, 0x03,
  0x26, 0x64, 0x8C, 0xB1, 0xB4, 0x1D, 0x00, 0x6E, 0x0B, 0x63, 0x4C, 0x49,
  0x99, 0x30, 0x36, 0x03, 0x80, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x66, 0x1F,
  0x03, 0x81, 0xE6, 0xFD, 0xB3, 0xEC, 0x7B, 0x9C, 0x7F, 0x8F, 0x70, 0xFE,
  0x80, 0x08, 0xCC, 0x46, 0x31, 0x98, 0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x61,
  0x0C, 0x30, 0x80, 0x8C, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x33, 0x33, 0x66,
  0xCC, 0x80, 0x08, 0x04, 0x12, 0x5F, 0xF1, 0xC1, 0xA0, 0xD8, 0x44, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xB6, 0x80,
  0xFF, 0x5D, 0x80, 0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x18, 0x30, 0x60,
  0x83, 0x06, 0x08, 0x30, 0x00, 0x3C, 0x7E, 0x66, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x7E, 0x3C, 0x1B, 0xFF, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0x06, 0x06, 0x0C,
  0x1C, 0x38, 0x30, 0x60, 0xFF, 0xFF, 0x3C, 0x7E, 0xE7, 0xC7, 0x07, 0x06,
  0x3E, 0x3E, 0x07, 0x03, 0xC3, 0xE7, 0x7E, 0x3C, 0x0E, 0x0E, 0x1E, 0x1E,
  0x36, 0x36, 0x66, 0x66, 0xC6, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x7F, 0x7F,
  0x60, 0x60, 0x60, 0x7C, 0x7E, 0x67, 0x03, 0x03, 0xC3, 0xE7, 0x7E, 0x3C,
  0x0C, 0x3C, 0x70, 0x60, 0x60, 0xDE, 0xFE, 0xE7, 0xC3, 0xC3, 0xE3, 0x67,
  0x7E, 0x3C, 0xFF, 0xFF, 0x03, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x70, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0x66, 0x7E, 0x7E,
  0xE7, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x3C, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3,
  0xE7, 0x7F, 0x3B, 0x07, 0x06, 0x0E, 0x3C, 0x38, 0x5D, 0x80, 0x00, 0x5D,
  0x80, 0x5F, 0x80, 0x00, 0x1F, 0xFD, 0xA0, 0x02, 0x1C, 0xF7, 0x8C, 0x1E,
  0x0F, 0x07, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC1,
  0xE0, 0xF0, 0x63, 0xDE, 0x70, 0x80, 0x79, 0xFB, 0x3E, 0x30, 0x61, 0x87,
  0x0C, 0x30, 0x60, 0x00, 0x83, 0x06, 0x00, 0x07, 0xC0, 0x73, 0x83, 0x03,
  0x18, 0x06, 0x63, 0x99, 0x1F, 0x2C, 0xCC, 0xB3, 0x32, 0xC8, 0x8B, 0x22,
  0x2D, 0x88, 0xB2, 0x66, 0xCF, 0xD3, 0x1B, 0xC6, 0x00, 0x1C, 0x00, 0x3D,
  0x80, 0x3E, 0x00, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF0, 0x33, 0x06,
  0x61, 0xCC, 0x31, 0xC7, 0xF9, 0xFF, 0x38, 0x76, 0x07, 0xC0, 0xC0, 0xFE,
  0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1B, 0xFD, 0xFE, 0xE3, 0xF0, 0xF8, 0x7C,
  0x7F, 0xF7, 0xF0, 0x1E, 0x1F, 0xE6, 0x1B, 0x86, 0xC1, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x7E, 0x19, 0x86, 0x7F, 0x07, 0x80, 0xFC, 0x7F, 0xB8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xF7,
  0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xE6, 0x3B, 0x86, 0xE1, 0xF0,
  0x0C, 0x03, 0x1F, 0xC7, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F, 0x87, 0xC0, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x1E, 0x3F, 0xEF, 0x80,
  0xE1, 0xB8, 0xEE, 0x73, 0x98, 0xEE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x39,
  0x8E, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFD, 0x8D, 0xFC, 0x6F, 0xE3, 0x7D, 0xB3, 0xED, 0xBF, 0x6D,
  0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0xF1, 0x9C, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0xFE, 0x3E, 0xCF, 0xBB, 0xE6, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8,
  0x70, 0x1E, 0x1F, 0xE7, 0x1B, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x3E, 0x1D, 0x86, 0x7F, 0x87, 0x80, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E,
  0x1F, 0x0F, 0x8F, 0xFF, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1E,
  0x1F, 0xE6, 0x3B, 0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E,
  0x1D, 0x86, 0x7F, 0x87, 0xE0, 0x1C, 0x02, 0xFE, 0x3F, 0xCE, 0x3B, 0x86,
  0xE1, 0xB8, 0x6E, 0x3B, 0xFC, 0xFE, 0x39, 0x8E, 0x73, 0x8C, 0xE3, 0xB8,
  0x60, 0x3E, 0x3F, 0xB8, 0xD8, 0x7E, 0x03, 0x81, 0xF0, 0x3E, 0x03, 0x61,
  0xF0, 0xFC, 0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x77, 0xF1,
  0xF0, 0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xCC,
  0x1B, 0x83, 0x60, 0x7C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xC3, 0x1F, 0x1C,
  0x6C, 0x71, 0xB1, 0xC6, 0xE7, 0x99, 0xB6, 0xE6, 0xDB, 0x1B, 0x6C, 0x6C,
  0xB1, 0xB3, 0xC3, 0x8F, 0x0E, 0x38, 0x38, 0xE0, 0xE1, 0x80, 0x70, 0xCE,
  0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E, 0x03, 0x80, 0x70, 0x1F, 0x03, 0x60,
  0xEE, 0x18, 0xC7, 0x1C, 0xC1, 0x80, 0xE0, 0xD8, 0x77, 0x18, 0xC6, 0x3B,
  0x06, 0xC1, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18,
  0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xF0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0xF0, 0x30, 0xC7, 0x9E, 0xDB, 0x3C, 0xC0, 0xFF, 0xFF, 0xE6,
  0x30, 0x3C, 0x7E, 0xE6, 0x06, 0x3E, 0x76, 0xC6, 0xC6, 0xC6, 0xFE, 0x77,
  0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE7, 0xFE, 0xDE, 0x3C, 0x7E, 0xE6, 0xC7, 0xC0, 0xC0, 0xC0, 0xC7, 0xE6,
  0x7E, 0x3C, 0x07, 0x07, 0x07, 0x07, 0x7F, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0x7F, 0x7B, 0x3C, 0x7E, 0xE6, 0xC3, 0xFF, 0xFF, 0xC0,
  0xC0, 0xE2, 0x7F, 0x3C, 0x3B, 0xD8, 0xCF, 0xFD, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x80, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F,
  0x3B, 0x03, 0x47, 0x7E, 0x3C, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x5F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x27, 0x60, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0xEC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCE, 0xCC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC,
  0xCE, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xDC, 0xF7, 0xFF,
  0xB9, 0xCF, 0x8E, 0x7C, 0x73, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7, 0xC7, 0x3E,
  0x39, 0xF1, 0xCE, 0xDC, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E,
  0x3C, 0xDC, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0xFE, 0xDC,
  0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xE7, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xDF, 0xF9, 0x8C, 0x63, 0x18,
  0xC6, 0x30, 0x3C, 0xFF, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC7, 0xFD, 0xF0,
  0x31, 0xBF, 0xF3, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0x80, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7F, 0x7F, 0xE3, 0x63, 0x63, 0x66,
  0x36, 0x36, 0x36, 0x3C, 0x1C, 0x1C, 0x1C, 0x66, 0x36, 0x73, 0x67, 0x36,
  0x73, 0x6D, 0x63, 0xDE, 0x3D, 0xE3, 0xDE, 0x38, 0xE3, 0x8C, 0x18, 0xC0,
  0x63, 0x3B, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0x70, 0x7C, 0x36, 0x3B, 0x98,
  0xC0, 0xE3, 0x63, 0x67, 0x76, 0x36, 0x36, 0x3E, 0x3C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x70, 0x70, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x30, 0xE1,
  0xFF, 0xF8, 0x11, 0x9C, 0xC6, 0x31, 0x8C, 0x66, 0x30, 0xC6, 0x31, 0x8C,
  0x63, 0x8C, 0x20, 0xFF, 0xFF, 0x80, 0x43, 0x1C, 0x63, 0x18, 0xC6, 0x30,
  0xC6, 0x63, 0x18, 0xC6, 0x33, 0x98, 0x80, 0x70, 0xBC, 0xF3, 0xF8, 0xE0,
};

const GFXglyph RobotoCondensed_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 5, 5, 6, 1, -15 },
  { 11, 9, 14, 11, 1, -14 },
  { 27, 8, 18, 10, 1, -16 },
  { 45, 11, 14, 13, 1, -14 },
  { 65, 10, 14, 11, 1, -14 },
  { 83, 2, 5, 3, 1, -15 },
  { 85, 5, 21, 6, 1, -16 },
  { 99, 4, 21, 6, 1, -16 },
  { 110, 9, 8, 9, 0, -14 },
  { 119, 8, 10, 10, 1, -12 },
  { 129, 3, 6, 4, 0, -2 },
  { 132, 4, 2, 6, 1, -7 },
  { 133, 3, 3, 6, 1, -3 },
  { 135, 7, 15, 7, 0, -14 },
  { 149, 8, 14, 10, 1, -14 },
  { 163, 5, 14, 10, 2, -14 },
  { 172, 8, 14, 10, 1, -14 },
  { 186, 8, 14, 10, 1, -14 },
  { 200, 8, 14, 10, 1, -14 },
  { 214, 8, 14, 10, 1, -14 },
  { 228, 8, 14, 10, 1, -14 },
  { 242, 8, 14, 10, 1, -14 },
  { 256, 8, 14, 10, 1, -14 },
  { 270, 8, 14, 10, 1, -14 },
  { 284, 3, 11, 5, 1, -11 },
  { 289, 3, 15, 5, 1, -11 },
  { 295, 7, 9, 9, 1, -11 },
  { 303, 8, 7, 10, 1, -10 },
  { 310, 7, 9, 9, 1, -11 },
  { 318, 7, 14, 9, 1, -14 },
  { 331, 14, 18, 15, 1, -14 },
  { 363, 11, 14, 12, 0, -14 },
  { 383, 9, 14, 11, 1, -14 },
  { 399, 10, 14, 11, 1, -14 },
  { 417, 9, 14, 11, 1, -14 },
  { 433, 8, 14, 10, 1, -14 },
  { 447, 8, 14, 10, 1, -14 },
  { 461, 10, 14, 12, 1, -14 },
  { 479, 10, 14, 12, 1, -14 },
  { 497, 3, 14, 5, 1, -14 },
  { 503, 7, 14, 10, 1, -14 },
  { 516, 10, 14, 11, 1, -14 },
  { 534, 8, 14, 10, 1, -14 },
  { 548, 13, 14, 15, 1, -14 },
  { 571, 10, 14, 12, 1, -14 },
  { 589, 10, 14, 12, 1, -14 },
  { 607, 9, 14, 11, 1, -14 },
  { 623, 10, 16, 12, 1, -14 },
  { 643, 10, 14, 11, 1, -14 },
  { 661, 9, 14, 11, 1, -14 },
  { 677, 9, 14, 11, 1, -14 },
  { 693, 9, 14, 11, 1, -14 },
  { 709, 11, 14, 11, 0, -14 },
  { 729, 14, 14, 15, 1, -14 },
  { 754, 11, 14, 11, 0, -14 },
  { 774, 10, 14, 11, 0, -14 },
  { 792, 9, 14, 11, 1, -14 },
  { 808, 4, 19, 5, 1, -16 },
  { 818, 8, 15, 8, 0, -14 },
  { 833, 4, 19, 5, 0, -16 },
  { 843, 6, 7, 8, 1, -14 },
  { 849, 8, 2, 8, 0, 0 },
  { 851, 4, 3, 6, 1, -15 },
  { 853, 8, 11, 10, 1, -11 },
  { 864, 8, 15, 10, 1, -15 },
  { 879, 8, 11, 9, 1, -11 },
  { 890, 8, 15, 10, 1, -15 },
  { 905, 8, 11, 9, 1, -11 },
  { 916, 5, 15, 6, 1, -15 },
  { 926, 8, 15, 10, 1, -11 },
  { 941, 8, 15, 10, 1, -15 },
  { 956, 3, 16, 5, 1, -16 },
  { 962, 4, 20, 5, 0, -16 },
  { 972, 8, 15, 9, 1, -15 },
  { 987, 3, 15, 5, 1, -15 },
  { 993, 13, 11, 15, 1, -11 },
  { 1011, 8, 11, 10, 1, -11 },
  { 1022, 8, 11, 10, 1, -11 },
  { 1033, 8, 15, 10, 1, -11 },
  { 1048, 8, 15, 10, 1, -11 },
  { 1063, 5, 11, 6, 1, -11 },
  { 1070, 7, 11, 9, 1, -11 },
  { 1080, 5, 13, 6, 0, -13 },
  { 1089, 8, 11, 10, 1, -11 },
  { 1100, 8, 11, 9, 0, -11 },
  { 1111, 12, 11, 13, 0, -11 },
  { 1128, 9, 11, 9, 0, -11 },
  { 1141, 8, 15, 9, 0, -11 },
  { 1156, 7, 11, 9, 1, -11 },
  { 1166, 5, 20, 6, 1, -16 },
  { 1179, 1, 17, 5, 2, -14 },
  { 1182, 5, 20, 6, 0, -16 },
  { 1195, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Medium20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_MEDIUM20PT7B_H_
