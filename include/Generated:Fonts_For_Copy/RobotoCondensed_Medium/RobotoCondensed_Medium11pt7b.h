#ifndef _ROBOTOCONDENSED_MEDIUM11PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x52, 0xBE, 0xA6, 0x7A, 0x94, 0x4E, 0xB9, 0xC3, 0x99,
  0xE4, 0xC3, 0x4D, 0x38, 0x39, 0x55, 0x46, 0x31, 0x45, 0x0C, 0x77, 0x64,
  0x9F, 0xE0, 0x5A, 0xAA, 0x94, 0x89, 0x12, 0x49, 0x4A, 0x00, 0x25, 0x5C,
  0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x58, 0xE0, 0x80, 0x22, 0x22, 0x44,
  0x48, 0x80, 0xEB, 0x99, 0x99, 0xBE, 0x7D, 0xB6, 0xDB, 0x72, 0xC2, 0x31,
  0x11, 0x0F, 0x72, 0xC6, 0x61, 0x87, 0x6E, 0x11, 0x8C, 0xA5, 0x7C, 0x42,
  0xF8, 0x8E, 0x11, 0x9E, 0x6C, 0x8E, 0x99, 0x96, 0xF8, 0x44, 0x23, 0x10,
  0x8C, 0xEB, 0xB6, 0xB9, 0xBE, 0xEB, 0x9B, 0xF3, 0x2C, 0x84, 0x40, 0x16,
  0x17, 0xC7, 0x10, 0xF0, 0xF0, 0x8E, 0x3E, 0x80, 0x7D, 0x11, 0x22, 0x02,
  0x1C, 0x22, 0x5D, 0x55, 0x55, 0xA5, 0x55, 0x5E, 0x40, 0x3C, 0x10, 0xC3,
  0x8A, 0x49, 0xF4, 0x71, 0xF4, 0xA5, 0xC9, 0x4E, 0x5E, 0x74, 0xE3, 0x08,
  0x46, 0x6E, 0xE4, 0xA7, 0x39, 0xCE, 0x5C, 0xF8, 0x8F, 0x88, 0x8F, 0xF8,
  0x88, 0xF8, 0x88, 0x74, 0xE3, 0x0B, 0xC6, 0x2E, 0x8C, 0x63, 0xF8, 0xC6,
  0x31, 0xFF, 0x18, 0xC6, 0x31, 0x8F, 0x6E, 0x9D, 0xA9, 0xCE, 0x5A, 0x53,
  0x88, 0x88, 0x88, 0x8F, 0xC7, 0x8F, 0x3E, 0x7A, 0xF6, 0xED, 0xCB, 0x8E,
  0x73, 0x5A, 0xCE, 0x71, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0xF4, 0xE7, 0x3F,
  0x42, 0x10, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0x08, 0xF4, 0xA7, 0x2F, 0x5A,
  0x53, 0x7A, 0x50, 0xE1, 0x87, 0x2F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x9C, 0xE7, 0x39, 0xCE, 0x5E, 0xC5, 0x34, 0x92, 0x68, 0xC3, 0x0C, 0xC9,
  0x59, 0x5B, 0x5A, 0x56, 0x56, 0x26, 0x26, 0x4D, 0x23, 0x8C, 0x30, 0xE4,
  0x93, 0xCD, 0x25, 0x8C, 0x30, 0xC3, 0x0C, 0xF8, 0x44, 0x62, 0x31, 0x1F,
  0xEA, 0xAA, 0xAC, 0xC4, 0x44, 0x22, 0x23, 0x10, 0xD5, 0x55, 0x5C, 0x26,
  0x6D, 0xF0, 0x4C, 0x72, 0xDE, 0xB5, 0xBC, 0x88, 0x8E, 0x99, 0x99, 0xE0,
  0x72, 0xF1, 0x85, 0xB8, 0x08, 0x42, 0xD5, 0xE7, 0x2B, 0x68, 0x72, 0x7F,
  0x84, 0x38, 0x29, 0x74, 0x92, 0x40, 0x7A, 0x73, 0x94, 0xBC, 0x6E, 0x88,
  0x8E, 0xBB, 0xBB, 0xB0, 0xBF, 0x45, 0x55, 0x70, 0x88, 0x8B, 0xEC, 0xEA,
  0xB0, 0xFF, 0x80, 0xED, 0x6E, 0xDD, 0xBB, 0x76, 0xC0, 0xEB, 0xBB, 0xBB,
  0x72, 0x73, 0x94, 0xB8, 0xE9, 0x99, 0x9E, 0x88, 0x6A, 0xF3, 0x94, 0xBC,
  0x21, 0xEA, 0xA0, 0x72, 0x98, 0x6D, 0xB8, 0x5D, 0x24, 0x98, 0xBB, 0xBB,
  0xBD, 0xD2, 0x94, 0xA6, 0x10, 0xD2, 0xA9, 0xB3, 0x66, 0xCD, 0x80, 0x52,
  0x88, 0xC5, 0x68, 0xD2, 0x94, 0xE6, 0x10, 0x88, 0xF1, 0x26, 0x4F, 0x29,
  0x25, 0x92, 0x48, 0x80, 0xFF, 0x80, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xCD,
  0x80,
};

const GFXglyph RobotoCondensed_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 5, 8, 6, 1, -8 },
  { 8, 4, 10, 6, 1, -9 },
  { 13, 6, 8, 7, 1, -8 },
  { 19, 6, 8, 6, 0, -8 },
  { 25, 1, 3, 2, 0, -8 },
  { 26, 2, 11, 4, 1, -9 },
  { 29, 3, 11, 4, 0, -9 },
  { 34, 5, 5, 5, 0, -8 },
  { 38, 5, 5, 5, 0, -6 },
  { 42, 2, 3, 2, 0, -1 },
  { 43, 3, 1, 3, 0, -4 },
  { 44, 1, 1, 3, 1, -1 },
  { 45, 4, 9, 4, 0, -8 },
  { 50, 4, 8, 6, 1, -8 },
  { 54, 3, 8, 6, 1, -8 },
  { 57, 5, 8, 6, 0, -8 },
  { 62, 5, 8, 6, 0, -8 },
  { 67, 5, 8, 6, 0, -8 },
  { 72, 4, 8, 6, 1, -8 },
  { 76, 4, 8, 6, 1, -8 },
  { 80, 5, 8, 6, 0, -8 },
  { 85, 4, 8, 6, 1, -8 },
  { 89, 4, 8, 6, 1, -8 },
  { 93, 1, 6, 3, 1, -6 },
  { 94, 2, 8, 3, 0, -6 },
  { 96, 4, 5, 5, 0, -6 },
  { 99, 4, 3, 5, 1, -5 },
  { 101, 4, 5, 5, 1, -6 },
  { 104, 4, 8, 5, 0, -8 },
  { 108, 8, 10, 8, 0, -8 },
  { 118, 6, 8, 6, 0, -8 },
  { 124, 5, 8, 6, 1, -8 },
  { 129, 5, 8, 6, 1, -8 },
  { 134, 5, 8, 6, 1, -8 },
  { 139, 4, 8, 5, 1, -8 },
  { 143, 4, 8, 5, 1, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 5, 8, 7, 1, -8 },
  { 157, 1, 8, 3, 1, -8 },
  { 158, 5, 8, 5, 0, -8 },
  { 163, 5, 8, 6, 1, -8 },
  { 168, 4, 8, 5, 1, -8 },
  { 172, 7, 8, 8, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 6, 1, -8 },
  { 194, 5, 9, 7, 1, -8 },
  { 200, 5, 8, 6, 1, -8 },
  { 205, 5, 8, 6, 0, -8 },
  { 210, 6, 8, 6, 0, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 8, 8, 8, 0, -8 },
  { 235, 6, 8, 6, 0, -8 },
  { 241, 6, 8, 6, 0, -8 },
  { 247, 5, 8, 6, 0, -8 },
  { 252, 2, 11, 3, 1, -9 },
  { 255, 4, 9, 4, 0, -8 },
  { 260, 2, 11, 3, 0, -9 },
  { 263, 4, 4, 4, 0, -8 },
  { 265, 4, 1, 4, 0, 0 },
  { 266, 3, 2, 4, 0, -9 },
  { 267, 5, 6, 5, 0, -6 },
  { 271, 4, 9, 5, 1, -9 },
  { 276, 5, 6, 5, 0, -6 },
  { 280, 5, 9, 5, 0, -9 },
  { 286, 5, 6, 5, 0, -6 },
  { 290, 3, 9, 4, 0, -9 },
  { 294, 5, 8, 5, 0, -6 },
  { 299, 4, 9, 5, 1, -9 },
  { 304, 1, 8, 3, 1, -8 },
  { 305, 2, 10, 3, 0, -8 },
  { 308, 4, 9, 5, 1, -9 },
  { 313, 1, 9, 3, 1, -9 },
  { 315, 7, 6, 8, 1, -6 },
  { 321, 4, 6, 5, 1, -6 },
  { 324, 5, 6, 6, 0, -6 },
  { 328, 4, 8, 5, 1, -6 },
  { 332, 5, 8, 5, 0, -6 },
  { 337, 2, 6, 4, 1, -6 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 3, 7, 3, 0, -7 },
  { 346, 4, 6, 5, 1, -6 },
  { 349, 5, 6, 5, 0, -6 },
  { 353, 7, 6, 7, 0, -6 },
  { 359, 5, 6, 5, 0, -6 },
  { 363, 5, 8, 5, 0, -6 },
  { 368, 4, 6, 5, 0, -6 },
  { 371, 3, 11, 3, 0, -9 },
  { 376, 1, 9, 3, 1, -8 },
  { 378, 3, 11, 3, 0, -9 },
  { 383, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Medium11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_MEDIUM11PT7B_H_
