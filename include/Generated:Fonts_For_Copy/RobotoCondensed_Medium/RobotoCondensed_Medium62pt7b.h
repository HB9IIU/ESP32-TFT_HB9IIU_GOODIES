#ifndef _ROBOTOCONDENSED_MEDIUM62PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF,
  0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xE7, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x1C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x1E, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x3E, 0x07, 0xC3,
  0xC0, 0x0F, 0x81, 0xF1, 0xF0, 0x03, 0xF0, 0x7C, 0x78, 0x00, 0x7C, 0x3E,
  0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x7F,
  0xE3, 0xE0, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x40, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0x3E, 0x3F,
  0xFC, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x07, 0xCF, 0xC7, 0xE0, 0x01, 0xE3,
  0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x1E, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0x1F,
  0x0F, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xC0, 0x3F, 0x1F, 0x80, 0x10, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x81, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0xFE,
  0xFF, 0x07, 0xE3, 0xFC, 0xFF, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x1F, 0xC1,
  0xFE, 0x7E, 0x3F, 0x81, 0xFE, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0x87, 0xF0, 0x07,
  0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x40, 0x01, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x78,
  0x04, 0x7C, 0x1E, 0x0F, 0x9F, 0xC7, 0x8F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC1, 0xF0, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x3F, 0x1F, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC,
  0xFC, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8,
  0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x03, 0xFC,
  0x7F, 0xEF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x03, 0xFE, 0x1E, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xEF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0x0F, 0xFB, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xF3, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0x7F, 0x07, 0xFE, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xF9,
  0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0F,
  0xCF, 0xF7, 0xFB, 0xFF, 0xFE, 0x7F, 0x3F, 0x02, 0x00, 0x06, 0x07, 0xE3,
  0xFD, 0xFF, 0x7F, 0xCF, 0xF3, 0xF8, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x3F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xFF, 0x00, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0xFF, 0xFC,
  0x0F, 0x8F, 0x80, 0x7F, 0xFF, 0x01, 0xE7, 0xE0, 0x3F, 0x87, 0xC0, 0x79,
  0xF0, 0x0F, 0xC1, 0xF0, 0x1E, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xDF, 0x01,
  0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0x01,
  0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xF8,
  0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0xF8, 0x1F, 0x00, 0xF8,
  0x07, 0xBE, 0x07, 0xE0, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x0F, 0x80, 0xFB,
  0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x07,
  0xF0, 0xFE, 0x07, 0xC7, 0xC0, 0xFE, 0x7F, 0xC3, 0xE1, 0xF0, 0x3F, 0xFD,
  0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0x7F, 0xFC, 0x1F, 0x01, 0xFF, 0x8F, 0xFE,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xE7, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFD, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFE, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFF, 0x3F,
  0x80, 0x0F, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x0F,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0x87, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xFE, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0x7E,
  0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0xFE, 0xFF, 0xFD, 0xFC, 0x01, 0xF9,
  0xFF, 0xF9, 0xF8, 0x03, 0xF3, 0xFF, 0xF3, 0xF0, 0x07, 0xE7, 0xFF, 0xE7,
  0xF0, 0x1F, 0x8F, 0xFF, 0xCF, 0xE0, 0x3F, 0x1F, 0xFF, 0x8F, 0xC0, 0x7E,
  0x3F, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0xF0, 0xFF, 0xFC,
  0x3F, 0x07, 0xE1, 0xFF, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x3F,
  0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC, 0x1F, 0xFF,
  0x83, 0xFB, 0xF0, 0x3F, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xEF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x7F, 0xFE, 0x7F, 0x01, 0xFF,
  0xF9, 0xFC, 0x07, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83,
  0xF8, 0x7F, 0xFE, 0x07, 0xF1, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF, 0xE0, 0x3F,
  0x9F, 0xFF, 0x80, 0xFE, 0x7F, 0xFE, 0x01, 0xFD, 0xFF, 0xF8, 0x07, 0xF7,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x7F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x23, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3E, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xDF, 0x81, 0xF8, 0x1F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F, 0x07,
  0xE7, 0xC1, 0xFC, 0x0F, 0xE0, 0xF8, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x1F,
  0x87, 0xF0, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x7E, 0x3F,
  0x80, 0x7F, 0x1F, 0x87, 0xC7, 0xF0, 0x0F, 0xE3, 0xE0, 0xFC, 0xFE, 0x00,
  0xFC, 0xFC, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x03, 0xFB,
  0xF0, 0x3E, 0x7E, 0x00, 0x7F, 0x7C, 0x07, 0xDF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x0F, 0x9F, 0x01, 0xF9, 0xF0, 0x1F,
  0x1F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0xCF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFE, 0x1F, 0xFE,
  0xFF, 0x07, 0xF8, 0x7F, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0xC0, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8, 0xFC, 0xFF,
  0xF0, 0xFC, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xF7, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFB, 0xFC, 0x03,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x7F, 0xC0, 0x3C, 0x3F, 0xF3,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x8F, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0x9F, 0xC0,
  0x04, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x10, 0x01, 0xFE, 0x1C, 0x00, 0xFF, 0x0F, 0x80, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x1F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF9, 0xFC, 0x07,
  0xFC, 0xFE, 0x07, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC3,
  0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80,
  0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xFB, 0xF8,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xF3, 0xFF, 0xC3, 0xFF, 0xC7, 0xEF,
  0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xC1, 0xFE, 0xFE,
  0x01, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE0,
  0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0xFF, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xCF, 0xF0, 0x1F, 0xE3, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFE, 0xFF, 0xF0, 0xFE, 0x7F, 0xC0, 0xFE, 0x04, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x0F, 0xC1, 0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFE, 0x7F, 0x81, 0xFF,
  0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF3, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0x1F, 0xC0, 0x04, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x09, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x10, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x7F, 0x07, 0xFC, 0x7F, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0x07, 0xF7,
  0xF0, 0x1F, 0xE0, 0x3F, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8,
  0x1F, 0xC7, 0xF0, 0x7F, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x07, 0xF1, 0xFC,
  0x1F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0xFE, 0x1F,
  0xC1, 0xF8, 0x7F, 0xF8, 0xFE, 0x0F, 0xE3, 0xEF, 0xC7, 0xE0, 0x3F, 0x1F,
  0x7E, 0x3F, 0x01, 0xF9, 0xF9, 0xF1, 0xF8, 0x0F, 0xCF, 0xCF, 0xDF, 0xC0,
  0x7E, 0x7C, 0x7E, 0xFE, 0x03, 0xFB, 0xE1, 0xF7, 0xE0, 0x0F, 0xFF, 0x0F,
  0xBF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xF3, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xC7, 0xFF,
  0x80, 0x3E, 0x3F, 0xFE, 0x03, 0xF3, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0xE0,
  0xFD, 0xFC, 0x7F, 0x9F, 0xCF, 0xC1, 0xFF, 0xFE, 0x7C, 0x07, 0xFF, 0xE3,
  0xE0, 0x1F, 0xFF, 0x3F, 0x00, 0x7F, 0xF1, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 14, 16, 20, 3, -47 },
  { 74, 28, 44, 33, 3, -44 },
  { 228, 25, 58, 31, 3, -51 },
  { 410, 34, 46, 39, 3, -45 },
  { 606, 31, 46, 35, 3, -45 },
  { 785, 6, 16, 10, 2, -47 },
  { 797, 14, 63, 20, 4, -49 },
  { 908, 14, 63, 20, 2, -49 },
  { 1019, 26, 26, 27, 1, -44 },
  { 1104, 26, 32, 30, 2, -37 },
  { 1208, 10, 17, 14, 1, -7 },
  { 1230, 13, 6, 19, 3, -22 },
  { 1240, 9, 9, 17, 4, -8 },
  { 1251, 20, 48, 22, 0, -44 },
  { 1371, 25, 46, 31, 3, -45 },
  { 1515, 16, 44, 31, 5, -44 },
  { 1603, 26, 45, 31, 3, -45 },
  { 1750, 25, 46, 31, 2, -45 },
  { 1894, 27, 44, 31, 2, -44 },
  { 2043, 24, 45, 31, 4, -44 },
  { 2178, 25, 45, 31, 3, -44 },
  { 2319, 26, 44, 31, 2, -44 },
  { 2462, 25, 46, 31, 3, -45 },
  { 2606, 24, 45, 31, 3, -45 },
  { 2741, 9, 35, 16, 4, -34 },
  { 2781, 10, 44, 14, 2, -34 },
  { 2836, 22, 28, 28, 2, -33 },
  { 2913, 22, 19, 30, 4, -30 },
  { 2966, 22, 28, 28, 4, -33 },
  { 3043, 23, 46, 27, 2, -45 },
  { 3176, 42, 57, 48, 3, -43 },
  { 3476, 35, 44, 36, 1, -44 },
  { 3669, 27, 44, 34, 4, -44 },
  { 3818, 30, 46, 35, 3, -45 },
  { 3991, 28, 44, 35, 4, -44 },
  { 4145, 25, 44, 31, 4, -44 },
  { 4283, 24, 44, 30, 4, -44 },
  { 4415, 30, 46, 36, 3, -45 },
  { 4588, 30, 44, 38, 4, -44 },
  { 4753, 8, 44, 16, 4, -44 },
  { 4797, 24, 45, 30, 2, -44 },
  { 4932, 30, 44, 34, 4, -44 },
  { 5097, 24, 44, 30, 4, -44 },
  { 5229, 39, 44, 47, 4, -44 },
  { 5444, 30, 44, 38, 4, -44 },
  { 5609, 31, 46, 37, 3, -45 },
  { 5788, 28, 44, 35, 4, -44 },
  { 5942, 31, 53, 37, 3, -45 },
  { 6148, 29, 44, 34, 4, -44 },
  { 6308, 28, 46, 33, 2, -45 },
  { 6469, 29, 44, 33, 2, -44 },
  { 6629, 28, 45, 35, 4, -44 },
  { 6787, 33, 44, 35, 1, -44 },
  { 6969, 43, 44, 47, 2, -44 },
  { 7206, 31, 44, 34, 2, -44 },
  { 7377, 31, 44, 33, 1, -44 },
  { 7548, 27, 44, 33, 3, -44 },
  { 7697, 11, 61, 16, 4, -51 },
  { 7781, 22, 48, 23, 1, -44 },
  { 7913, 11, 61, 16, 1, -51 },
  { 7997, 20, 22, 24, 2, -44 },
  { 8052, 23, 6, 25, 1, 0 },
  { 8070, 14, 9, 20, 2, -46 },
  { 8086, 24, 35, 29, 3, -34 },
  { 8191, 24, 48, 31, 4, -47 },
  { 8335, 24, 35, 29, 3, -34 },
  { 8440, 25, 48, 31, 2, -47 },
  { 8590, 24, 35, 29, 3, -34 },
  { 8695, 17, 48, 20, 2, -48 },
  { 8797, 25, 47, 31, 2, -34 },
  { 8944, 24, 47, 30, 3, -47 },
  { 9085, 7, 46, 15, 4, -46 },
  { 9126, 12, 59, 15, -1, -46 },
  { 9215, 25, 47, 29, 4, -47 },
  { 9362, 7, 47, 15, 4, -47 },
  { 9404, 39, 34, 46, 4, -34 },
  { 9570, 24, 34, 30, 3, -34 },
  { 9672, 25, 35, 31, 3, -34 },
  { 9782, 24, 47, 31, 4, -34 },
  { 9923, 25, 47, 31, 2, -34 },
  { 10070, 15, 34, 20, 4, -34 },
  { 10134, 24, 35, 28, 2, -34 },
  { 10239, 16, 42, 19, 1, -41 },
  { 10323, 24, 34, 30, 3, -33 },
  { 10425, 25, 33, 27, 1, -33 },
  { 10529, 37, 33, 40, 1, -33 },
  { 10682, 25, 33, 28, 1, -33 },
  { 10786, 25, 46, 27, 1, -33 },
  { 10930, 22, 33, 28, 3, -33 },
  { 11021, 15, 59, 19, 2, -48 },
  { 11132, 5, 52, 15, 5, -44 },
  { 11165, 16, 59, 19, 1, -48 },
  { 11283, 29, 13, 35, 3, -25 },
};

const GFXfont RobotoCondensed_Medium62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_MEDIUM62PT7B_H_
