#ifndef _ROBOTOCONDENSED_MEDIUM29PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x06, 0xFF, 0x60,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0x80, 0x07, 0x30, 0x18, 0xC0, 0x63,
  0x01, 0x9C, 0x06, 0x70, 0x19, 0x87, 0xFF, 0xDF, 0xFF, 0x0C, 0x60, 0x31,
  0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC3, 0xFF, 0xEF, 0xFF, 0x86, 0x30, 0x19,
  0xC0, 0x67, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x80, 0x03, 0x00, 0x30, 0x03,
  0x00, 0xF8, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x8F, 0x70, 0x77, 0x07, 0x78,
  0x03, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xFF, 0x07, 0x70,
  0x77, 0x07, 0x78, 0xF7, 0xFE, 0x3F, 0xE0, 0xF8, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x67, 0x10, 0xE3, 0x18, 0xE3, 0x38, 0xE3,
  0x30, 0xE3, 0x70, 0x67, 0x60, 0x7E, 0xC0, 0x3C, 0xC0, 0x01, 0x80, 0x01,
  0x9C, 0x03, 0x7E, 0x03, 0x77, 0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C,
  0x63, 0x08, 0x77, 0x00, 0x7E, 0x00, 0x1C, 0x0F, 0x80, 0x3F, 0x80, 0xFF,
  0x01, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1F, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0xE7, 0x79, 0xDE, 0x7B, 0xBC, 0x7E, 0x78,
  0xFC, 0xF0, 0xF8, 0xE1, 0xF1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF9, 0xE0, 0xFF,
  0xFF, 0xF0, 0x04, 0x31, 0xC6, 0x38, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87, 0x1C, 0x30, 0xE1, 0x87, 0x0C,
  0x10, 0x81, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x61,
  0xC7, 0x0C, 0x10, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x27, 0xF7,
  0x7F, 0xFC, 0x3E, 0x01, 0xF0, 0x1D, 0x80, 0xCE, 0x0E, 0x38, 0x20, 0x80,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x39,
  0xCE, 0x73, 0xB9, 0xCC, 0xFF, 0xFF, 0xF8, 0x6F, 0xF6, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0x0F,
  0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xF7, 0x0F, 0x70, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x0F, 0x70,
  0xF7, 0x8E, 0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x03, 0x0F, 0x7F, 0xFF, 0xFF,
  0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF,
  0x0F, 0xE0, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x7E, 0x07,
  0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xBC, 0x1D, 0xE1, 0xCF,
  0x0E, 0x78, 0xE3, 0xC7, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x78, 0xFF, 0xDF, 0xF9, 0x87, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0x1F, 0xC1, 0xF0,
  0x07, 0x83, 0xF0, 0xFE, 0x3E, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x78, 0xFF,
  0xDF, 0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE,
  0x3D, 0xFF, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0E,
  0xF1, 0xCF, 0xF0, 0xFC, 0x3F, 0xCF, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE1,
  0xFE, 0x3F, 0xFF, 0x3F, 0xC1, 0xF0, 0x0F, 0x03, 0xFC, 0x3F, 0xC7, 0x9E,
  0x70, 0xEF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x77, 0x0F, 0x78, 0xF7, 0xFF,
  0x3F, 0xF1, 0xEE, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x1F, 0x81, 0xF0,
  0x1C, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0x73, 0x9E,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0xB9, 0xC4, 0x00,
  0x00, 0x40, 0x70, 0x7C, 0x3F, 0x3F, 0x3F, 0x0F, 0x03, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x0F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x3C, 0x0F, 0x0F, 0xCF, 0xCF, 0xC3, 0xC0, 0xE0, 0x20, 0x00,
  0x1F, 0x1F, 0xEF, 0xFF, 0xC7, 0xE1, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC1,
  0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x03, 0x01, 0xE0,
  0x78, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x07, 0x80, 0xE0,
  0x1C, 0x1C, 0x00, 0xC3, 0x80, 0x06, 0x30, 0x78, 0x67, 0x0F, 0xE6, 0x61,
  0xCE, 0x36, 0x18, 0xC3, 0x63, 0x8C, 0x3E, 0x30, 0xC3, 0xE3, 0x0C, 0x3E,
  0x30, 0xC3, 0xE7, 0x0C, 0x3E, 0x71, 0xC7, 0xE3, 0x1C, 0x66, 0x3B, 0xCE,
  0x63, 0xFF, 0xC7, 0x1C, 0x78, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xF0, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xC7, 0x81, 0xC1, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x38, 0x0E, 0x1C, 0x07, 0x9E, 0x03,
  0xCE, 0x00, 0xE7, 0x00, 0x70, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF,
  0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xBF, 0xFD,
  0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0xFC, 0x07, 0xF0, 0x7B, 0x83, 0xDF, 0xFC, 0x7F,
  0xC0, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0xBF, 0xF9, 0xFF, 0x8F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3B, 0xC3, 0xDF, 0xFE, 0x7F, 0xE0, 0xFC, 0x00, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x3D,
  0xFF, 0x3F, 0xC1, 0xF0, 0xE0, 0x7B, 0x81, 0xEE, 0x0F, 0x38, 0x78, 0xE1,
  0xE3, 0x8F, 0x0E, 0x78, 0x39, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xCF, 0x0E, 0x3C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE,
  0x07, 0xB8, 0x1E, 0xE0, 0x3C, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x77, 0xEE, 0x1D, 0xFB, 0x87, 0x7E, 0xE3, 0x9F, 0x9C,
  0xE7, 0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0, 0xC1, 0xC0, 0xF0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFB, 0x87,
  0xEF, 0x1F, 0x9C, 0x7E, 0x79, 0xF8, 0xE7, 0xE3, 0xDF, 0x87, 0x7E, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x39, 0xE1, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x78, 0x1C, 0x78, 0x78, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0E, 0xE0,
  0x77, 0x07, 0xBF, 0xF9, 0xFF, 0x8F, 0xFC, 0x71, 0xE3, 0x87, 0x1C, 0x3C,
  0xE0, 0xE7, 0x07, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0x80, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF0, 0xF7, 0x07, 0xB8, 0x1D, 0xC0, 0x0F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3B, 0xC3, 0xDF, 0xFC, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x87, 0x9F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x70, 0x0F, 0x78, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C,
  0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0xF8, 0xE7, 0x1F, 0x8E, 0x79, 0xF9,
  0xE3, 0x99, 0x9C, 0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xB9,
  0xDC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0x3D, 0xC0, 0xF7, 0x87,
  0x8E, 0x1E, 0x3C, 0xF0, 0x73, 0xC1, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xEE, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE1, 0xE7, 0x87, 0xBC, 0x0F, 0xF0, 0x3C, 0x70, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x07, 0x38, 0x0E,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC,
  0x1C, 0x0E, 0x0F, 0x87, 0xC3, 0x63, 0xB9, 0xDC, 0xC6, 0xE3, 0xF1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0x1E, 0x70, 0xE0, 0x0E, 0x1F, 0xE3, 0xFE, 0x78, 0xE7, 0x0E, 0xF0,
  0xEF, 0x0E, 0xF1, 0xE7, 0xFE, 0x7F, 0xE1, 0xEE, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xEF,
  0xFD, 0xDE, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x77, 0x0E, 0xFF, 0xCF, 0xF0,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF3,
  0xFF, 0x7F, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0xFF, 0x3F, 0x71, 0xE7, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x67, 0xFE, 0x3F, 0xE0, 0xF8, 0x0F, 0x1F,
  0x3F, 0x38, 0x38, 0x38, 0xFE, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1E, 0x73, 0xF7, 0x7F,
  0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x0F, 0x20,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3B, 0xC7, 0xFC, 0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xC0,
  0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x71, 0xC7,
  0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xBC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x7F, 0x1E, 0xE7, 0x9C, 0xE3, 0xBC, 0x7F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF8, 0xE7, 0x1C, 0xF3, 0x8E, 0x71, 0xEE, 0x1F, 0xC3,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0x0F,
  0x3F, 0xEF, 0xEF, 0xFF, 0xFB, 0xC7, 0x8F, 0xE1, 0xE1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xEF, 0x1F,
  0xFB, 0xFF, 0x78, 0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x77, 0x07, 0x78, 0xF7, 0xFE, 0x3F, 0xC0, 0xF8, 0xEF, 0x1F, 0xFB, 0xFF,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xFF, 0xBF, 0xF7, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0xFF,
  0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xEF, 0xFF, 0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x1F, 0x07, 0xF9, 0xFF, 0x38, 0xF7, 0x0E, 0xE0, 0x1F, 0x01,
  0xF8, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x7F, 0x0E, 0xFF, 0xCF, 0xF0, 0xF8,
  0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0x1F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xFF, 0xDF, 0xF9, 0xEF, 0xE0, 0xFC, 0x3F, 0x87, 0xF8, 0xE7, 0x1C,
  0xE3, 0x9C, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0x70, 0xE1, 0xC3, 0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xE7,
  0x3E, 0x73, 0x9F, 0x39, 0xDF, 0x9C, 0xEE, 0xDC, 0x77, 0x7E, 0x1F, 0x3F,
  0x0F, 0x9F, 0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE1, 0xE0, 0x70, 0xF0, 0x38,
  0x38, 0xF1, 0xFE, 0x39, 0xC7, 0x3D, 0xC3, 0xB8, 0x7E, 0x07, 0xC0, 0xF0,
  0x1F, 0x03, 0xE0, 0xFE, 0x1D, 0xC7, 0xBC, 0xE3, 0xBC, 0x7F, 0x07, 0x70,
  0x77, 0x0F, 0x78, 0xE7, 0x8E, 0x38, 0xE3, 0x9E, 0x39, 0xC3, 0xDC, 0x1D,
  0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x1C, 0x70, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xCF, 0x1C, 0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xE3, 0xC7, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x38, 0x71, 0xE3, 0x86, 0x00, 0x38, 0x3B, 0xF1, 0xFF, 0xCF, 0xCF,
  0xEC, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 7, 2, -21 },
  { 12, 7, 7, 9, 1, -22 },
  { 19, 14, 21, 16, 1, -21 },
  { 56, 12, 27, 15, 1, -24 },
  { 97, 16, 21, 18, 1, -21 },
  { 139, 15, 21, 16, 1, -21 },
  { 179, 3, 7, 5, 1, -22 },
  { 182, 6, 30, 9, 2, -23 },
  { 205, 7, 30, 9, 1, -23 },
  { 232, 13, 12, 13, 0, -21 },
  { 252, 12, 15, 14, 1, -17 },
  { 275, 5, 8, 6, 0, -3 },
  { 280, 7, 3, 9, 1, -10 },
  { 283, 4, 4, 8, 2, -4 },
  { 285, 9, 23, 10, 0, -21 },
  { 311, 12, 21, 15, 1, -21 },
  { 343, 8, 21, 15, 2, -21 },
  { 364, 12, 21, 15, 1, -21 },
  { 396, 12, 21, 15, 1, -21 },
  { 428, 13, 21, 15, 1, -21 },
  { 463, 11, 21, 15, 2, -21 },
  { 492, 11, 21, 15, 2, -21 },
  { 521, 12, 21, 15, 1, -21 },
  { 553, 11, 21, 15, 2, -21 },
  { 582, 12, 21, 15, 1, -21 },
  { 614, 4, 16, 7, 2, -16 },
  { 622, 5, 21, 7, 1, -16 },
  { 636, 10, 14, 13, 1, -16 },
  { 654, 10, 9, 14, 2, -14 },
  { 666, 10, 14, 13, 2, -16 },
  { 684, 10, 21, 13, 1, -21 },
  { 711, 20, 26, 22, 1, -20 },
  { 776, 17, 21, 17, 0, -21 },
  { 821, 13, 21, 16, 2, -21 },
  { 856, 13, 21, 17, 2, -21 },
  { 891, 13, 21, 16, 2, -21 },
  { 926, 11, 21, 14, 2, -21 },
  { 955, 11, 21, 14, 2, -21 },
  { 984, 13, 21, 17, 2, -21 },
  { 1019, 14, 21, 18, 2, -21 },
  { 1056, 4, 21, 8, 2, -21 },
  { 1067, 11, 21, 14, 1, -21 },
  { 1096, 14, 21, 16, 2, -21 },
  { 1133, 11, 21, 14, 2, -21 },
  { 1162, 18, 21, 22, 2, -21 },
  { 1210, 14, 21, 18, 2, -21 },
  { 1247, 14, 21, 17, 2, -21 },
  { 1284, 13, 21, 16, 2, -21 },
  { 1319, 15, 25, 17, 1, -21 },
  { 1366, 13, 21, 16, 2, -21 },
  { 1401, 13, 21, 15, 1, -21 },
  { 1436, 14, 21, 15, 1, -21 },
  { 1473, 13, 21, 16, 2, -21 },
  { 1508, 16, 21, 17, 0, -21 },
  { 1550, 20, 21, 22, 1, -21 },
  { 1603, 14, 21, 16, 1, -21 },
  { 1640, 15, 21, 16, 0, -21 },
  { 1680, 13, 21, 15, 1, -21 },
  { 1715, 5, 29, 7, 2, -24 },
  { 1734, 11, 23, 11, 0, -21 },
  { 1766, 6, 29, 7, 0, -24 },
  { 1788, 9, 10, 11, 1, -21 },
  { 1800, 11, 3, 12, 0, 0 },
  { 1805, 6, 4, 9, 1, -21 },
  { 1808, 12, 16, 14, 1, -16 },
  { 1832, 11, 22, 14, 2, -22 },
  { 1863, 11, 16, 13, 1, -16 },
  { 1885, 12, 22, 14, 1, -22 },
  { 1918, 12, 16, 14, 1, -16 },
  { 1942, 8, 22, 9, 1, -22 },
  { 1964, 12, 22, 14, 1, -16 },
  { 1997, 11, 22, 14, 2, -22 },
  { 2028, 3, 22, 7, 2, -22 },
  { 2037, 6, 28, 7, -1, -22 },
  { 2058, 11, 22, 14, 2, -22 },
  { 2089, 3, 22, 7, 2, -22 },
  { 2098, 18, 16, 22, 2, -16 },
  { 2134, 11, 16, 14, 2, -16 },
  { 2156, 12, 16, 14, 1, -16 },
  { 2180, 11, 22, 14, 2, -16 },
  { 2211, 12, 22, 14, 1, -16 },
  { 2244, 7, 16, 9, 2, -16 },
  { 2258, 11, 16, 13, 1, -16 },
  { 2280, 8, 19, 9, 0, -19 },
  { 2299, 11, 16, 14, 2, -16 },
  { 2321, 11, 16, 13, 1, -16 },
  { 2343, 17, 16, 19, 1, -16 },
  { 2377, 11, 16, 13, 1, -16 },
  { 2399, 12, 22, 13, 0, -16 },
  { 2432, 11, 16, 13, 1, -16 },
  { 2454, 7, 28, 9, 1, -23 },
  { 2479, 3, 25, 7, 2, -21 },
  { 2489, 7, 28, 9, 1, -23 },
  { 2514, 13, 6, 17, 2, -12 },
};

const GFXfont RobotoCondensed_Medium29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_MEDIUM29PT7B_H_
