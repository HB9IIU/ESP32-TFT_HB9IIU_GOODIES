#ifndef _ROBOTOCONDENSED_MEDIUM39PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE0, 0x00, 0x0E, 0xF7, 0xFD, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC6, 0xE3, 0x71, 0x80, 0x01, 0xC7, 0x00, 0xE1, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C,
  0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xE7, 0x82, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x38, 0xE0, 0xE1, 0xCE, 0x07, 0x9E, 0xE0,
  0x1F, 0xE7, 0x00, 0xFF, 0x70, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0xE7, 0xF0, 0x0E, 0x7F, 0x80, 0x77, 0x9E,
  0x07, 0x38, 0x70, 0x39, 0xC3, 0x83, 0x8E, 0x1C, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x1E, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xC7, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0xCF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0xF3,
  0xFF, 0x1E, 0x7B, 0xE3, 0xDF, 0x3E, 0x7B, 0xC3, 0xFF, 0x78, 0x7F, 0xCF,
  0x07, 0xF9, 0xE0, 0x7F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xDF, 0x07, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0xC0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x06, 0x01, 0x40, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x07, 0x07, 0x83, 0x80, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xE3, 0x86, 0xFF, 0xBE, 0xFF, 0xFF, 0x3F, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0x78, 0x3C, 0x38, 0x38,
  0x38, 0x00, 0x10, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0xF3, 0xCF, 0x7D, 0xE7,
  0x9E, 0xF3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF7, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C,
  0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0xC0, 0xF0,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF,
  0x87, 0xDF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xBE, 0x03, 0xDF, 0x01, 0xCF, 0x81, 0xE7, 0xC0, 0xE3,
  0xE0, 0xF1, 0xF0, 0x70, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3C, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7B, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x78,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x79,
  0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xEF, 0x07,
  0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x7D, 0xF0, 0xF1, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x3E, 0x3E, 0x78, 0x3F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xBE, 0x1F, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF,
  0x3F, 0xFE, 0x3F, 0xBC, 0x3E, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xFF, 0xF7,
  0x00, 0x3C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3,
  0xC1, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F,
  0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x03, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x38, 0x0F, 0x83, 0x8E, 0x0F, 0xF0,
  0x67, 0x03, 0xFE, 0x1D, 0xC1, 0xE3, 0x87, 0x70, 0xF0, 0xE1, 0xFC, 0x38,
  0x78, 0x7E, 0x0E, 0x1E, 0x1F, 0x87, 0x87, 0x87, 0xE1, 0xE1, 0xC1, 0xF8,
  0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1F, 0x87, 0x07, 0x07, 0xE1, 0xC1, 0xC1,
  0xF8, 0x70, 0x70, 0x6E, 0x1E, 0x3C, 0x3B, 0x87, 0x9F, 0x1E, 0xE0, 0xFF,
  0xFF, 0x3C, 0x3F, 0x3F, 0x87, 0x07, 0x87, 0xC1, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07,
  0xC7, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F,
  0xBC, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xE0,
  0x7E, 0xF0, 0x1F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x3E, 0xF0, 0x07, 0x9F, 0x01, 0xF1, 0xF0, 0x7E,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xE7, 0x80, 0xFB, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x7D, 0xE0,
  0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xF9, 0xF0, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC,
  0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x01, 0xF3, 0xC0,
  0xFC, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0,
  0x3C, 0xFC, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0x83, 0xC3,
  0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x03, 0xEF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xEF, 0xFF, 0x01, 0xEF, 0xFF, 0x81, 0xEF, 0xF7, 0x81, 0xEF,
  0xF7, 0x83, 0xCF, 0xF7, 0xC3, 0xCF, 0xF3, 0xC3, 0xDF, 0xF3, 0xC7, 0x9F,
  0xF3, 0xC7, 0x9F, 0xF1, 0xE7, 0x9F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7E, 0x1F,
  0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFD, 0xE0, 0xFF, 0x78,
  0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3, 0xCF,
  0xF0, 0xF3, 0xFC, 0x1E, 0xFF, 0x07, 0xBF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF1, 0xF0, 0x7E,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F, 0xC7, 0xC0,
  0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3D,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x03,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x78, 0x7C, 0x3C,
  0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0xC7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x3E,
  0xF0, 0x1F, 0x78, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x03, 0xDF, 0x01, 0xF7, 0xC0,
  0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x3E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xC0, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x3C,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80,
  0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x01, 0xEF, 0x80, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xE7, 0x81,
  0xF0, 0x3E, 0x78, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83,
  0xC7, 0xC3, 0xF8, 0x3C, 0x3C, 0x3F, 0x83, 0xC3, 0xC3, 0xFC, 0x7C, 0x3C,
  0x3F, 0xC7, 0xC3, 0xE3, 0xBC, 0x78, 0x3E, 0x79, 0xC7, 0x81, 0xE7, 0x9C,
  0x78, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x1E, 0xF8, 0x1E, 0x71, 0xEF, 0x01,
  0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0xEF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F, 0x83,
  0xE0, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xEF, 0x80, 0x3F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x8F, 0x80, 0x78,
  0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0xBC,
  0x39, 0xE1, 0xC7, 0x1E, 0x3C, 0xF1, 0xE7, 0x07, 0x78, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE1, 0xEF,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x7D, 0xFF, 0xF9, 0xFF,
  0xF1, 0xFD, 0xF1, 0xF3, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xF7,
  0xF8, 0xF1, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x87,
  0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x9E,
  0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFE, 0xF0,
  0xF9, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDF,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x1C, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF1,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x9E,
  0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFE, 0xF0,
  0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x90, 0x1F, 0x30, 0x3E, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0,
  0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFD, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xF0, 0x7C, 0x7F, 0xFC, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xC7, 0xF0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF,
  0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F,
  0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0xF1, 0xF1, 0xEF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF1, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xF9, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0x83,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3E, 0xFF,
  0xFD, 0xFF, 0xF9, 0xFE, 0xF0, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x07,
  0xDF, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xFE, 0x0F, 0xBC, 0x0F, 0x78, 0x3E, 0xFF, 0xFC, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFE, 0xF1, 0xF1, 0xE0, 0xF0, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x87, 0x8F, 0x1F, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x38, 0x1F, 0xE0, 0xF0, 0x3F, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1,
  0xE7, 0x87, 0xC3, 0xCF, 0x1F, 0x87, 0x9E, 0x3F, 0x8F, 0x3E, 0x7F, 0x3E,
  0x3C, 0xEE, 0x78, 0x7B, 0xDC, 0xF0, 0xF7, 0xBD, 0xE1, 0xEE, 0x7B, 0xC1,
  0xDC, 0x77, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F,
  0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x78,
  0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3E, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xE0, 0x7C, 0x3E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xE0, 0x7C, 0x0E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x1F, 0x07, 0x81, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x83, 0xC0, 0x40, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x77, 0xFC,
  0x1D, 0xFF, 0x8F, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x07, 0xF0, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 28, 10, 3, -28 },
  { 19, 9, 10, 13, 2, -29 },
  { 31, 18, 28, 21, 2, -28 },
  { 94, 16, 36, 20, 2, -32 },
  { 166, 21, 28, 25, 2, -28 },
  { 240, 19, 28, 22, 2, -28 },
  { 307, 3, 10, 7, 2, -29 },
  { 311, 9, 40, 12, 2, -31 },
  { 356, 9, 40, 13, 1, -31 },
  { 401, 16, 17, 17, 1, -28 },
  { 435, 16, 20, 19, 1, -23 },
  { 475, 6, 11, 9, 1, -4 },
  { 484, 8, 4, 12, 2, -14 },
  { 488, 5, 5, 11, 3, -5 },
  { 492, 13, 30, 14, 0, -28 },
  { 541, 16, 28, 20, 2, -28 },
  { 597, 10, 28, 20, 3, -28 },
  { 632, 16, 28, 20, 2, -28 },
  { 688, 15, 28, 20, 2, -28 },
  { 741, 17, 28, 20, 1, -28 },
  { 801, 16, 28, 20, 2, -28 },
  { 857, 16, 28, 20, 2, -28 },
  { 913, 17, 28, 20, 1, -28 },
  { 973, 15, 28, 20, 2, -28 },
  { 1026, 15, 28, 20, 2, -28 },
  { 1079, 5, 21, 10, 3, -21 },
  { 1093, 7, 28, 9, 1, -21 },
  { 1118, 14, 18, 17, 1, -21 },
  { 1150, 14, 12, 19, 3, -19 },
  { 1171, 14, 18, 18, 2, -21 },
  { 1203, 14, 28, 17, 1, -28 },
  { 1252, 26, 36, 30, 2, -27 },
  { 1369, 21, 28, 23, 1, -28 },
  { 1443, 17, 28, 22, 3, -28 },
  { 1503, 19, 28, 22, 2, -28 },
  { 1570, 17, 28, 22, 3, -28 },
  { 1630, 15, 28, 19, 3, -28 },
  { 1683, 15, 28, 19, 3, -28 },
  { 1736, 19, 28, 23, 2, -28 },
  { 1803, 18, 28, 24, 3, -28 },
  { 1866, 4, 28, 10, 3, -28 },
  { 1880, 16, 28, 19, 1, -28 },
  { 1936, 18, 28, 21, 3, -28 },
  { 1999, 15, 28, 19, 3, -28 },
  { 2052, 24, 28, 30, 3, -28 },
  { 2136, 18, 28, 24, 3, -28 },
  { 2199, 19, 28, 24, 2, -28 },
  { 2266, 17, 28, 22, 3, -28 },
  { 2326, 20, 33, 24, 2, -28 },
  { 2409, 17, 28, 21, 3, -28 },
  { 2469, 18, 28, 21, 1, -28 },
  { 2532, 19, 28, 21, 1, -28 },
  { 2599, 18, 28, 22, 2, -28 },
  { 2662, 21, 28, 22, 1, -28 },
  { 2736, 28, 28, 29, 1, -28 },
  { 2834, 20, 28, 22, 1, -28 },
  { 2904, 20, 28, 21, 0, -28 },
  { 2974, 17, 28, 21, 2, -28 },
  { 3034, 7, 38, 10, 2, -32 },
  { 3068, 14, 30, 15, 1, -28 },
  { 3121, 7, 38, 10, 1, -32 },
  { 3155, 13, 14, 15, 1, -28 },
  { 3178, 15, 4, 16, 0, 0 },
  { 3186, 9, 6, 13, 1, -30 },
  { 3193, 15, 21, 19, 2, -21 },
  { 3233, 16, 29, 19, 2, -29 },
  { 3291, 15, 21, 18, 2, -21 },
  { 3331, 15, 29, 19, 2, -29 },
  { 3386, 15, 21, 18, 2, -21 },
  { 3426, 11, 29, 13, 1, -29 },
  { 3466, 15, 29, 19, 2, -21 },
  { 3521, 15, 29, 19, 2, -29 },
  { 3576, 5, 29, 9, 2, -29 },
  { 3595, 8, 37, 9, -1, -29 },
  { 3632, 16, 29, 18, 2, -29 },
  { 3690, 5, 29, 9, 2, -29 },
  { 3709, 25, 21, 29, 2, -21 },
  { 3775, 15, 21, 19, 2, -21 },
  { 3815, 16, 21, 19, 2, -21 },
  { 3857, 16, 29, 19, 2, -21 },
  { 3915, 15, 29, 19, 2, -21 },
  { 3970, 10, 21, 12, 2, -21 },
  { 3997, 15, 21, 18, 1, -21 },
  { 4037, 11, 26, 12, 0, -26 },
  { 4073, 15, 21, 19, 2, -21 },
  { 4113, 15, 21, 17, 1, -21 },
  { 4153, 23, 21, 25, 1, -21 },
  { 4214, 16, 21, 17, 1, -21 },
  { 4256, 16, 29, 17, 0, -21 },
  { 4314, 14, 21, 17, 2, -21 },
  { 4351, 10, 37, 12, 1, -30 },
  { 4398, 3, 33, 10, 3, -28 },
  { 4411, 10, 37, 12, 1, -30 },
  { 4458, 18, 8, 22, 2, -15 },
};

const GFXfont RobotoCondensed_Medium39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_MEDIUM39PT7B_H_
