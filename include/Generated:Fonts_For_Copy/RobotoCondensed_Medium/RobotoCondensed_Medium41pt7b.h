#ifndef _ROBOTOCONDENSED_MEDIUM41PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE0, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x01, 0xC7, 0x80, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xE0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E,
  0x1E, 0x38, 0x38, 0x79, 0xE0, 0xE1, 0xE7, 0x03, 0x87, 0x3C, 0x0F, 0x1C,
  0xE0, 0x1F, 0xF7, 0x00, 0x3F, 0x9C, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x77, 0xF8, 0x03, 0x9F, 0xE0, 0x1E, 0xF3, 0xC0,
  0x73, 0x87, 0x03, 0x8E, 0x1C, 0x0E, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x18, 0x3C, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3C, 0x01, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x3C, 0x7F, 0xF1, 0xE3,
  0xCF, 0x8F, 0x3E, 0x3E, 0x79, 0xF0, 0xFF, 0xCF, 0x07, 0xFC, 0x78, 0x1F,
  0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xF7, 0xC0, 0x7E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xC0, 0x20, 0x40, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x10, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x0E, 0x3B, 0xF7,
  0x7D, 0xFF, 0xFF, 0x3F, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x08, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF, 0x3D,
  0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF7, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0,
  0x3E, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x7C, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xFC, 0x10, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0,
  0x7D, 0xE0, 0x3C, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x7C, 0x0F, 0x7F, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8, 0xFD,
  0xF8, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFB, 0xC0, 0x7D, 0xF0, 0x3C, 0xF8, 0x3E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xB8, 0x3C, 0xFD, 0xF9, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x78, 0xF3, 0xC1, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01,
  0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xF0,
  0x1F, 0xC1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x7C, 0x0E, 0x78, 0x1F,
  0xE0, 0xE7, 0x03, 0xFF, 0x0E, 0x70, 0x7C, 0x70, 0xE7, 0x07, 0x8F, 0x06,
  0xF0, 0xF0, 0xF0, 0x7F, 0x0F, 0x0F, 0x07, 0xE0, 0xE0, 0xF0, 0x7E, 0x0E,
  0x0E, 0x07, 0xE1, 0xE0, 0xE0, 0x7E, 0x1E, 0x0E, 0x0E, 0xE1, 0xE0, 0xE0,
  0xEE, 0x1E, 0x0E, 0x0E, 0xE1, 0xE1, 0xE0, 0xEE, 0x1E, 0x1E, 0x1C, 0xF0,
  0xF3, 0xF3, 0xCF, 0x0F, 0xFF, 0xF8, 0x70, 0x7E, 0x7F, 0x07, 0x03, 0xC3,
  0xE0, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xE0, 0x3E, 0x3F, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x3F,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xE0, 0x1F, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xFB,
  0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0x87, 0xC0,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7B, 0xFD, 0xE0, 0x3D, 0xFE, 0xF0, 0x1E, 0xFF, 0x7C, 0x1E, 0x7F, 0x9E,
  0x0F, 0x3F, 0xCF, 0x07, 0x9F, 0xE7, 0xC7, 0xCF, 0xF1, 0xE3, 0xC7, 0xF8,
  0xF1, 0xE3, 0xFC, 0x7D, 0xF1, 0xFE, 0x1E, 0xF0, 0xFF, 0x0F, 0x78, 0x7F,
  0x87, 0xBC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07,
  0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x01, 0xE0,
  0x78, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFE, 0xF0,
  0x3F, 0xDF, 0x07, 0xF9, 0xE0, 0xFF, 0x3E, 0x1F, 0xE3, 0xC3, 0xFC, 0x7C,
  0x7F, 0x87, 0x8F, 0xF0, 0xF9, 0xFE, 0x0F, 0x3F, 0xC1, 0xF7, 0xF8, 0x1E,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x3F,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x3D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0,
  0x7C, 0x3F, 0x8F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x3F, 0x01,
  0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x03,
  0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0x7C,
  0x3F, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x7F,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7C,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBF,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7E, 0x0F, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x3E, 0xF8,
  0x1F, 0x01, 0xE7, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F,
  0x07, 0xC7, 0x83, 0xF8, 0x3E, 0x3C, 0x1F, 0xC1, 0xE1, 0xF0, 0xFF, 0x0F,
  0x0F, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC1, 0xE3, 0xDE, 0x3E, 0x0F,
  0x1E, 0x71, 0xE0, 0x78, 0xE3, 0xCF, 0x03, 0xEF, 0x1E, 0x78, 0x1F, 0x78,
  0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x03, 0xDE, 0x1D, 0xF0, 0x1E, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3F, 0x03, 0xE0,
  0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFE, 0x07, 0x78, 0x3C, 0xE0, 0xF3, 0xC3, 0x8F, 0x1E, 0x1C,
  0x78, 0x79, 0xE1, 0xEF, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x07, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xDE, 0x1F, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0xF8, 0x3E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F,
  0xBF, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xDF, 0xE3, 0xE7, 0xC0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x0F, 0x9F, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x04, 0x7C, 0x0E, 0x7F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x8F, 0x3F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x38, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3F, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0,
  0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x79, 0xEF, 0xDE, 0x78, 0x00, 0x00,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7,
  0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xF7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xF0, 0x3E, 0x3E, 0xFF, 0x3F, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xFE, 0x07, 0xC1,
  0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07,
  0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE,
  0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03,
  0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F,
  0x03, 0xFE, 0x07, 0xC0, 0xF0, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8,
  0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00,
  0xF9, 0xF0, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xC3, 0xF7, 0xC0,
  0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F,
  0x7E, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xBF, 0xC7, 0xCF, 0x83, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0x3F, 0xEF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7D, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0x81,
  0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF8,
  0x3C, 0x0F, 0xF8, 0x3C, 0x1F, 0x78, 0x3E, 0x1F, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x7C, 0x7E, 0x1E, 0x7C, 0x7F, 0x3E, 0x3C, 0xFF, 0x3E, 0x3C,
  0xF7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0xBC, 0x1F, 0xE7, 0xBC, 0x1F,
  0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xF0, 0xF8, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x87, 0xC7, 0x83, 0xE7,
  0xC0, 0xFB, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC1, 0xF7, 0xC0,
  0xF8, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0x81, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x70, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x3C,
  0x04, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x1C, 0xFF, 0x03, 0xBF, 0xF0, 0xF7,
  0x9F, 0x3F, 0xE1, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 29, 10, 3, -29 },
  { 20, 9, 10, 13, 2, -31 },
  { 32, 19, 29, 22, 2, -29 },
  { 101, 16, 37, 21, 2, -33 },
  { 175, 22, 29, 26, 2, -29 },
  { 255, 21, 29, 23, 2, -29 },
  { 332, 3, 10, 7, 2, -31 },
  { 336, 10, 42, 13, 2, -33 },
  { 389, 10, 42, 13, 1, -33 },
  { 442, 17, 17, 18, 1, -29 },
  { 479, 17, 21, 20, 1, -24 },
  { 524, 6, 11, 9, 1, -5 },
  { 533, 9, 4, 13, 2, -14 },
  { 538, 5, 5, 11, 3, -5 },
  { 542, 13, 32, 14, 0, -29 },
  { 594, 16, 29, 21, 2, -29 },
  { 652, 11, 29, 21, 3, -29 },
  { 692, 17, 29, 21, 2, -29 },
  { 754, 16, 29, 21, 2, -29 },
  { 812, 18, 29, 21, 1, -29 },
  { 878, 17, 29, 21, 2, -29 },
  { 940, 17, 29, 21, 2, -29 },
  { 1002, 17, 29, 21, 2, -29 },
  { 1064, 16, 29, 21, 2, -29 },
  { 1122, 16, 29, 21, 2, -29 },
  { 1180, 5, 22, 10, 3, -22 },
  { 1194, 7, 28, 9, 1, -22 },
  { 1219, 15, 19, 18, 1, -22 },
  { 1255, 14, 13, 20, 3, -20 },
  { 1278, 14, 19, 19, 3, -22 },
  { 1312, 15, 29, 18, 1, -29 },
  { 1367, 28, 37, 31, 2, -28 },
  { 1497, 23, 29, 24, 1, -29 },
  { 1581, 18, 29, 23, 3, -29 },
  { 1647, 20, 29, 23, 2, -29 },
  { 1720, 18, 29, 23, 3, -29 },
  { 1786, 16, 29, 20, 3, -29 },
  { 1844, 15, 29, 20, 3, -29 },
  { 1899, 20, 29, 24, 2, -29 },
  { 1972, 20, 29, 25, 3, -29 },
  { 2045, 5, 29, 11, 3, -29 },
  { 2064, 16, 29, 20, 1, -29 },
  { 2122, 20, 29, 23, 3, -29 },
  { 2195, 15, 29, 20, 3, -29 },
  { 2250, 25, 29, 31, 3, -29 },
  { 2341, 19, 29, 25, 3, -29 },
  { 2410, 21, 29, 25, 2, -29 },
  { 2487, 18, 29, 23, 3, -29 },
  { 2553, 21, 34, 25, 2, -29 },
  { 2643, 19, 29, 22, 3, -29 },
  { 2712, 18, 29, 22, 2, -29 },
  { 2778, 20, 29, 22, 1, -29 },
  { 2851, 19, 29, 23, 2, -29 },
  { 2920, 22, 29, 23, 1, -29 },
  { 3000, 29, 29, 31, 1, -29 },
  { 3106, 21, 29, 23, 1, -29 },
  { 3183, 21, 29, 22, 0, -29 },
  { 3260, 18, 29, 22, 2, -29 },
  { 3326, 8, 41, 11, 2, -34 },
  { 3367, 14, 32, 15, 1, -29 },
  { 3423, 7, 41, 11, 1, -34 },
  { 3459, 14, 15, 16, 1, -29 },
  { 3486, 16, 4, 17, 0, 0 },
  { 3494, 9, 6, 13, 1, -31 },
  { 3501, 16, 22, 19, 2, -22 },
  { 3545, 17, 31, 20, 2, -31 },
  { 3611, 16, 22, 19, 2, -22 },
  { 3655, 16, 31, 20, 2, -31 },
  { 3717, 16, 22, 19, 2, -22 },
  { 3761, 12, 31, 13, 1, -31 },
  { 3808, 16, 30, 20, 2, -22 },
  { 3868, 16, 31, 20, 2, -31 },
  { 3930, 6, 30, 10, 2, -30 },
  { 3953, 8, 38, 10, -1, -30 },
  { 3991, 17, 31, 19, 2, -31 },
  { 4057, 4, 31, 10, 3, -31 },
  { 4073, 26, 22, 31, 2, -22 },
  { 4145, 16, 22, 20, 2, -22 },
  { 4189, 17, 22, 20, 2, -22 },
  { 4236, 17, 30, 20, 2, -22 },
  { 4300, 16, 30, 20, 2, -22 },
  { 4360, 10, 22, 13, 2, -22 },
  { 4388, 15, 22, 19, 2, -22 },
  { 4430, 11, 27, 12, 0, -27 },
  { 4468, 16, 22, 20, 2, -22 },
  { 4512, 16, 22, 18, 1, -22 },
  { 4556, 24, 22, 26, 1, -22 },
  { 4622, 17, 22, 18, 1, -22 },
  { 4669, 16, 30, 18, 1, -22 },
  { 4729, 15, 22, 18, 2, -22 },
  { 4771, 10, 39, 12, 1, -32 },
  { 4820, 4, 34, 10, 3, -29 },
  { 4837, 10, 39, 12, 1, -32 },
  { 4886, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_Medium41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_MEDIUM41PT7B_H_
