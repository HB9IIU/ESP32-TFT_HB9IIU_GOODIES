#ifndef _ROBOTOCONDENSED_MEDIUM55PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xFC,
  0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x10, 0x0F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0xF8, 0x0F,
  0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0x1F, 0x00, 0xF0, 0x7C, 0x78, 0x03, 0xE1,
  0xF3, 0xC0, 0x07, 0xCF, 0x8F, 0x00, 0x1F, 0xFE, 0x78, 0x00, 0x3F, 0xF1,
  0xE0, 0x00, 0x7F, 0x8F, 0x00, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x20,
  0x00, 0x07, 0x87, 0xF0, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0xF1, 0xFF, 0xC0,
  0x07, 0xCF, 0xDF, 0x80, 0x1E, 0x3C, 0x3E, 0x00, 0xF8, 0xF0, 0x78, 0x03,
  0xC7, 0xC1, 0xE0, 0x1F, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x1F, 0x03, 0xC1,
  0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x3E,
  0x1E, 0x01, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x7C, 0x1F, 0xFF, 0x07, 0xC3, 0xFF, 0xF8, 0x7C, 0x3F, 0x3F, 0x8F, 0xC7,
  0xF1, 0xFC, 0xFC, 0x7E, 0x0F, 0xEF, 0xCF, 0xE0, 0xFE, 0xF8, 0xFE, 0x07,
  0xFF, 0x8F, 0xE0, 0x3F, 0xF8, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x1F, 0xF0,
  0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF,
  0xE0, 0x3F, 0xF0, 0x7F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0x80, 0x1E, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x02,
  0x40, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x10, 0x1E, 0x00, 0x3C, 0x3C, 0x1E, 0xFF, 0x78, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x3E,
  0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7C, 0xFC, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xF8, 0x7F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF9, 0xF8, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F,
  0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x8F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7F,
  0x03, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x07,
  0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFC,
  0xFF, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC,
  0x3F, 0x07, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x03,
  0xF1, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFE, 0x01, 0xFB, 0xF8,
  0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0xC7, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xCF, 0xC0, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x0E, 0x07,
  0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1E, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF,
  0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x3F, 0x00, 0xF0, 0x78, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0x1F,
  0xFE, 0x07, 0x8F, 0x80, 0xFF, 0xFC, 0x1E, 0x3C, 0x03, 0xE1, 0xE0, 0x78,
  0xF0, 0x1F, 0x07, 0x81, 0xE7, 0xC0, 0xF8, 0x1E, 0x03, 0xDF, 0x03, 0xE0,
  0x78, 0x0F, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE0, 0x7C, 0x0F, 0x80, 0xF7,
  0x81, 0xF0, 0x3E, 0x03, 0xDE, 0x07, 0xC0, 0xF8, 0x0F, 0x78, 0x1F, 0x03,
  0xE0, 0x3D, 0xE0, 0x78, 0x0F, 0x80, 0xF7, 0x83, 0xE0, 0x3E, 0x03, 0xDE,
  0x0F, 0x80, 0xF8, 0x1E, 0x78, 0x3E, 0x03, 0xC0, 0x79, 0xE0, 0xF8, 0x0F,
  0x01, 0xE7, 0x83, 0xE0, 0x3C, 0x07, 0x9E, 0x0F, 0xC1, 0xF0, 0x3C, 0x78,
  0x1F, 0x07, 0xC0, 0xF1, 0xF0, 0x7E, 0x3F, 0x87, 0xC7, 0xC1, 0xFF, 0xFF,
  0x3E, 0x1F, 0x03, 0xFF, 0x7F, 0xF0, 0x3C, 0x0F, 0xF9, 0xFF, 0x80, 0xF8,
  0x0F, 0xC3, 0xFC, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40,
  0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFC, 0x1F, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE,
  0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F,
  0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF8,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC,
  0x3F, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x03, 0xFC, 0xFC,
  0x3F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xFE, 0x07,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00,
  0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x03,
  0xF8, 0xFC, 0x01, 0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xF0,
  0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01,
  0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0xFC, 0x01, 0xFE, 0x3F,
  0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xFC, 0x00,
  0xFB, 0xFF, 0xDF, 0x00, 0x7E, 0xFF, 0xF7, 0xE0, 0x1F, 0xBF, 0xFD, 0xF8,
  0x07, 0xCF, 0xFF, 0x7E, 0x03, 0xF3, 0xFF, 0xCF, 0xC0, 0xFC, 0xFF, 0xF3,
  0xF0, 0x3E, 0x3F, 0xFC, 0xFC, 0x1F, 0x8F, 0xFF, 0x1F, 0x07, 0xE3, 0xFF,
  0xC7, 0xE1, 0xF0, 0xFF, 0xF1, 0xF8, 0xFC, 0x3F, 0xFC, 0x3E, 0x3F, 0x0F,
  0xFF, 0x0F, 0xCF, 0x83, 0xFF, 0xC3, 0xF3, 0xE0, 0xFF, 0xF0, 0x7D, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xDF, 0x80,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0xFC, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7,
  0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xE3, 0xFF,
  0xC1, 0xF8, 0xFF, 0xF0, 0x3F, 0x3F, 0xFC, 0x0F, 0xCF, 0xFF, 0x01, 0xFB,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x07, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0xF3, 0xF0, 0x03, 0xFD,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x3F, 0xDF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x04, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xE0,
  0x7F, 0xE3, 0xF0, 0x07, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0x3F, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x3F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x01, 0xFE,
  0x01, 0xF9, 0xF8, 0x07, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x9F,
  0x80, 0x7F, 0x80, 0x7E, 0x7E, 0x03, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x3F,
  0x03, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0xFC, 0x0F, 0xC3, 0xF0, 0x7D, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF3, 0xE1, 0xF8, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x7E,
  0x1F, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0xF8, 0x7E, 0x07, 0xE3, 0xE3, 0xF1,
  0xF8, 0x1F, 0x8F, 0x87, 0xCF, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFC,
  0xF8, 0x7C, 0xFC, 0x03, 0xF7, 0xE1, 0xF3, 0xF0, 0x0F, 0xDF, 0x03, 0xEF,
  0xC0, 0x3F, 0x7C, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1E, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFE, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xC1, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0x80,
  0xFE, 0x7F, 0x07, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFD, 0xF8, 0x1F, 0xE7, 0xF0, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x83, 0xF7, 0xFF, 0x0F,
  0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFC, 0x1F, 0xEF, 0xE0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xDF, 0xFE, 0x3F, 0x7F, 0xF0, 0xFC,
  0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F,
  0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F,
  0x83, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xFC, 0xFC, 0x3F, 0xFB, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x07, 0xF8, 0xFC,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0C, 0x3F, 0x80, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0xFF,
  0xEF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F,
  0xDF, 0xC0, 0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0x7F,
  0x83, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE,
  0xFC, 0x0F, 0xF3, 0xF0, 0x04, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x20, 0x07, 0xF0, 0xC0, 0x1F, 0xC7, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC7, 0xF8, 0x7E, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF, 0x80, 0xFD,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x38, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x03, 0x81, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFD, 0x7F,
  0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xE3, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0,
  0xFF, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC,
  0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xF0, 0x3F, 0xC3, 0xF7, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC1,
  0xFF, 0x87, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE3,
  0xFC, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE,
  0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF1, 0xFE, 0x0F, 0xDF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xBF, 0x80, 0xFE, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFD, 0xFF, 0xC3, 0xF1, 0xFE, 0x0F, 0xC0, 0x80, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x1F, 0xF3,
  0xF0, 0x04, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x17, 0xE7, 0xFF, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF9,
  0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x7E,
  0x03, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x20, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF,
  0xE1, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFB,
  0xF0, 0xFF, 0x1F, 0x80, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xDF, 0x80,
  0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0,
  0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC, 0x7E, 0x1F, 0xF0, 0x7C, 0x3F,
  0x0F, 0xF8, 0x7E, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x1F, 0x83,
  0xE3, 0xEF, 0x8F, 0xC1, 0xF9, 0xF7, 0xC7, 0xC0, 0xFC, 0xFB, 0xE7, 0xE0,
  0x7E, 0x7C, 0xFB, 0xF0, 0x1F, 0x7C, 0x7D, 0xF8, 0x0F, 0xBE, 0x3E, 0xF8,
  0x07, 0xFF, 0x1F, 0x7C, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFC, 0x7E, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xE1, 0xFF, 0x80, 0x78, 0xFF, 0xF0,
  0x3E, 0x7F, 0xFE, 0x0F, 0x9F, 0xFF, 0x87, 0xE7, 0xC3, 0xFB, 0xFB, 0xE0,
  0x7F, 0xFC, 0xF8, 0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0,
  0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 40, 14, 4, -39 },
  { 36, 12, 14, 18, 3, -41 },
  { 57, 25, 39, 30, 3, -39 },
  { 179, 22, 52, 28, 3, -46 },
  { 322, 30, 41, 35, 3, -40 },
  { 476, 28, 41, 31, 2, -40 },
  { 620, 5, 14, 9, 2, -41 },
  { 629, 13, 56, 18, 3, -44 },
  { 720, 13, 56, 18, 1, -44 },
  { 811, 23, 23, 24, 1, -39 },
  { 878, 23, 29, 27, 2, -33 },
  { 962, 8, 15, 12, 1, -6 },
  { 977, 13, 5, 17, 2, -19 },
  { 986, 7, 8, 15, 4, -7 },
  { 993, 18, 42, 19, 0, -39 },
  { 1088, 22, 41, 28, 3, -40 },
  { 1201, 14, 39, 28, 4, -39 },
  { 1270, 23, 40, 28, 2, -40 },
  { 1385, 22, 41, 28, 2, -40 },
  { 1498, 24, 39, 28, 2, -39 },
  { 1615, 22, 40, 28, 3, -39 },
  { 1725, 22, 40, 28, 3, -39 },
  { 1835, 23, 39, 28, 2, -39 },
  { 1948, 22, 41, 28, 3, -40 },
  { 2061, 21, 40, 28, 3, -40 },
  { 2166, 7, 31, 14, 4, -30 },
  { 2194, 10, 39, 13, 1, -30 },
  { 2243, 19, 26, 25, 2, -30 },
  { 2305, 19, 16, 27, 4, -26 },
  { 2343, 20, 26, 25, 3, -30 },
  { 2408, 20, 41, 24, 2, -40 },
  { 2511, 38, 50, 42, 2, -38 },
  { 2749, 31, 39, 32, 1, -39 },
  { 2901, 24, 39, 30, 4, -39 },
  { 3018, 26, 41, 31, 3, -40 },
  { 3152, 24, 39, 31, 4, -39 },
  { 3269, 21, 39, 27, 4, -39 },
  { 3372, 21, 39, 26, 4, -39 },
  { 3475, 26, 41, 32, 3, -40 },
  { 3609, 26, 39, 34, 4, -39 },
  { 3736, 6, 39, 14, 4, -39 },
  { 3766, 22, 40, 27, 1, -39 },
  { 3876, 26, 39, 30, 4, -39 },
  { 4003, 21, 39, 26, 4, -39 },
  { 4106, 34, 39, 42, 4, -39 },
  { 4272, 26, 39, 34, 4, -39 },
  { 4399, 27, 41, 33, 3, -40 },
  { 4538, 25, 39, 31, 4, -39 },
  { 4660, 27, 47, 33, 3, -40 },
  { 4819, 25, 39, 30, 4, -39 },
  { 4941, 25, 41, 29, 2, -40 },
  { 5070, 27, 39, 29, 1, -39 },
  { 5202, 25, 40, 31, 3, -39 },
  { 5327, 30, 39, 31, 1, -39 },
  { 5474, 38, 39, 42, 2, -39 },
  { 5660, 28, 39, 31, 1, -39 },
  { 5797, 28, 39, 29, 1, -39 },
  { 5934, 25, 39, 29, 2, -39 },
  { 6056, 10, 54, 14, 3, -45 },
  { 6124, 20, 42, 21, 1, -39 },
  { 6229, 10, 54, 14, 1, -45 },
  { 6297, 17, 20, 21, 2, -39 },
  { 6340, 21, 5, 22, 1, 0 },
  { 6354, 13, 8, 18, 1, -41 },
  { 6367, 22, 31, 26, 2, -30 },
  { 6453, 22, 42, 27, 3, -41 },
  { 6569, 22, 31, 25, 2, -30 },
  { 6655, 22, 42, 27, 2, -41 },
  { 6771, 22, 31, 26, 2, -30 },
  { 6857, 16, 42, 18, 1, -42 },
  { 6941, 22, 41, 27, 2, -30 },
  { 7054, 21, 41, 27, 3, -41 },
  { 7162, 7, 40, 13, 3, -40 },
  { 7197, 11, 51, 13, -1, -40 },
  { 7268, 22, 41, 26, 3, -41 },
  { 7381, 6, 41, 13, 4, -41 },
  { 7412, 35, 30, 41, 3, -30 },
  { 7544, 21, 30, 27, 3, -30 },
  { 7623, 23, 31, 27, 2, -30 },
  { 7713, 22, 41, 27, 3, -30 },
  { 7826, 22, 41, 27, 2, -30 },
  { 7939, 13, 30, 18, 3, -30 },
  { 7988, 21, 31, 25, 2, -30 },
  { 8070, 14, 37, 17, 1, -36 },
  { 8135, 21, 30, 27, 3, -29 },
  { 8214, 22, 29, 24, 1, -29 },
  { 8294, 33, 29, 35, 1, -29 },
  { 8414, 22, 29, 25, 1, -29 },
  { 8494, 22, 40, 24, 1, -29 },
  { 8604, 20, 29, 25, 2, -29 },
  { 8677, 13, 53, 17, 2, -43 },
  { 8764, 4, 46, 14, 5, -39 },
  { 8787, 14, 53, 17, 1, -43 },
  { 8880, 26, 12, 31, 3, -22 },
};

const GFXfont RobotoCondensed_Medium55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_MEDIUM55PT7B_H_
