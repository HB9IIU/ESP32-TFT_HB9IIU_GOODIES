#ifndef _ROBOTOCONDENSED_MEDIUM57PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0xF9,
  0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x43, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78,
  0x7B, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3,
  0xF8, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0xC0, 0x3E, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x3E, 0x03, 0xC0, 0xF8, 0x78, 0x07,
  0x81, 0xF1, 0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0x1F, 0x07, 0x8F, 0x80, 0x3E,
  0x1F, 0x1E, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x7F,
  0xE3, 0xE0, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x80, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x3C, 0x7F, 0xE0, 0x00, 0x78,
  0xFF, 0xE0, 0x01, 0xE3, 0xFF, 0xE0, 0x03, 0xC7, 0x87, 0xC0, 0x0F, 0x1F,
  0x07, 0x80, 0x3E, 0x3E, 0x0F, 0x80, 0x78, 0x78, 0x1F, 0x01, 0xF0, 0xF0,
  0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x70, 0x0F, 0x8F, 0x80, 0x20, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFD,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7C, 0x3F, 0xFF, 0x83, 0xE1, 0xFD,
  0xFE, 0x3F, 0x1F, 0xC7, 0xF9, 0xF8, 0xFE, 0x1F, 0xCF, 0xC7, 0xE0, 0x7F,
  0x7E, 0x7F, 0x03, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0x3F, 0xF8,
  0xFE, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xF0, 0x0F, 0xFC, 0x3F,
  0xC0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x08, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x20, 0x40, 0x07, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x40, 0x3C, 0x00, 0x70, 0x3C, 0x0E, 0x7E, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xE7, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF0,
  0x06, 0x00, 0xE0, 0x02, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE1, 0xE0, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0x7E, 0x01,
  0xFC, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8,
  0x1F, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0,
  0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xE7, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x0F,
  0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03,
  0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE3, 0xFE, 0x7F, 0xC7, 0xF0, 0x3F, 0xC0, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x3F, 0x3F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE7, 0xFF, 0x7F, 0xEF, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01,
  0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x80, 0xFC, 0x3F, 0x03, 0xF8,
  0x7F, 0x07, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xF8, 0xFE,
  0x07, 0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01,
  0xFB, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x7F, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x01,
  0xFD, 0xFC, 0x0F, 0xF7, 0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFB, 0xF0, 0xFF, 0xCF, 0xC0, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x0F, 0x07, 0xE3, 0xFC, 0xFF,
  0x3F, 0xC7, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0xF8, 0x03, 0xFF, 0x01, 0xE3, 0xE0, 0x1F, 0xFE, 0x07, 0x8F,
  0x00, 0xFF, 0xFC, 0x1E, 0x7C, 0x07, 0xF3, 0xF0, 0x7D, 0xF0, 0x1F, 0x07,
  0x80, 0xF7, 0x80, 0xF8, 0x1E, 0x03, 0xDE, 0x03, 0xE0, 0x78, 0x0F, 0xF8,
  0x1F, 0x01, 0xE0, 0x3F, 0xE0, 0x7C, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x3E,
  0x03, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xC0,
  0xF8, 0x0F, 0x80, 0xFF, 0x03, 0xE0, 0x3E, 0x03, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0xC0, 0xF8, 0x0F, 0x80, 0xFF, 0x03,
  0xE0, 0x3C, 0x07, 0xFC, 0x0F, 0x80, 0xF0, 0x1E, 0xF0, 0x3E, 0x07, 0xC0,
  0x7B, 0xC0, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0xFE, 0x0F, 0x3E, 0x07,
  0xE7, 0xF8, 0x7C, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xE0, 0x7F, 0xF7, 0xFF,
  0x07, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x00,
  0x80, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFC, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0xE0, 0x07, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03,
  0xFD, 0xFE, 0x07, 0xF1, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07,
  0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xC0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7F, 0x8F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xEF, 0xFF, 0x7E, 0x00, 0xFD, 0xFF, 0xEF, 0xC0, 0x1F, 0xBF, 0xFD, 0xF8,
  0x03, 0xF7, 0xFF, 0x9F, 0x80, 0x7C, 0xFF, 0xF3, 0xF0, 0x1F, 0x9F, 0xFE,
  0x7E, 0x03, 0xF3, 0xFF, 0xC7, 0xE0, 0x7C, 0x7F, 0xF8, 0xFC, 0x1F, 0x8F,
  0xFF, 0x1F, 0x83, 0xF1, 0xFF, 0xE3, 0xF0, 0x7C, 0x3F, 0xFC, 0x3F, 0x1F,
  0x87, 0xFF, 0x87, 0xE3, 0xF0, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0xFE, 0x0F,
  0xDF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xF0, 0x0F, 0xFF,
  0x7F, 0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFC, 0xFE, 0x07, 0xFF, 0x8F, 0xC0,
  0xFF, 0xF1, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8,
  0x3F, 0x0F, 0xFF, 0x07, 0xF1, 0xFF, 0xE0, 0x7E, 0x3F, 0xFC, 0x0F, 0xE7,
  0xFF, 0x80, 0xFC, 0xFF, 0xF0, 0x1F, 0xDF, 0xFE, 0x01, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F,
  0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0xCF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x03,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x7E, 0x00, 0xFF,
  0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x00, 0xFC, 0x7F, 0x01, 0xFF, 0x00, 0xFC,
  0x7F, 0x01, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0x81, 0xFC, 0x3F, 0x01,
  0xFF, 0x81, 0xFC, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x3F, 0x03, 0xFF, 0x81,
  0xF8, 0x3F, 0x83, 0xEF, 0x81, 0xF8, 0x3F, 0x83, 0xEF, 0xC1, 0xF8, 0x1F,
  0x83, 0xEF, 0xC3, 0xF8, 0x1F, 0x87, 0xE7, 0xC3, 0xF0, 0x1F, 0x87, 0xE7,
  0xC3, 0xF0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x1F, 0xC7, 0xC7, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC3, 0xE7, 0xF0, 0x0F, 0xCF,
  0x83, 0xE7, 0xE0, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x0F, 0xCF, 0x83, 0xF7,
  0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xFF, 0x81, 0xF7, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7E, 0x7C, 0x0F, 0xBF,
  0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xE7, 0xE0, 0xFF, 0x1F, 0xC0,
  0x20, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xCF, 0xF8, 0x3F, 0xBF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xEF,
  0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xF0, 0x1F,
  0xDF, 0xF0, 0x7F, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFD, 0xFF, 0xF1,
  0xF9, 0xFF, 0xC3, 0xF1, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x07, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x9F, 0xC3, 0xFF, 0xBF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x0F, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xE7, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC, 0x0F, 0xF1, 0xF8, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F,
  0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x08, 0x3F, 0x80, 0x38,
  0x7F, 0x81, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC, 0xFC,
  0x3F, 0xFD, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xF0, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x80, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xC0, 0xFF, 0x1F, 0x80,
  0x10, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x40,
  0x07, 0xF0, 0xE0, 0x1F, 0xC3, 0xF8, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x04, 0x03, 0xF9, 0xFF,
  0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3C, 0x7E, 0xFE,
  0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE,
  0x7F, 0x8F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0xBF, 0x80, 0xFE, 0x7F, 0x03,
  0xFC, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xFC, 0x0F,
  0xF0, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0x80,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFF,
  0x01, 0xFD, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xDF, 0xFC, 0x3F, 0x9F, 0xF0, 0x7F, 0x06, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFC,
  0x3F, 0xF9, 0xF8, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF,
  0xF0, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xC0, 0xFF, 0x3F, 0x80,
  0x20, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E,
  0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x04, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0x7F, 0x8F, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFD, 0xFC, 0x3F, 0xE7, 0xF0, 0x08, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x00, 0xFD, 0xF8, 0x0F, 0xE0, 0x7F, 0x7E, 0x03, 0xF8, 0x1F, 0x9F,
  0xC1, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x81, 0xF8, 0xFC, 0x1F, 0xF0, 0x7E,
  0x3F, 0x07, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC1, 0xF0, 0xFF, 0xC3,
  0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0x1F, 0x8F, 0xBE, 0x3F, 0x07, 0xE7, 0xEF,
  0x9F, 0x81, 0xF9, 0xF3, 0xE7, 0xE0, 0x3E, 0x7C, 0xFD, 0xF8, 0x0F, 0xDF,
  0x1F, 0x7E, 0x03, 0xFF, 0x87, 0xDF, 0x00, 0xFF, 0xE1, 0xF7, 0xC0, 0x1F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07,
  0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC,
  0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x01,
  0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x01, 0xE0,
  0x07, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x7C, 0x7F, 0xE0, 0x1F, 0x1F, 0xFE, 0x03, 0xE7, 0xFF, 0xE0,
  0x7C, 0xFF, 0xFE, 0x1F, 0x9F, 0x0F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFC, 0xF8,
  0x0F, 0xFF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7C,
  0x00,
};

const GFXglyph RobotoCondensed_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 42, 14, 4, -41 },
  { 38, 13, 15, 18, 3, -43 },
  { 63, 26, 41, 31, 3, -41 },
  { 197, 23, 54, 29, 3, -48 },
  { 353, 31, 43, 36, 3, -42 },
  { 520, 29, 43, 32, 2, -42 },
  { 676, 5, 14, 10, 2, -43 },
  { 685, 14, 58, 18, 3, -45 },
  { 787, 13, 58, 18, 2, -45 },
  { 882, 24, 24, 25, 1, -41 },
  { 954, 23, 29, 28, 2, -33 },
  { 1038, 9, 16, 13, 1, -7 },
  { 1056, 13, 5, 18, 2, -20 },
  { 1065, 8, 8, 16, 4, -7 },
  { 1073, 19, 44, 20, 0, -41 },
  { 1178, 23, 43, 29, 3, -42 },
  { 1302, 15, 41, 29, 4, -41 },
  { 1379, 24, 42, 29, 2, -42 },
  { 1505, 23, 43, 29, 2, -42 },
  { 1629, 25, 41, 29, 2, -41 },
  { 1758, 23, 42, 29, 3, -41 },
  { 1879, 23, 42, 29, 3, -41 },
  { 2000, 24, 41, 29, 2, -41 },
  { 2123, 23, 43, 29, 3, -42 },
  { 2247, 22, 42, 29, 3, -42 },
  { 2363, 8, 32, 15, 4, -31 },
  { 2395, 10, 40, 13, 1, -31 },
  { 2445, 20, 26, 25, 2, -31 },
  { 2510, 20, 19, 28, 4, -28 },
  { 2558, 20, 26, 26, 4, -31 },
  { 2623, 21, 43, 25, 2, -42 },
  { 2736, 38, 53, 44, 3, -40 },
  { 2988, 32, 41, 34, 1, -41 },
  { 3152, 25, 41, 32, 4, -41 },
  { 3281, 27, 43, 32, 3, -42 },
  { 3427, 25, 41, 32, 4, -41 },
  { 3556, 22, 41, 28, 4, -41 },
  { 3669, 22, 41, 27, 4, -41 },
  { 3782, 27, 43, 34, 3, -42 },
  { 3928, 27, 41, 35, 4, -41 },
  { 4067, 7, 41, 15, 4, -41 },
  { 4103, 23, 42, 28, 1, -41 },
  { 4224, 27, 41, 31, 4, -41 },
  { 4363, 22, 41, 27, 4, -41 },
  { 4476, 35, 41, 43, 4, -41 },
  { 4656, 27, 41, 35, 4, -41 },
  { 4795, 28, 43, 34, 3, -42 },
  { 4946, 26, 41, 32, 4, -41 },
  { 5080, 29, 49, 34, 3, -42 },
  { 5258, 26, 41, 31, 4, -41 },
  { 5392, 26, 43, 30, 2, -42 },
  { 5532, 27, 41, 30, 2, -41 },
  { 5671, 26, 42, 32, 3, -41 },
  { 5808, 31, 41, 32, 1, -41 },
  { 5967, 40, 41, 43, 2, -41 },
  { 6172, 29, 41, 32, 1, -41 },
  { 6321, 29, 41, 30, 1, -41 },
  { 6470, 26, 41, 30, 2, -41 },
  { 6604, 11, 56, 15, 3, -47 },
  { 6681, 20, 44, 21, 1, -41 },
  { 6791, 10, 56, 15, 1, -47 },
  { 6861, 18, 20, 22, 2, -41 },
  { 6906, 21, 5, 23, 1, 0 },
  { 6920, 14, 8, 18, 1, -42 },
  { 6934, 22, 32, 27, 3, -31 },
  { 7022, 23, 44, 28, 3, -43 },
  { 7149, 23, 32, 26, 2, -31 },
  { 7241, 23, 44, 28, 2, -43 },
  { 7368, 23, 32, 27, 2, -31 },
  { 7460, 17, 44, 18, 1, -44 },
  { 7554, 23, 43, 28, 2, -31 },
  { 7678, 22, 43, 28, 3, -43 },
  { 7797, 8, 41, 14, 3, -41 },
  { 7838, 11, 53, 13, -1, -41 },
  { 7911, 23, 43, 27, 3, -43 },
  { 8035, 6, 43, 14, 4, -43 },
  { 8068, 36, 31, 43, 3, -31 },
  { 8208, 22, 31, 28, 3, -31 },
  { 8294, 24, 32, 28, 2, -31 },
  { 8390, 23, 43, 28, 3, -31 },
  { 8514, 23, 43, 28, 2, -31 },
  { 8638, 14, 31, 18, 3, -31 },
  { 8693, 22, 32, 26, 2, -31 },
  { 8781, 15, 38, 17, 1, -37 },
  { 8853, 22, 31, 28, 3, -30 },
  { 8939, 23, 30, 25, 1, -30 },
  { 9026, 34, 30, 37, 1, -30 },
  { 9154, 23, 30, 25, 1, -30 },
  { 9241, 23, 42, 25, 1, -30 },
  { 9362, 21, 30, 25, 2, -30 },
  { 9441, 14, 54, 17, 2, -44 },
  { 9536, 4, 49, 14, 5, -41 },
  { 9561, 14, 54, 17, 1, -44 },
  { 9656, 27, 12, 33, 3, -23 },
};

const GFXfont RobotoCondensed_Medium57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_MEDIUM57PT7B_H_
