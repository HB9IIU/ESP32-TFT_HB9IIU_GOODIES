#ifndef _ROBOTOCONDENSED_MEDIUM15PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xB6, 0xD0, 0x24, 0x58, 0xA7, 0xF2, 0x8D, 0x12,
  0x7E, 0x58, 0xA1, 0x40, 0x20, 0x87, 0xBE, 0xCF, 0x0E, 0x1E, 0x18, 0x38,
  0xF6, 0x78, 0x80, 0xE0, 0xB4, 0xB4, 0xB8, 0xE8, 0x10, 0x16, 0x29, 0x29,
  0x49, 0x06, 0x70, 0xB3, 0x26, 0xC7, 0x0C, 0x3D, 0xCF, 0x8D, 0xB9, 0xD8,
  0xF0, 0x25, 0x2D, 0xA4, 0x9B, 0x24, 0x48, 0x84, 0x62, 0x33, 0x33, 0x33,
  0x32, 0x64, 0x80, 0x10, 0x23, 0xF1, 0x82, 0x89, 0x00, 0x20, 0x82, 0x3F,
  0xFC, 0x82, 0x08, 0x6D, 0x60, 0xE0, 0xF0, 0x18, 0x84, 0x23, 0x10, 0x8C,
  0x42, 0x11, 0x80, 0x73, 0x6C, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x67, 0x00,
  0x1F, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x73, 0x68, 0xC3, 0x08, 0x63, 0x18,
  0x63, 0x0F, 0xC0, 0x73, 0x68, 0xC2, 0x18, 0xE0, 0x83, 0x8F, 0x67, 0x00,
  0x0C, 0x18, 0x70, 0xE3, 0xC5, 0x9B, 0x26, 0xFE, 0x18, 0x30, 0x7D, 0xFC,
  0x30, 0xFB, 0x60, 0xC3, 0xCF, 0x67, 0x80, 0x39, 0xCC, 0x30, 0xFB, 0x6C,
  0xF3, 0xCF, 0xE7, 0x80, 0xFC, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x61, 0x86,
  0x00, 0x73, 0x6C, 0xF2, 0xD9, 0xEC, 0xA3, 0xCF, 0x67, 0x80, 0x73, 0x6C,
  0xA3, 0xCF, 0x77, 0xC2, 0x19, 0xC6, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B,
  0x58, 0x04, 0x77, 0x30, 0x70, 0x70, 0x40, 0xF8, 0x01, 0xF0, 0x87, 0x1E,
  0x17, 0xF2, 0x00, 0x39, 0xF4, 0xC3, 0x0C, 0x63, 0x0C, 0x00, 0xC3, 0x00,
  0x1E, 0x08, 0x64, 0x0B, 0x3B, 0x92, 0x64, 0x9B, 0x26, 0xC9, 0xB6, 0xA6,
  0xEC, 0x01, 0x88, 0x3E, 0x00, 0x18, 0x0E, 0x07, 0x02, 0x83, 0x61, 0xB0,
  0xF8, 0xFE, 0x63, 0x21, 0xB0, 0x40, 0xF9, 0xFB, 0x16, 0x2C, 0xDF, 0xB3,
  0x63, 0xC5, 0xBB, 0xE0, 0x38, 0xDB, 0x1E, 0x3C, 0x18, 0x30, 0x63, 0xC6,
  0xD8, 0xE0, 0xF9, 0xFB, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0xC5, 0xBB, 0xE0,
  0xFF, 0xFC, 0x30, 0xC3, 0xEC, 0x30, 0xC3, 0x0F, 0xC0, 0xFF, 0xFC, 0x30,
  0xFB, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x7D, 0xDF, 0x1E, 0x0C, 0x18, 0x37,
  0xE3, 0xC6, 0xFC, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0xFF, 0xFF, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xCD,
  0xF3, 0x80, 0xC7, 0x9B, 0x66, 0xCF, 0x1E, 0x3E, 0x6C, 0xCD, 0x9B, 0x18,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xC1, 0xF0, 0xF8,
  0xFC, 0x7F, 0x2F, 0xB7, 0x5B, 0xA9, 0xDC, 0xE6, 0x72, 0x20, 0xC3, 0x87,
  0x8F, 0x1F, 0x3A, 0x76, 0xE5, 0xCF, 0x8F, 0x18, 0x38, 0xFB, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC6, 0xF8, 0xE0, 0xF9, 0xFB, 0x1E, 0x3C, 0x79, 0xBE,
  0x60, 0xC1, 0x83, 0x00, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0xF8, 0xF0, 0x30, 0x20, 0xF9, 0xFB, 0x16, 0x3C, 0x5F, 0xBE, 0x6C, 0xCD,
  0x9B, 0x18, 0x7B, 0xFC, 0xF0, 0xE1, 0xE0, 0xC1, 0x87, 0xF7, 0x80, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xF9, 0xE0, 0xC3, 0x63, 0x63, 0x62,
  0x26, 0x36, 0x34, 0x3C, 0x1C, 0x1C, 0x18, 0x46, 0x68, 0xCD, 0xB9, 0xB7,
  0x26, 0xA4, 0xD7, 0x8A, 0xF1, 0xCE, 0x39, 0x86, 0x30, 0xC6, 0x00, 0x63,
  0x66, 0x36, 0x3C, 0x1C, 0x18, 0x1C, 0x3C, 0x26, 0x66, 0x63, 0xC3, 0x66,
  0x66, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF0, 0x86,
  0x10, 0xC6, 0x18, 0xC3, 0x0F, 0xC0, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0,
  0xC1, 0x06, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x61, 0x82, 0xED, 0xB6, 0xDB,
  0x6D, 0xB7, 0xC0, 0x31, 0x9C, 0xB4, 0x80, 0xFC, 0x62, 0x73, 0x60, 0x9E,
  0xCA, 0x2D, 0xBA, 0xC3, 0x0C, 0x30, 0xFB, 0x6C, 0xF3, 0xCF, 0x3D, 0xAE,
  0x76, 0xE3, 0x08, 0x47, 0x6E, 0x0C, 0x30, 0xC3, 0x7F, 0x78, 0xE3, 0x8E,
  0x3D, 0xDF, 0x73, 0x68, 0xA3, 0xFE, 0x0C, 0x9E, 0x39, 0xD8, 0xCF, 0x31,
  0x8C, 0x63, 0x18, 0xC0, 0x7F, 0x78, 0xE3, 0x8E, 0x3D, 0xDF, 0x0F, 0x67,
  0x00, 0xC6, 0x31, 0x8F, 0xEF, 0x39, 0xCE, 0x73, 0x90, 0xF3, 0xFF, 0xFC,
  0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x30, 0xDB, 0x6F, 0x38,
  0xF3, 0x6D, 0xB3, 0xFF, 0xFF, 0xFF, 0xFB, 0xEE, 0xF2, 0x39, 0x1C, 0x8E,
  0x47, 0x23, 0x91, 0xBE, 0xF3, 0x9C, 0xE7, 0x39, 0x73, 0x68, 0xE3, 0x8E,
  0x3D, 0x9E, 0xBB, 0x6C, 0xF3, 0xCF, 0x3D, 0xBE, 0xC3, 0x0C, 0x00, 0x7F,
  0x78, 0xE3, 0x8E, 0x3D, 0xDF, 0x0C, 0x30, 0xC0, 0xFF, 0x6D, 0xB6, 0x76,
  0xF1, 0xC3, 0xCF, 0x6E, 0x66, 0xF6, 0x66, 0x66, 0x63, 0xCE, 0x73, 0x9C,
  0xE7, 0x6D, 0xCD, 0x36, 0xDA, 0x28, 0xE3, 0x0C, 0xCC, 0xA6, 0xD3, 0x6F,
  0xB7, 0x71, 0xB8, 0xCC, 0x66, 0x4D, 0xB3, 0x8C, 0x38, 0xE6, 0xD3, 0xCD,
  0x36, 0xDA, 0x38, 0xE3, 0x0C, 0x31, 0x86, 0x00, 0xF8, 0xCC, 0x66, 0x63,
  0x1F, 0x13, 0x22, 0x22, 0x6C, 0x62, 0x22, 0x23, 0x10, 0xFF, 0xF8, 0x46,
  0x66, 0x66, 0x23, 0x26, 0x66, 0x64, 0x40, 0x67, 0xFE, 0x70,
};

const GFXglyph RobotoCondensed_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 3, 4, 5, 1, -11 },
  { 6, 7, 11, 8, 1, -11 },
  { 16, 6, 14, 8, 1, -13 },
  { 27, 8, 11, 10, 1, -11 },
  { 38, 7, 11, 8, 1, -11 },
  { 48, 1, 4, 3, 1, -11 },
  { 49, 3, 15, 5, 1, -12 },
  { 55, 4, 15, 5, 0, -12 },
  { 63, 7, 6, 7, 0, -11 },
  { 69, 6, 8, 7, 1, -9 },
  { 75, 3, 4, 3, 0, -2 },
  { 77, 3, 1, 5, 1, -5 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 5, 12, 5, 0, -11 },
  { 87, 6, 11, 8, 1, -11 },
  { 96, 4, 11, 8, 1, -11 },
  { 102, 6, 11, 8, 1, -11 },
  { 111, 6, 11, 8, 1, -11 },
  { 120, 7, 11, 8, 0, -11 },
  { 130, 6, 11, 8, 1, -11 },
  { 139, 6, 11, 8, 1, -11 },
  { 148, 6, 11, 8, 1, -11 },
  { 157, 6, 11, 8, 1, -11 },
  { 166, 6, 11, 8, 1, -11 },
  { 175, 2, 8, 4, 1, -8 },
  { 177, 3, 10, 3, 0, -8 },
  { 181, 6, 7, 7, 0, -8 },
  { 187, 5, 4, 7, 1, -7 },
  { 190, 5, 7, 7, 1, -8 },
  { 195, 6, 11, 7, 0, -11 },
  { 204, 10, 13, 12, 1, -10 },
  { 221, 9, 11, 9, 0, -11 },
  { 234, 7, 11, 8, 1, -11 },
  { 244, 7, 11, 9, 1, -11 },
  { 254, 7, 11, 9, 1, -11 },
  { 264, 6, 11, 7, 1, -11 },
  { 273, 6, 11, 7, 1, -11 },
  { 282, 7, 11, 9, 1, -11 },
  { 292, 7, 11, 9, 1, -11 },
  { 302, 2, 11, 4, 1, -11 },
  { 305, 6, 11, 7, 0, -11 },
  { 314, 7, 11, 8, 1, -11 },
  { 324, 6, 11, 7, 1, -11 },
  { 333, 9, 11, 11, 1, -11 },
  { 346, 7, 11, 9, 1, -11 },
  { 356, 7, 11, 9, 1, -11 },
  { 366, 7, 11, 8, 1, -11 },
  { 376, 7, 13, 9, 1, -11 },
  { 388, 7, 11, 8, 1, -11 },
  { 398, 6, 11, 8, 1, -11 },
  { 407, 8, 11, 8, 0, -11 },
  { 418, 7, 11, 9, 1, -11 },
  { 428, 8, 11, 9, 0, -11 },
  { 439, 11, 11, 11, 0, -11 },
  { 455, 8, 11, 8, 0, -11 },
  { 466, 8, 11, 8, 0, -11 },
  { 477, 6, 11, 8, 1, -11 },
  { 486, 3, 14, 4, 1, -12 },
  { 492, 6, 12, 6, 0, -11 },
  { 501, 3, 14, 4, 0, -12 },
  { 507, 5, 5, 6, 0, -11 },
  { 511, 6, 1, 6, 0, 0 },
  { 512, 4, 2, 5, 0, -11 },
  { 513, 6, 8, 7, 1, -8 },
  { 519, 6, 12, 7, 1, -12 },
  { 528, 5, 8, 7, 1, -8 },
  { 533, 6, 12, 7, 1, -12 },
  { 542, 6, 8, 7, 1, -8 },
  { 548, 5, 12, 5, 0, -12 },
  { 556, 6, 11, 7, 1, -8 },
  { 565, 5, 12, 7, 1, -12 },
  { 573, 2, 11, 4, 1, -11 },
  { 576, 3, 14, 4, 0, -11 },
  { 582, 6, 12, 7, 1, -12 },
  { 591, 2, 12, 4, 1, -12 },
  { 594, 9, 8, 11, 1, -8 },
  { 603, 5, 8, 7, 1, -8 },
  { 608, 6, 8, 8, 1, -8 },
  { 614, 6, 11, 7, 1, -8 },
  { 623, 6, 11, 7, 1, -8 },
  { 632, 3, 8, 5, 1, -8 },
  { 635, 5, 8, 7, 1, -8 },
  { 640, 4, 10, 5, 0, -10 },
  { 645, 5, 8, 7, 1, -8 },
  { 650, 6, 8, 7, 0, -8 },
  { 656, 9, 8, 10, 0, -8 },
  { 665, 6, 8, 7, 0, -8 },
  { 671, 6, 11, 6, 0, -8 },
  { 680, 5, 8, 7, 1, -8 },
  { 685, 4, 15, 5, 0, -12 },
  { 693, 1, 13, 4, 1, -11 },
  { 695, 4, 15, 5, 0, -12 },
  { 703, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Medium15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_MEDIUM15PT7B_H_
