#ifndef _ROBOTOCONDENSED_MEDIUM10PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x9E, 0x6F, 0xA9, 0x40, 0x23, 0x94, 0x83,
  0x09, 0x4E, 0x20, 0x62, 0xA7, 0x04, 0x2C, 0xD0, 0xC0, 0x71, 0x45, 0x18,
  0x7B, 0x67, 0x80, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x22, 0x52, 0x50, 0x2F,
  0x65, 0x22, 0xF2, 0x20, 0x58, 0xE0, 0x80, 0x24, 0xA4, 0xA4, 0xF6, 0xDB,
  0x78, 0x75, 0x54, 0x76, 0x84, 0x22, 0x21, 0xE0, 0x75, 0x12, 0x1D, 0x70,
  0x11, 0x94, 0xAF, 0x88, 0x40, 0xE8, 0xE2, 0x3A, 0xE0, 0x68, 0xEA, 0xBA,
  0xE0, 0xF8, 0x84, 0x62, 0x11, 0x00, 0xF6, 0xFB, 0x78, 0x75, 0xD5, 0x71,
  0x60, 0x88, 0x40, 0x58, 0x16, 0x61, 0xE3, 0x80, 0x8D, 0xC0, 0x6D, 0x12,
  0x20, 0x60, 0x3C, 0x85, 0x6D, 0x5A, 0xB5, 0x55, 0xA0, 0x38, 0x30, 0xC3,
  0x16, 0x79, 0x2C, 0xC0, 0xE9, 0x9E, 0x99, 0xE0, 0xF9, 0x88, 0x89, 0xF0,
  0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF2, 0x79, 0x20, 0xF9,
  0x8B, 0x99, 0xF0, 0x9C, 0xE7, 0xF9, 0xCE, 0x60, 0xFE, 0x11, 0x11, 0x1D,
  0x70, 0x95, 0x39, 0x8A, 0x5A, 0x40, 0x88, 0x88, 0x88, 0xF0, 0x8F, 0x3C,
  0xF5, 0xB6, 0xDA, 0x40, 0x9D, 0xDB, 0xB9, 0x90, 0xF9, 0x99, 0x99, 0xF0,
  0xF9, 0x9F, 0x88, 0x80, 0x79, 0x24, 0xB2, 0x49, 0x27, 0x82, 0xE9, 0x9E,
  0xAB, 0x90, 0x72, 0x50, 0x60, 0xE5, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0x99, 0x99, 0x99, 0xE0, 0xC9, 0x24, 0x94, 0x30, 0xC3, 0x00, 0xD2, 0xB5,
  0x6A, 0xD6, 0xCC, 0x89, 0x00, 0x4A, 0xCC, 0x63, 0x2D, 0x20, 0xCA, 0xD4,
  0x62, 0x10, 0x80, 0xF8, 0x84, 0x46, 0x23, 0xE0, 0xFF, 0xC0, 0x84, 0x44,
  0x22, 0x23, 0xD5, 0x55, 0x70, 0x46, 0x6A, 0xF0, 0x48, 0x75, 0x7D, 0x70,
  0x88, 0x8E, 0xAB, 0xAE, 0x7D, 0xCD, 0x70, 0x11, 0x17, 0xDD, 0xD7, 0x75,
  0xF4, 0x70, 0x69, 0x74, 0x92, 0x7D, 0xDD, 0x71, 0x70, 0x92, 0x7B, 0x6D,
  0xBE, 0x45, 0x55, 0x80, 0x88, 0x8A, 0xCC, 0xEA, 0xFF, 0xFE, 0x9A, 0x69,
  0xA4, 0xF6, 0xDA, 0x76, 0xB7, 0xA7, 0x00, 0xEA, 0xBA, 0xE8, 0x80, 0x7D,
  0xDD, 0x71, 0x10, 0xEA, 0x80, 0x75, 0x6D, 0x70, 0x4B, 0xA4, 0x98, 0xB6,
  0xDE, 0x95, 0x66, 0x20, 0x95, 0xD7, 0x5A, 0x48, 0x56, 0x26, 0xD0, 0x95,
  0x66, 0x26, 0x40, 0xF2, 0x24, 0xF0, 0x29, 0x28, 0x92, 0x44, 0xFF, 0x89,
  0x22, 0x92, 0x50, 0xDB,
};

const GFXglyph RobotoCondensed_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 3, 3, 0, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 0, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 4, 4, 4, 0, -7 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 2, 3, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -4 },
  { 42, 1, 1, 3, 1, -1 },
  { 43, 3, 8, 4, 0, -7 },
  { 46, 3, 7, 5, 1, -7 },
  { 49, 2, 7, 5, 1, -7 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 4, 7, 5, 1, -7 },
  { 69, 4, 7, 5, 1, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 3, 7, 5, 1, -7 },
  { 81, 4, 7, 5, 0, -7 },
  { 85, 1, 5, 3, 1, -5 },
  { 86, 2, 7, 2, 0, -5 },
  { 88, 4, 4, 4, 0, -5 },
  { 90, 3, 3, 5, 1, -5 },
  { 92, 3, 4, 5, 1, -5 },
  { 94, 4, 7, 4, 0, -7 },
  { 98, 7, 9, 8, 0, -7 },
  { 106, 6, 7, 6, 0, -7 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 4, 7, 5, 1, -7 },
  { 128, 3, 7, 5, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 5, 7, 6, 1, -7 },
  { 140, 1, 7, 3, 1, -7 },
  { 141, 4, 7, 5, 0, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 4, 7, 5, 1, -7 },
  { 154, 6, 7, 8, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 6, 8, 6, 0, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 5, 7, 5, 0, -7 },
  { 187, 5, 7, 5, 0, -7 },
  { 192, 4, 7, 6, 1, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 7, 7, 8, 0, -7 },
  { 209, 5, 7, 6, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 5, 7, 5, 0, -7 },
  { 224, 1, 10, 3, 1, -8 },
  { 226, 4, 8, 4, 0, -7 },
  { 230, 2, 10, 3, 0, -8 },
  { 233, 4, 4, 4, 0, -7 },
  { 235, 4, 1, 4, 0, 0 },
  { 236, 3, 2, 3, 0, -8 },
  { 237, 4, 5, 5, 0, -5 },
  { 240, 4, 8, 5, 1, -8 },
  { 244, 4, 5, 5, 0, -5 },
  { 247, 4, 8, 5, 0, -8 },
  { 251, 4, 5, 5, 0, -5 },
  { 254, 3, 8, 3, 0, -8 },
  { 257, 4, 7, 5, 0, -5 },
  { 261, 3, 8, 5, 1, -8 },
  { 264, 1, 7, 2, 1, -7 },
  { 265, 2, 9, 2, 0, -7 },
  { 268, 4, 8, 5, 1, -8 },
  { 272, 1, 8, 2, 1, -8 },
  { 273, 6, 5, 7, 1, -5 },
  { 277, 3, 5, 5, 1, -5 },
  { 279, 5, 5, 5, 0, -5 },
  { 283, 4, 7, 5, 1, -5 },
  { 287, 4, 7, 5, 0, -5 },
  { 291, 2, 5, 3, 1, -5 },
  { 293, 4, 5, 5, 0, -5 },
  { 296, 3, 7, 3, 0, -7 },
  { 299, 3, 5, 5, 1, -5 },
  { 301, 4, 5, 4, 0, -5 },
  { 304, 6, 5, 6, 0, -5 },
  { 308, 4, 5, 4, 0, -5 },
  { 311, 4, 7, 4, 0, -5 },
  { 315, 4, 5, 4, 0, -5 },
  { 318, 3, 10, 3, 0, -8 },
  { 322, 1, 8, 2, 1, -7 },
  { 323, 3, 10, 3, 0, -8 },
  { 327, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Medium10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_MEDIUM10PT7B_H_
