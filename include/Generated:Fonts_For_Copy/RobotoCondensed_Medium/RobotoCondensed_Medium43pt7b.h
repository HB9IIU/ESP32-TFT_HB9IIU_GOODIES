#ifndef _ROBOTOCONDENSED_MEDIUM43PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xBF, 0xFF, 0xFD, 0xC0, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x38, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0x3F,
  0x3F, 0x0F, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0xFE, 0x7F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0x8F, 0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x71, 0xE0, 0xF0, 0xE3, 0x81, 0xE1, 0xCF, 0x01, 0xC7, 0x9C, 0x03,
  0xFE, 0x78, 0x03, 0xFC, 0xE0, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0xE0, 0x01, 0xCF, 0xF0, 0x07,
  0x3F, 0xE0, 0x0E, 0x79, 0xE0, 0x38, 0xE1, 0xC0, 0xF3, 0xC3, 0x81, 0xC7,
  0x87, 0x07, 0x8F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x1C, 0x38, 0x30, 0x3C,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x3E, 0x00,
  0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0xF8,
  0x78, 0x03, 0xE3, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0xF0, 0xFF, 0xC3, 0xC7,
  0xDF, 0x8F, 0x3E, 0x3F, 0x7C, 0xF8, 0x7D, 0xF3, 0xE1, 0xFF, 0x8F, 0x83,
  0xFE, 0x3E, 0x07, 0xF8, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE3, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0xE0, 0x7E, 0x0F, 0x80,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x80, 0x60, 0x38, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x18,
  0x02, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x06, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x70, 0x6F, 0x9C, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0x78, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x1C, 0x1C, 0x02, 0x02,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF, 0x7B, 0xEF, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xC0, 0x00, 0x20, 0x3C, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xF0, 0x1E, 0x3E, 0x03,
  0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3C,
  0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF7, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xF1, 0xF8, 0xFE, 0x08, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xCF, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xF3, 0xFB,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83,
  0xE3, 0xF3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3,
  0xE3, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFE, 0x1F, 0x1F,
  0x9F, 0x07, 0xCF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E,
  0xF8, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0, 0x7C,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x33, 0xEF,
  0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x3E, 0xFF, 0xFF, 0x9E, 0x18, 0x7D, 0xFB, 0xF3, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0x9E, 0x08, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x3F,
  0x03, 0x8E, 0x03, 0xFC, 0x1C, 0x70, 0x3F, 0xF0, 0xE7, 0x83, 0xE7, 0x83,
  0xB8, 0x1E, 0x3C, 0x1D, 0xC1, 0xE1, 0xE0, 0xEE, 0x0F, 0x0F, 0x07, 0xF0,
  0xF0, 0x78, 0x3F, 0x87, 0x83, 0xC1, 0xFC, 0x3C, 0x1E, 0x0F, 0xE1, 0xE0,
  0xE0, 0x7F, 0x0F, 0x07, 0x03, 0xF0, 0x78, 0x38, 0x1F, 0x83, 0xC1, 0xC0,
  0xFE, 0x1E, 0x1E, 0x0E, 0xF0, 0xF0, 0xF0, 0x77, 0x87, 0x8F, 0x87, 0xBC,
  0x3F, 0xFE, 0x78, 0xE0, 0xFF, 0xFF, 0x87, 0x07, 0xF3, 0xFC, 0x3C, 0x0F,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0x80, 0x03,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07,
  0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83, 0xF9, 0xF0,
  0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x01,
  0xFB, 0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x7E, 0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xE1, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x87, 0xF9, 0xF0,
  0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01,
  0xF3, 0xE0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0x01,
  0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7E, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0xCF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF7, 0xC0, 0x3F,
  0x3E, 0x03, 0xF9, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x7E, 0x01,
  0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xBF, 0x01, 0xF8, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x87, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xEF, 0xFF, 0xE0, 0x3D, 0xFF,
  0xBC, 0x0F, 0xBF, 0xF7, 0x81, 0xF7, 0xFE, 0xF8, 0x3C, 0xFF, 0xDF, 0x07,
  0x9F, 0xF9, 0xE1, 0xF3, 0xFF, 0x3E, 0x3C, 0x7F, 0xE7, 0xC7, 0x8F, 0xFC,
  0x79, 0xF1, 0xFF, 0x8F, 0x3C, 0x3F, 0xF1, 0xF7, 0x87, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFC, 0x1F, 0xF8, 0x7F, 0x83, 0xFF, 0x07, 0xF0, 0x7F, 0xE0,
  0xFE, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07,
  0xFE, 0x07, 0x80, 0xF8, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF,
  0xBE, 0x0F, 0xFC, 0xF8, 0x7F, 0xE7, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0x3F, 0xF0, 0x7D, 0xFF, 0x83, 0xEF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xCF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFC,
  0x0F, 0xC3, 0xFC, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xF8, 0x1F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x08, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8,
  0x1F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x1F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xFC, 0x3F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E,
  0x3F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC,
  0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07,
  0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xE0,
  0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0xDF, 0x01, 0xF0, 0x1F, 0x7C, 0x0F,
  0xC0, 0x7D, 0xF0, 0x3F, 0x81, 0xE7, 0xC0, 0xFE, 0x0F, 0x8F, 0x03, 0xF8,
  0x3E, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x7F, 0x83, 0xE3, 0xE1, 0xEF, 0x0F,
  0x8F, 0x87, 0xBC, 0x3C, 0x1E, 0x1E, 0xF1, 0xF0, 0x78, 0x7B, 0xC7, 0xC1,
  0xF3, 0xCF, 0x1F, 0x07, 0xCF, 0x1E, 0x7C, 0x1F, 0x3C, 0x79, 0xE0, 0x7C,
  0xF1, 0xE7, 0x80, 0xF7, 0xC7, 0xBE, 0x03, 0xDE, 0x1E, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0,
  0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xFF, 0xFF, 0xFC, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x81, 0xEE, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0xC7, 0x9E,
  0x1E, 0x78, 0x79, 0xE0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xF7, 0xE0,
  0xFB, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xE7, 0xE1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBF, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x3E,
  0x7E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x3E, 0x0F,
  0xBF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x8F, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0xC0, 0xFB, 0xF8, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xBF, 0xE3, 0xE3,
  0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC7, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F, 0x9F, 0x03, 0xF0, 0x07, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x1F, 0x83, 0xC7,
  0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x1F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xC7, 0x8F, 0xF7,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x8F,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x1F, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC4, 0x07, 0xE7, 0x87, 0xE3, 0xFF, 0xF3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x7C, 0x3E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0,
  0x0F, 0x0F, 0xC7, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xEF, 0xF7, 0xF3, 0xF9, 0xF0, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x1F, 0x0F, 0xBF, 0xC7, 0xFC,
  0xFF, 0xFE, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3F, 0xC7, 0xEF, 0xC1,
  0xF8, 0x3E, 0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x81,
  0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF,
  0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F,
  0x81, 0xF0, 0xF8, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3,
  0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3E, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xE1, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xF8, 0xF8, 0x3E, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x03, 0xEF,
  0xE1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0x8F, 0x83, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x8F, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xBE, 0x0F, 0xDF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0x7C, 0x3E, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xEF,
  0x83, 0xE0, 0xF9, 0xE0, 0xF8, 0x3E, 0x78, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3,
  0xC7, 0xC7, 0xF0, 0xF0, 0xF1, 0xFC, 0x7C, 0x3C, 0x7F, 0x9F, 0x0F, 0x1D,
  0xE7, 0xC3, 0xEF, 0x79, 0xE0, 0xFB, 0xCE, 0x78, 0x1E, 0xF3, 0xDE, 0x07,
  0xB8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xBE, 0x0F,
  0x9F, 0x87, 0xC7, 0xC7, 0xC3, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x8F,
  0x87, 0xC7, 0xE7, 0xC1, 0xF3, 0xE0, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x81, 0xF7,
  0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0xF8, 0x7F, 0x0F, 0xC1, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x40, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x08, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x07, 0x3F, 0xE0, 0xF7, 0xFF, 0x0F, 0x7D, 0xF9, 0xF7,
  0x87, 0xFE, 0xF0, 0x3F, 0xEF, 0x01, 0xFC, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 10, 11, 14, 2, -32 },
  { 35, 20, 31, 23, 2, -31 },
  { 113, 17, 39, 22, 2, -35 },
  { 196, 23, 31, 27, 2, -31 },
  { 286, 22, 31, 24, 2, -31 },
  { 372, 4, 11, 7, 2, -32 },
  { 378, 10, 44, 14, 3, -34 },
  { 433, 10, 44, 14, 1, -34 },
  { 488, 18, 18, 19, 1, -31 },
  { 529, 17, 23, 21, 2, -26 },
  { 578, 6, 12, 10, 1, -5 },
  { 587, 9, 4, 13, 2, -15 },
  { 592, 6, 6, 12, 3, -6 },
  { 597, 14, 34, 15, 0, -31 },
  { 657, 17, 31, 22, 2, -31 },
  { 723, 11, 31, 22, 3, -31 },
  { 766, 18, 31, 22, 2, -31 },
  { 836, 17, 31, 22, 2, -31 },
  { 902, 19, 31, 22, 1, -31 },
  { 976, 18, 31, 22, 2, -31 },
  { 1046, 18, 31, 22, 2, -31 },
  { 1116, 18, 31, 22, 2, -31 },
  { 1186, 17, 31, 22, 2, -31 },
  { 1252, 17, 31, 22, 2, -31 },
  { 1318, 6, 24, 11, 3, -24 },
  { 1336, 7, 31, 10, 1, -24 },
  { 1364, 15, 20, 19, 1, -23 },
  { 1402, 15, 12, 21, 3, -20 },
  { 1425, 15, 20, 20, 3, -23 },
  { 1463, 16, 31, 19, 1, -31 },
  { 1525, 29, 40, 33, 2, -30 },
  { 1670, 24, 31, 25, 1, -31 },
  { 1763, 19, 31, 24, 3, -31 },
  { 1837, 21, 31, 24, 2, -31 },
  { 1919, 19, 31, 24, 3, -31 },
  { 1993, 17, 31, 21, 3, -31 },
  { 2059, 16, 31, 21, 3, -31 },
  { 2121, 21, 31, 25, 2, -31 },
  { 2203, 21, 31, 27, 3, -31 },
  { 2285, 5, 31, 11, 3, -31 },
  { 2305, 17, 31, 21, 1, -31 },
  { 2371, 21, 31, 24, 3, -31 },
  { 2453, 16, 31, 21, 3, -31 },
  { 2515, 27, 31, 33, 3, -31 },
  { 2620, 21, 31, 26, 3, -31 },
  { 2702, 22, 31, 26, 2, -31 },
  { 2788, 20, 31, 24, 3, -31 },
  { 2866, 22, 36, 26, 2, -31 },
  { 2965, 20, 31, 23, 3, -31 },
  { 3043, 19, 31, 23, 2, -31 },
  { 3117, 21, 31, 23, 1, -31 },
  { 3199, 20, 31, 24, 2, -31 },
  { 3277, 23, 31, 25, 1, -31 },
  { 3367, 30, 31, 32, 1, -31 },
  { 3484, 22, 31, 24, 1, -31 },
  { 3570, 22, 31, 23, 0, -31 },
  { 3656, 19, 31, 23, 2, -31 },
  { 3730, 7, 42, 11, 3, -35 },
  { 3767, 15, 34, 16, 1, -31 },
  { 3831, 7, 42, 11, 1, -35 },
  { 3868, 14, 15, 16, 1, -31 },
  { 3895, 17, 4, 17, 0, 0 },
  { 3904, 10, 6, 14, 1, -32 },
  { 3912, 17, 23, 20, 2, -23 },
  { 3961, 18, 32, 21, 2, -32 },
  { 4033, 16, 23, 20, 2, -23 },
  { 4079, 17, 32, 21, 2, -32 },
  { 4147, 17, 23, 20, 2, -23 },
  { 4196, 12, 32, 14, 1, -32 },
  { 4244, 17, 32, 21, 2, -23 },
  { 4312, 17, 32, 21, 2, -32 },
  { 4380, 6, 31, 10, 2, -31 },
  { 4404, 9, 40, 10, -1, -31 },
  { 4449, 18, 32, 20, 2, -32 },
  { 4521, 5, 32, 10, 3, -32 },
  { 4541, 28, 23, 32, 2, -23 },
  { 4622, 17, 23, 21, 2, -23 },
  { 4671, 18, 23, 21, 2, -23 },
  { 4723, 18, 32, 21, 2, -23 },
  { 4795, 17, 32, 21, 2, -23 },
  { 4863, 11, 23, 14, 2, -23 },
  { 4895, 16, 23, 20, 2, -23 },
  { 4941, 12, 28, 13, 0, -28 },
  { 4983, 17, 23, 21, 2, -23 },
  { 5032, 17, 23, 19, 1, -23 },
  { 5081, 26, 23, 28, 1, -23 },
  { 5156, 17, 23, 19, 1, -23 },
  { 5205, 17, 32, 19, 1, -23 },
  { 5273, 15, 23, 19, 2, -23 },
  { 5317, 11, 42, 13, 1, -34 },
  { 5375, 3, 37, 11, 4, -31 },
  { 5389, 11, 42, 13, 1, -34 },
  { 5447, 20, 9, 25, 2, -17 },
};

const GFXfont RobotoCondensed_Medium43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_MEDIUM43PT7B_H_
