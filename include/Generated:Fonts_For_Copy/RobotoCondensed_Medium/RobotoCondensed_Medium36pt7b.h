#ifndef _ROBOTOCONDENSED_MEDIUM36PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73,
  0x80, 0x00, 0x39, 0xFF, 0x7B, 0x80, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7,
  0xC7, 0xC7, 0xC6, 0x03, 0x8C, 0x03, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x71, 0xC3, 0x0E, 0x38, 0x61, 0xC7, 0x1C, 0x38, 0xE3, 0x07, 0x1C, 0xE0,
  0xE3, 0x98, 0x1F, 0xE7, 0x01, 0xFC, 0xC0, 0x1F, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x71, 0xE0, 0x0E, 0xFE, 0x03, 0x9F, 0xE0, 0x77, 0x1C,
  0x1C, 0xE3, 0x83, 0x1C, 0x30, 0xE3, 0x86, 0x18, 0x71, 0xC7, 0x0E, 0x38,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xE1, 0xC7, 0xFC, 0x73, 0xEF, 0x1C, 0xF1, 0xEF, 0x3C, 0x7F, 0xCF,
  0x0F, 0xF3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0xDF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xEF, 0x83, 0xE1, 0xE0, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x01,
  0x01, 0x81, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x60, 0x10, 0x40, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0xE0, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x61, 0x86, 0x7D, 0x9E, 0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x08, 0x10,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0x33, 0xFE,
  0xF7, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xE1, 0xE7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x01, 0x83, 0xC7, 0xFF, 0xFF, 0xFF,
  0xBF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x3E,
  0x78, 0x1E, 0xF8, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0x83, 0xCF, 0x07, 0xDE, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x07, 0x9F, 0xBF, 0x1F,
  0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78,
  0x78, 0x70, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xEF, 0x87, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xC1, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE,
  0x07, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xCF,
  0x8F, 0x7F, 0x3F, 0xFE, 0xFE, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xE1, 0xF3, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x79, 0xE1, 0xE7,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xBE, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0xF8,
  0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x7D, 0xF7, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0x78, 0x00, 0x33, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x7F, 0xFE, 0xE0, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0xF1, 0x80, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x1F, 0x00,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xF8,
  0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x70, 0x1E, 0x06, 0x70, 0x7F, 0x86,
  0x70, 0xFF, 0x87, 0xE0, 0xE3, 0x87, 0xE1, 0xE3, 0x87, 0xE1, 0xC3, 0x87,
  0xE1, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87,
  0xE3, 0x83, 0x87, 0xE3, 0x87, 0x86, 0xE3, 0xC7, 0x8E, 0xE3, 0xCF, 0x8E,
  0xE1, 0xFF, 0xFC, 0xE1, 0xFB, 0xF8, 0x70, 0xF0, 0xF0, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xC0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xF7, 0x80, 0xFB, 0xE0, 0x78, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x83,
  0xE7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF7, 0xC1,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F,
  0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E,
  0xF8, 0x0F, 0xBC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFC, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xF7,
  0x01, 0xFF, 0xEF, 0x03, 0xBF, 0xDE, 0x0F, 0x7F, 0xBC, 0x1E, 0xFF, 0x3C,
  0x39, 0xFE, 0x78, 0xF3, 0xFC, 0xF1, 0xE7, 0xFC, 0xE3, 0x8F, 0xF9, 0xEF,
  0x1F, 0xF3, 0xDE, 0x3F, 0xE3, 0xBC, 0x7F, 0xC7, 0xF0, 0xFF, 0x8F, 0xE1,
  0xFF, 0x0F, 0xC3, 0xFE, 0x1F, 0x07, 0xFC, 0x3E, 0x0F, 0xF8, 0x3C, 0x1F,
  0xF0, 0x70, 0x3C, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xBC, 0x3F, 0xEF, 0x0F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x8F,
  0x3F, 0xE3, 0xCF, 0xF8, 0x7B, 0xFE, 0x1E, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C,
  0x1F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0x78,
  0x0F, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xEF, 0x80,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x07, 0xC3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0x40, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x1F, 0x07, 0x8F,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0x79, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07,
  0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1F, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE0, 0x78,
  0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78,
  0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xF0, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x1F,
  0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x0F, 0x81, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x1E, 0x07, 0xF8, 0x0F, 0x03, 0xFE, 0x0F, 0x81, 0xEF, 0x07, 0xC0, 0xF7,
  0x83, 0xE0, 0xFB, 0xC1, 0xF8, 0x79, 0xE0, 0xFC, 0x3C, 0xF0, 0xFE, 0x1E,
  0x3C, 0x7F, 0x0F, 0x1E, 0x3B, 0x87, 0x8F, 0x1D, 0xE7, 0x87, 0x8E, 0xF3,
  0xC3, 0xCF, 0x39, 0xE0, 0xE7, 0x9C, 0xF0, 0x7B, 0x8E, 0x78, 0x3D, 0xC7,
  0xB8, 0x1E, 0xE3, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xDF,
  0x01, 0xE7, 0xC0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3,
  0xE0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0xC3, 0xC0,
  0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xF0, 0x78, 0x03, 0xEF, 0x80,
  0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF,
  0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x3B, 0xC3, 0x9C, 0x39, 0xC7, 0x1E, 0x70, 0xE7, 0x0E, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0xC0,
  0xFF, 0x87, 0xFF, 0x3F, 0x7E, 0xF0, 0x7B, 0xC1, 0xE0, 0x07, 0x83, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0xBF, 0xFE, 0xFF, 0xF9, 0xFF, 0xE1, 0xE7, 0xC0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3,
  0xDF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFB, 0xDF, 0xCF, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0xC3,
  0xFF, 0x9F, 0xFF, 0x78, 0x3D, 0xE0, 0xF7, 0x81, 0xFE, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x1D, 0xE0, 0xF7, 0x83, 0xDF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x9E, 0x3F,
  0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xBC, 0x3E, 0x78, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1F, 0xFE, 0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x81, 0x1F,
  0xBE, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xC3, 0xF1, 0xFC, 0x7F,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F,
  0xFE, 0x3F, 0xBC, 0x3E, 0x78, 0x00, 0xF0, 0x01, 0xE2, 0x07, 0xCF, 0xBF,
  0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xC0, 0x27, 0xBF, 0xF7, 0x00, 0x00, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00,
  0x3C, 0x78, 0xF0, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xFF, 0xFF, 0xFD, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7D, 0xE1, 0xF3,
  0xC7, 0xC7, 0x8F, 0x0F, 0x3E, 0x1E, 0xF8, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x07, 0xDE, 0x0F, 0x3E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xE1,
  0xF1, 0xEF, 0xE7, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x87, 0xC3,
  0xFE, 0x0F, 0x83, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F,
  0xE0, 0xF0, 0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xC0, 0xFF, 0x07, 0x81, 0xFE,
  0x0F, 0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xE0, 0x78, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFB, 0xDF,
  0xCF, 0x3E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0x83,
  0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F,
  0xBC, 0x3E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7D, 0xE0,
  0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3E, 0x00,
  0x7F, 0xC0, 0xF7, 0x83, 0xDF, 0x1F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xFC,
  0xFE, 0xF1, 0xF3, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0x9E, 0x1E, 0x78,
  0x79, 0xE1, 0xE3, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x81, 0xDE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC, 0x3E, 0x1E, 0xE1, 0xF0,
  0xF7, 0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE7, 0xF3, 0xCF, 0x3B, 0x9E, 0x39,
  0xDC, 0xE1, 0xEE, 0xE7, 0x0F, 0xF7, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x78,
  0x3C, 0x03, 0xC0, 0xE0, 0xF8, 0x7D, 0xE1, 0xE7, 0xC7, 0x8F, 0x3C, 0x3E,
  0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xCF, 0x0F, 0x3C, 0x78, 0x79, 0xE1, 0xFF,
  0x03, 0xC0, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x78, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x03,
  0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0xF0, 0xF8, 0xF8, 0x78, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x80,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3E, 0x0F, 0x83, 0xC3, 0xE3, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE1,
  0xE0, 0xE0, 0x60, 0x00, 0x1E, 0x00, 0x1F, 0x81, 0xDF, 0xE1, 0xEF, 0xF8,
  0xEF, 0x1F, 0xF7, 0x07, 0xFB, 0x83, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 8, 9, 12, 2, -27 },
  { 27, 16, 26, 19, 2, -26 },
  { 79, 14, 33, 18, 2, -30 },
  { 137, 19, 26, 23, 2, -26 },
  { 199, 18, 26, 20, 2, -26 },
  { 258, 4, 9, 6, 1, -27 },
  { 263, 9, 37, 11, 2, -29 },
  { 305, 8, 37, 12, 1, -29 },
  { 342, 16, 15, 16, 0, -26 },
  { 372, 15, 19, 17, 1, -21 },
  { 408, 5, 10, 8, 1, -4 },
  { 415, 8, 3, 11, 2, -12 },
  { 418, 5, 5, 10, 2, -5 },
  { 422, 12, 28, 13, 0, -26 },
  { 464, 14, 26, 18, 2, -26 },
  { 510, 9, 26, 18, 3, -26 },
  { 540, 16, 26, 18, 1, -26 },
  { 592, 15, 26, 18, 1, -26 },
  { 641, 16, 26, 18, 1, -26 },
  { 693, 14, 26, 18, 2, -26 },
  { 739, 14, 26, 18, 2, -26 },
  { 785, 15, 26, 18, 1, -26 },
  { 834, 14, 26, 18, 2, -26 },
  { 880, 14, 26, 18, 2, -26 },
  { 926, 5, 20, 9, 2, -20 },
  { 939, 6, 26, 8, 1, -20 },
  { 959, 13, 16, 16, 1, -19 },
  { 985, 13, 12, 18, 2, -18 },
  { 1005, 13, 16, 16, 2, -19 },
  { 1031, 13, 26, 16, 1, -26 },
  { 1074, 24, 33, 28, 2, -25 },
  { 1173, 20, 26, 21, 1, -26 },
  { 1238, 16, 26, 20, 2, -26 },
  { 1290, 17, 26, 20, 2, -26 },
  { 1346, 17, 26, 20, 2, -26 },
  { 1402, 15, 26, 18, 2, -26 },
  { 1451, 14, 26, 17, 2, -26 },
  { 1497, 17, 26, 21, 2, -26 },
  { 1553, 18, 26, 22, 2, -26 },
  { 1612, 4, 26, 9, 3, -26 },
  { 1625, 14, 26, 18, 1, -26 },
  { 1671, 18, 26, 20, 2, -26 },
  { 1730, 14, 26, 17, 2, -26 },
  { 1776, 23, 26, 27, 2, -26 },
  { 1851, 18, 26, 22, 2, -26 },
  { 1910, 18, 26, 22, 2, -26 },
  { 1969, 17, 26, 20, 2, -26 },
  { 2025, 18, 30, 22, 2, -26 },
  { 2093, 17, 26, 20, 2, -26 },
  { 2149, 17, 26, 19, 1, -26 },
  { 2205, 17, 26, 19, 1, -26 },
  { 2261, 16, 26, 20, 2, -26 },
  { 2313, 19, 26, 21, 1, -26 },
  { 2375, 25, 26, 27, 1, -26 },
  { 2457, 18, 26, 20, 1, -26 },
  { 2516, 19, 26, 19, 0, -26 },
  { 2578, 17, 26, 19, 1, -26 },
  { 2634, 7, 36, 9, 2, -30 },
  { 2666, 13, 28, 14, 1, -26 },
  { 2712, 6, 36, 9, 1, -30 },
  { 2739, 12, 13, 14, 1, -26 },
  { 2759, 14, 3, 14, 0, 0 },
  { 2765, 8, 5, 12, 1, -27 },
  { 2770, 14, 19, 17, 2, -19 },
  { 2804, 14, 27, 18, 2, -27 },
  { 2852, 14, 19, 17, 1, -19 },
  { 2886, 15, 27, 18, 1, -27 },
  { 2937, 14, 19, 17, 2, -19 },
  { 2971, 10, 27, 12, 1, -27 },
  { 3005, 15, 26, 18, 1, -19 },
  { 3054, 14, 27, 18, 2, -27 },
  { 3102, 5, 27, 9, 2, -27 },
  { 3119, 7, 34, 8, -1, -27 },
  { 3149, 15, 27, 17, 2, -27 },
  { 3200, 4, 27, 9, 2, -27 },
  { 3214, 23, 19, 27, 2, -19 },
  { 3269, 14, 19, 18, 2, -19 },
  { 3303, 16, 19, 18, 1, -19 },
  { 3341, 14, 26, 18, 2, -19 },
  { 3387, 15, 26, 18, 1, -19 },
  { 3436, 9, 19, 11, 2, -19 },
  { 3458, 14, 19, 16, 1, -19 },
  { 3492, 10, 24, 11, 0, -24 },
  { 3522, 14, 19, 18, 2, -19 },
  { 3556, 14, 19, 16, 1, -19 },
  { 3590, 21, 19, 23, 1, -19 },
  { 3640, 14, 19, 16, 1, -19 },
  { 3674, 15, 26, 16, 0, -19 },
  { 3723, 13, 19, 16, 2, -19 },
  { 3754, 9, 34, 11, 1, -28 },
  { 3793, 3, 31, 9, 3, -26 },
  { 3805, 9, 34, 11, 1, -28 },
  { 3844, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_Medium36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_MEDIUM36PT7B_H_
