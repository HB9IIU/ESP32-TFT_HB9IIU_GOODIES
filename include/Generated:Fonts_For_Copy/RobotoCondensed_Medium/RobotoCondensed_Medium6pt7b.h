#ifndef _ROBOTOCONDENSED_MEDIUM6PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x6B, 0x80, 0x55, 0x1E, 0x80, 0xE4, 0x63, 0xEB, 0xF0,
  0xC0, 0x6A, 0x90, 0xA5, 0x60, 0x48, 0x49, 0x20, 0xC0, 0x00, 0x80, 0x5A,
  0xF6, 0xA0, 0xD5, 0xE5, 0x70, 0xE4, 0xE0, 0x4B, 0x90, 0xD8, 0xB0, 0x5A,
  0xB0, 0x69, 0x20, 0xFE, 0xF0, 0xF5, 0xA0, 0x20, 0x30, 0x70, 0xFC, 0xC8,
  0x00, 0xD5, 0x7B, 0xFF, 0xC0, 0x4D, 0xD0, 0xFE, 0xF0, 0xF2, 0x30, 0xF6,
  0xF0, 0xDA, 0x70, 0xDA, 0x40, 0xF2, 0xB0, 0xBE, 0xD0, 0xF0, 0x24, 0xE0,
  0xBA, 0xD0, 0x92, 0x70, 0xDD, 0xBB, 0xBE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40,
  0xF6, 0xB0, 0xF7, 0xD0, 0xE8, 0xF0, 0x69, 0x20, 0xB6, 0xB0, 0xB5, 0xA0,
  0xBB, 0x55, 0xA9, 0x50, 0xA9, 0x20, 0x69, 0x70, 0xFC, 0xA5, 0xFC, 0x70,
  0xC0, 0x80, 0xFF, 0x80, 0x93, 0xDE, 0xF3, 0x00, 0x27, 0xDE, 0xFF, 0x80,
  0x6A, 0x80, 0xF7, 0xB0, 0x93, 0xDA, 0x70, 0x78, 0x93, 0x6A, 0xF8, 0xFB,
  0xB0, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xA8, 0xDC, 0xA9,
  0xB7, 0x80, 0xC9, 0x00, 0xDE, 0x60, 0x4B, 0x00, 0xC9, 0x20, 0x5C, 0x6A,
  0x90, 0x70, 0xA8, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 3, 2, 3, 0, -4 },
  { 18, 3, 4, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 1, 0, -3 },
  { 45, 2, 3, 3, 0, -3 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -3 },
  { 49, 2, 4, 3, 0, -4 },
  { 50, 4, 5, 5, 0, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 1, 4, 2, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 4, 4, 5, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 3, 5, 4, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 4, 4, 5, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 3, 4, 3, 0, -4 },
  { 104, 1, 6, 2, 0, -5 },
  { 105, 2, 4, 2, 0, -4 },
  { 106, 1, 6, 2, 0, -5 },
  { 107, 2, 2, 2, 0, -4 },
  { 108, 2, 1, 2, 0, 0 },
  { 109, 2, 1, 2, 0, -5 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 2, 5, 2, 0, -5 },
  { 122, 3, 4, 3, 0, -3 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 1, 4, 1, 0, -4 },
  { 127, 1, 5, 1, 0, -4 },
  { 128, 3, 5, 3, 0, -5 },
  { 130, 1, 5, 1, 0, -5 },
  { 131, 4, 3, 4, 0, -3 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 2, 3, 2, 0, -3 },
  { 142, 2, 3, 3, 0, -3 },
  { 143, 2, 4, 2, 0, -4 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 4, 3, 4, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 3, 4, 3, 0, -3 },
  { 154, 2, 3, 3, 0, -3 },
  { 155, 2, 6, 2, 0, -5 },
  { 157, 1, 5, 2, 0, -4 },
  { 158, 2, 6, 2, 0, -5 },
  { 160, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_Medium6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_MEDIUM6PT7B_H_
