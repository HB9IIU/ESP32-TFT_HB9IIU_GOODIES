#ifndef _ROBOTOCONDENSED_MEDIUM31PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x6F, 0xF6,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0xE6, 0xE6, 0x06, 0x30, 0x18, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x31, 0x80, 0xC6, 0x3F, 0xFF, 0xFF, 0xFC,
  0x73, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC3, 0xFF, 0xEF, 0xFF, 0x8E, 0x70,
  0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x79, 0xEF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0xFE, 0x00, 0xEE, 0x10, 0xC6,
  0x18, 0xC7, 0x38, 0xC7, 0x30, 0xC6, 0x70, 0xEE, 0x60, 0xFE, 0xE0, 0x3C,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06, 0x77, 0x0E,
  0xE3, 0x0C, 0xE3, 0x1C, 0xE3, 0x18, 0xE3, 0x18, 0x77, 0x00, 0x7E, 0x00,
  0x3C, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3C, 0xE0, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x3D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x3F,
  0x8E, 0x7F, 0x8E, 0x73, 0xCE, 0xF1, 0xFE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0,
  0x78, 0x78, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF,
  0x02, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x60, 0xE0,
  0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C,
  0x38, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7,
  0x0E, 0x1C, 0x70, 0xE1, 0x87, 0x1C, 0x30, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x86, 0x07, 0x33, 0xBF, 0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0xEE,
  0x07, 0x38, 0x70, 0xE0, 0x04, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x39, 0xCE, 0x73, 0x9D,
  0xCE, 0x20, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0x1F, 0x03, 0xFC, 0x7F, 0xCF, 0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0xC1, 0xF0, 0x01, 0x0F,
  0x3F, 0xFF, 0xFF, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xF0, 0x7F,
  0x83, 0xDE, 0x3C, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0,
  0x73, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F,
  0xCF, 0xFE, 0xF1, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xE0,
  0xFF, 0x0F, 0xF1, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x03, 0x80, 0xF8, 0x1F,
  0x83, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x78, 0xFF, 0xCF, 0xFE, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0x79,
  0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x1E, 0xF0,
  0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x87, 0xFC, 0xF1,
  0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF1, 0xE7, 0xFE, 0x7F,
  0xC1, 0xF0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x8F, 0x38, 0x39,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDC, 0x1E, 0xF1, 0xF3, 0xFF, 0x9F,
  0xF8, 0x3D, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x73,
  0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0x9D, 0xEE,
  0x20, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF1, 0xFC, 0xFE, 0x3F, 0x07, 0x80,
  0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xF8, 0x1F, 0x0F,
  0xE7, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0x07, 0xF9, 0xFF,
  0xFC, 0xFF, 0x0F, 0xE1, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xF1, 0xF0, 0x1E,
  0x01, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x07, 0x87,
  0x30, 0x7F, 0x1B, 0x87, 0x38, 0xD8, 0x71, 0xC6, 0xC3, 0x8C, 0x36, 0x38,
  0x61, 0xB1, 0xC3, 0x0F, 0x8E, 0x18, 0x7C, 0x70, 0xC3, 0xE3, 0x8E, 0x1B,
  0x1C, 0x70, 0xD8, 0xE3, 0x8C, 0xC7, 0xFC, 0xE6, 0x1F, 0x7E, 0x38, 0x71,
  0xE0, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE3, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7B, 0x80,
  0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x1E,
  0x1E, 0x07, 0x83, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0x01,
  0xC3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9C, 0x00, 0xF0, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xFC, 0xF0, 0x7B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x8F, 0xFE,
  0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0,
  0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF,
  0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0xC3, 0xCF, 0xFF,
  0x1F, 0xF8, 0x1F, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF9, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7,
  0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x78, 0x3C, 0x78, 0x78, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0x70, 0x7F, 0xEE, 0x0E, 0xFD, 0xE1, 0xDF, 0xDC, 0x3B, 0xFB,
  0x8E, 0x7F, 0x79, 0xCF, 0xE7, 0x39, 0xFC, 0xEE, 0x3F, 0x9D, 0xC7, 0xF1,
  0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1,
  0xC1, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xF7, 0x1F, 0xEE, 0x3F, 0xCE, 0x7F, 0x9C,
  0xFF, 0x1D, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xE3, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x79, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x01,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x1D, 0xE0, 0x79, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C,
  0x3E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF,
  0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xF3,
  0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xDE, 0x00, 0x7C,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0xC7, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38,
  0x38, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xF3,
  0x80, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x70, 0x3F, 0xC1,
  0xE0, 0xEF, 0x07, 0x83, 0x9C, 0x1E, 0x1E, 0x70, 0xF8, 0x79, 0xC3, 0xE1,
  0xE7, 0x8F, 0xC7, 0x1E, 0x3F, 0x1C, 0x78, 0xDC, 0x70, 0xE7, 0x73, 0xC3,
  0x9C, 0xCF, 0x0E, 0x73, 0xBC, 0x3D, 0xCE, 0xE0, 0xFE, 0x3B, 0x81, 0xF8,
  0xEE, 0x07, 0xE1, 0xB8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78,
  0x3C, 0xF8, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFC, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x1C, 0x07,
  0x81, 0xE0, 0xF8, 0x3F, 0x0D, 0xC7, 0x31, 0xCE, 0x73, 0xB8, 0x6E, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE0, 0xE1, 0xE0, 0x0F, 0x83,
  0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0x3F, 0xF7,
  0xCF, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xFF, 0x1E, 0x70,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFC,
  0xFF, 0xEF, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFF, 0x1F, 0xFF, 0xEE, 0xFC, 0xE7, 0x80, 0x0F,
  0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x70, 0x77, 0x8F, 0x7F, 0xE3, 0xFC, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7D,
  0xE7, 0xFF, 0x7F, 0xFB, 0xC7, 0xDC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xF1, 0xF7, 0xFF, 0x9F,
  0xFC, 0x7D, 0xE0, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38,
  0x3B, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x18, 0xFF, 0xC7, 0xFE, 0x0F, 0xC0, 0x0F, 0x8F, 0xCF, 0xE7, 0x83,
  0xC1, 0xC3, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0x79, 0xFF,
  0xDF, 0xFE, 0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F,
  0x78, 0x03, 0xC0, 0x1E, 0x61, 0xE3, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0x7E, 0xFF, 0xFE,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0x6F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x38, 0x78, 0xE0, 0x00,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3B, 0xF7, 0xCF, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x1E, 0xE3, 0xCE, 0x78,
  0xE7, 0x8E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x78,
  0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9F, 0xFB,
  0xFB, 0xFF, 0xFF, 0xF8, 0xF8, 0xFE, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8, 0x38,
  0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70,
  0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0,
  0xE0, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xE0, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xF7, 0x07, 0xBC, 0x78,
  0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0xE7, 0x8F, 0xFC, 0xFF, 0xEF, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFF, 0x1E, 0xFF, 0xEE, 0xFC, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xF1, 0xF7, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7,
  0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xEF, 0xDF, 0xFF, 0xFF, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x0F, 0x83, 0xFC,
  0x7F, 0xE7, 0x0E, 0x70, 0xF7, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x1C,
  0x1C, 0x1C, 0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xE3, 0xFF, 0xFB, 0xFF, 0x3E, 0xE0, 0xE0, 0xFF, 0x0F, 0xF0, 0xE7,
  0x0E, 0x71, 0xE7, 0x1E, 0x79, 0xC3, 0x9C, 0x39, 0xC3, 0xB8, 0x3F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE1, 0xC1, 0xF8,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0xFC, 0xE7, 0x3F,
  0x39, 0xCF, 0xDE, 0x7B, 0x37, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x0E, 0x00,
  0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9C, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0xC7, 0x9C, 0x79, 0xEF, 0x0E,
  0xF0, 0xF0, 0x70, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE3, 0x8F, 0x1C, 0x70,
  0xF3, 0x83, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0xF8, 0xE0, 0xF0, 0x78, 0x38,
  0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xC3, 0xC3, 0x87, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC3, 0xC3, 0x8F, 0x3C, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x18, 0x00, 0x3C, 0x1D,
  0xF8, 0x7F, 0xF1, 0xF9, 0xFE, 0xE3, 0xF8, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 14, 22, 17, 2, -22 },
  { 59, 12, 28, 16, 2, -25 },
  { 101, 16, 22, 20, 2, -22 },
  { 145, 16, 22, 17, 1, -22 },
  { 189, 3, 8, 5, 1, -23 },
  { 192, 7, 32, 10, 2, -25 },
  { 220, 7, 32, 10, 1, -25 },
  { 248, 13, 13, 14, 0, -22 },
  { 270, 13, 16, 15, 1, -18 },
  { 296, 5, 9, 7, 0, -4 },
  { 302, 7, 3, 10, 1, -11 },
  { 305, 4, 4, 9, 2, -4 },
  { 307, 10, 24, 11, 0, -22 },
  { 337, 12, 22, 16, 2, -22 },
  { 370, 8, 22, 16, 2, -22 },
  { 392, 13, 22, 16, 1, -22 },
  { 428, 13, 22, 16, 1, -22 },
  { 464, 14, 22, 16, 1, -22 },
  { 503, 12, 22, 16, 2, -22 },
  { 536, 12, 22, 16, 2, -22 },
  { 569, 13, 22, 16, 1, -22 },
  { 605, 12, 22, 16, 2, -22 },
  { 638, 13, 22, 16, 1, -22 },
  { 674, 4, 17, 8, 2, -17 },
  { 683, 5, 22, 7, 1, -17 },
  { 697, 11, 15, 14, 1, -17 },
  { 718, 11, 10, 15, 2, -15 },
  { 732, 11, 14, 14, 2, -17 },
  { 752, 11, 22, 14, 1, -22 },
  { 783, 21, 29, 24, 1, -22 },
  { 860, 18, 22, 18, 0, -22 },
  { 910, 14, 22, 17, 2, -22 },
  { 949, 14, 22, 18, 2, -22 },
  { 988, 14, 22, 18, 2, -22 },
  { 1027, 12, 22, 15, 2, -22 },
  { 1060, 12, 22, 15, 2, -22 },
  { 1093, 14, 22, 18, 2, -22 },
  { 1132, 15, 22, 19, 2, -22 },
  { 1174, 4, 22, 8, 2, -22 },
  { 1185, 12, 22, 15, 1, -22 },
  { 1218, 15, 22, 17, 2, -22 },
  { 1260, 12, 22, 15, 2, -22 },
  { 1293, 19, 22, 23, 2, -22 },
  { 1346, 15, 22, 19, 2, -22 },
  { 1388, 15, 22, 19, 2, -22 },
  { 1430, 14, 22, 17, 2, -22 },
  { 1469, 15, 26, 19, 2, -22 },
  { 1518, 14, 22, 17, 2, -22 },
  { 1557, 14, 22, 16, 1, -22 },
  { 1596, 15, 22, 17, 1, -22 },
  { 1638, 14, 22, 18, 2, -22 },
  { 1677, 17, 22, 18, 0, -22 },
  { 1724, 22, 22, 23, 1, -22 },
  { 1785, 16, 22, 17, 1, -22 },
  { 1829, 16, 22, 17, 0, -22 },
  { 1873, 14, 22, 16, 1, -22 },
  { 1912, 5, 30, 8, 2, -25 },
  { 1931, 12, 24, 12, 0, -22 },
  { 1967, 6, 30, 8, 0, -25 },
  { 1990, 10, 11, 12, 1, -22 },
  { 2004, 12, 3, 12, 0, 0 },
  { 2009, 7, 5, 10, 1, -24 },
  { 2014, 12, 17, 15, 1, -17 },
  { 2040, 12, 23, 15, 2, -23 },
  { 2075, 12, 17, 14, 1, -17 },
  { 2101, 13, 23, 15, 1, -23 },
  { 2139, 13, 17, 15, 1, -17 },
  { 2167, 9, 23, 10, 1, -23 },
  { 2193, 13, 23, 15, 1, -17 },
  { 2231, 11, 23, 15, 2, -23 },
  { 2263, 4, 23, 8, 2, -23 },
  { 2275, 7, 29, 7, -1, -23 },
  { 2301, 12, 23, 14, 2, -23 },
  { 2336, 4, 23, 8, 2, -23 },
  { 2348, 19, 17, 23, 2, -17 },
  { 2389, 11, 17, 15, 2, -17 },
  { 2413, 13, 17, 15, 1, -17 },
  { 2441, 12, 23, 15, 2, -17 },
  { 2476, 13, 23, 15, 1, -17 },
  { 2514, 7, 17, 10, 2, -17 },
  { 2529, 12, 17, 14, 1, -17 },
  { 2555, 8, 20, 9, 0, -20 },
  { 2575, 11, 17, 15, 2, -17 },
  { 2599, 12, 17, 14, 1, -17 },
  { 2625, 18, 17, 20, 1, -17 },
  { 2664, 12, 17, 14, 1, -17 },
  { 2690, 13, 23, 13, 0, -17 },
  { 2728, 12, 17, 14, 1, -17 },
  { 2754, 8, 30, 9, 1, -24 },
  { 2784, 2, 26, 8, 3, -22 },
  { 2791, 7, 30, 9, 1, -24 },
  { 2818, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Medium31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_MEDIUM31PT7B_H_
