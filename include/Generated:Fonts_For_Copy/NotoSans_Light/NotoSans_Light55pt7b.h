#ifndef _NOTOSANS_LIGHT55PT7B_H_
#define _NOTOSANS_LIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x00, 0x00, 0x00, 0x1C, 0xFF,
  0xFD, 0xE4, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x1F, 0x18, 0x7C, 0x3C, 0x18, 0x04, 0x78, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x78, 0x18, 0x00, 0x7C, 0x18, 0x00, 0x3E, 0x18,
  0x00, 0x1F, 0x98, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1B, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x18,
  0x1E, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x0F, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0x1E, 0x70, 0x18, 0x7C, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00,
  0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x01, 0xC1, 0xE0,
  0x00, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x06,
  0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x06, 0x0E, 0x0F, 0xC1, 0xC0, 0x1C, 0x38, 0x7F, 0xC1, 0x80,
  0x38, 0x71, 0xF3, 0xC3, 0x80, 0x71, 0xC3, 0x81, 0xC7, 0x01, 0xC3, 0x8E,
  0x01, 0x87, 0x07, 0x8E, 0x1C, 0x03, 0x87, 0xFE, 0x1C, 0x30, 0x07, 0x07,
  0xF8, 0x70, 0xE0, 0x06, 0x07, 0xC0, 0xE1, 0xC0, 0x0C, 0x00, 0x03, 0x83,
  0x80, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x80,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0xE1, 0xE0, 0x0F, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0x03, 0x8F, 0x00, 0x0F, 0x00, 0xE1, 0xC0, 0x00, 0xF0,
  0x1C, 0x78, 0x00, 0x0F, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xE1, 0xC0, 0x00,
  0x0F, 0x3C, 0x38, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x0F, 0xF0,
  0x1E, 0x00, 0x03, 0xCF, 0x03, 0xE0, 0x01, 0xF0, 0xF0, 0x3F, 0x87, 0xFC,
  0x0F, 0x03, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x18, 0x07,
  0xFC, 0x18, 0x3F, 0xFF, 0x99, 0xFF, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0xF8, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x73, 0xFF, 0xF7, 0x90, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0xF7, 0x07, 0x9C, 0x7C, 0x73,
  0xC1, 0xFE, 0x07, 0x70, 0x1C, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x07, 0x81, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x90, 0x00, 0x03, 0xCE, 0x00, 0x07, 0xC7, 0xF0,
  0x1F, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x38, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xE0, 0x08, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x7F, 0xE0, 0x1C, 0x7F,
  0xFE, 0x07, 0x3E, 0x0F, 0xC1, 0xDC, 0x00, 0x78, 0xFE, 0x00, 0x0F, 0x3F,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0xF0,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x38, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3,
  0xE0, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x07, 0x81, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xDC, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xF3, 0xC0, 0x03, 0xB8, 0xF0, 0x03,
  0x9C, 0x3F, 0xFF, 0x8E, 0x0F, 0xFF, 0x87, 0x01, 0xFE, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x01,
  0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x33, 0xFF, 0xF7, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xBC, 0x80, 0x0C, 0x3C, 0xF9,
  0xF1, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E,
  0x38, 0x70, 0xE1, 0x87, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xF8, 0x0F, 0xC6, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0xFC, 0x00, 0xE3,
  0x80, 0x07, 0xFF, 0xE0, 0x1C, 0x70, 0x03, 0xF0, 0x7C, 0x03, 0x9C, 0x00,
  0xF0, 0x03, 0x00, 0x33, 0x80, 0x3C, 0x00, 0x60, 0x07, 0x70, 0x07, 0x00,
  0x0C, 0x00, 0xEC, 0x01, 0xC0, 0x01, 0x80, 0x1F, 0x80, 0x38, 0x00, 0x70,
  0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xC0, 0x0F,
  0xC0, 0x38, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xDC, 0x03, 0x80,
  0x03, 0x80, 0x3B, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x70, 0x07, 0x00, 0x1E,
  0x00, 0xCE, 0x00, 0xE0, 0x07, 0xE0, 0x38, 0xC0, 0x0E, 0x01, 0xDC, 0x0E,
  0x1C, 0x00, 0xF8, 0xF1, 0xE7, 0x83, 0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x30,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x78, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x3E,
  0x01, 0xF0, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x10, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xE8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7E, 0x07, 0x80,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x60,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x78,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x5C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x72, 0x07, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x03,
  0xDF, 0xC0, 0x00, 0x7F, 0xBC, 0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xF8, 0x3C,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xDC, 0x00, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0x80,
  0x00, 0x01, 0xDF, 0x9C, 0x00, 0x00, 0x0E, 0xFC, 0xE0, 0x00, 0x00, 0x77,
  0xF3, 0x80, 0x00, 0x07, 0x3F, 0x9C, 0x00, 0x00, 0x39, 0xFC, 0xF0, 0x00,
  0x03, 0x8F, 0xE3, 0x80, 0x00, 0x1C, 0x7F, 0x1C, 0x00, 0x00, 0xE3, 0xF8,
  0x70, 0x00, 0x0E, 0x1F, 0xC3, 0x80, 0x00, 0x70, 0xFE, 0x1E, 0x00, 0x07,
  0x07, 0xF0, 0x70, 0x00, 0x38, 0x3F, 0x83, 0x80, 0x01, 0xC1, 0xFC, 0x0E,
  0x00, 0x1C, 0x0F, 0xE0, 0x70, 0x00, 0xE0, 0x7F, 0x03, 0xC0, 0x0E, 0x03,
  0xF8, 0x0E, 0x00, 0x70, 0x1F, 0xC0, 0x70, 0x03, 0x80, 0xFE, 0x03, 0xC0,
  0x38, 0x07, 0xF0, 0x0E, 0x01, 0xC0, 0x3F, 0x80, 0x70, 0x1C, 0x01, 0xFC,
  0x01, 0xC0, 0xE0, 0x0F, 0xE0, 0x0E, 0x07, 0x00, 0x7F, 0x00, 0x78, 0x70,
  0x03, 0xF8, 0x01, 0xC3, 0x80, 0x1F, 0xC0, 0x0E, 0x3C, 0x00, 0xFE, 0x00,
  0x39, 0xC0, 0x07, 0xF0, 0x01, 0xCE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x7E, 0x70,
  0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x1F, 0x87, 0x00,
  0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xF0, 0x70, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xFC, 0x07, 0x00, 0x07,
  0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x70, 0x01, 0xFC,
  0x01, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x7F, 0x00,
  0x1E, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x70, 0x1F, 0xC0, 0x01,
  0xE0, 0x7F, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x1E,
  0x1F, 0xC0, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x01, 0xE7,
  0xF0, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0x07, 0x7F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x78,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0x04, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x7C, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x1E, 0x00,
  0x07, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0xE1, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x01, 0xC0, 0x07,
  0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x01,
  0xE0, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x07,
  0x0E, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x70,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x18, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC7, 0xFE, 0x07, 0x3F, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1D, 0xDF, 0x03,
  0xE7, 0x3F, 0xFF, 0x1C, 0x3F, 0xF0, 0x30, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0xF0, 0x07, 0x0F, 0xFF, 0x03, 0x8F, 0xFF, 0xC1, 0xCF, 0x01, 0xF0,
  0xEE, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xCF, 0x80, 0x01, 0xE7, 0xE0, 0x01, 0xE3, 0xB8, 0x01, 0xF1,
  0x8F, 0x03, 0xF0, 0xC3, 0xFF, 0xE0, 0x60, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0x70,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x02,
  0x1F, 0xE1, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0xF0, 0x38, 0x0F, 0xFE, 0x1C, 0x1F, 0xFF, 0xCE, 0x1F, 0x00,
  0xF7, 0x1F, 0x00, 0x3B, 0x9E, 0x00, 0x0F, 0xCF, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0xEE, 0x1F, 0x81, 0xE7, 0x07, 0xFF, 0xE3, 0x80, 0xFF, 0xE0, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F,
  0x80, 0xF8, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x06, 0x07,
  0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x05, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE1, 0xC1, 0xFF, 0xFC,
  0xE1, 0xF0, 0x0F, 0x71, 0xF0, 0x01, 0xB8, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x0F,
  0xC7, 0xC0, 0x0E, 0xE1, 0xF8, 0x1E, 0x70, 0x7F, 0xFE, 0x38, 0x0F, 0xFC,
  0x1C, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x80, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xF0, 0x1C, 0x3F, 0xFC, 0x38, 0xFF,
  0xFC, 0x73, 0xC0, 0x7C, 0xEE, 0x00, 0x3D, 0xF8, 0x00, 0x3B, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x77, 0xBE, 0xE6, 0x00, 0x00,
  0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0xE0, 0x1E, 0x01,
  0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x78,
  0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xE0,
  0x3C, 0x03, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0,
  0x03, 0x8F, 0x00, 0x0E, 0x7C, 0x00, 0x3B, 0xB8, 0x00, 0xFC, 0xF0, 0x03,
  0xE1, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0xC1, 0xFF, 0x80,
  0x7F, 0xF0, 0xE7, 0xFF, 0xE1, 0xFF, 0xF8, 0xEF, 0x01, 0xF3, 0xC0, 0x7C,
  0xEC, 0x00, 0xF7, 0x80, 0x3C, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0xF8, 0x00,
  0x7E, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3F,
  0x01, 0x83, 0xFF, 0xC3, 0x8F, 0xFF, 0xC7, 0x3C, 0x07, 0xCE, 0xE0, 0x03,
  0xDF, 0x80, 0x03, 0xBE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x60, 0xFF, 0xF0,
  0x38, 0xFF, 0xFC, 0x1C, 0xF0, 0x1F, 0x0E, 0xE0, 0x03, 0xC7, 0xE0, 0x00,
  0xF3, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1E,
  0x7E, 0x00, 0x1E, 0x3B, 0x80, 0x1F, 0x1C, 0xF0, 0x3F, 0x0E, 0x3F, 0xFF,
  0x07, 0x07, 0xFE, 0x03, 0x80, 0x20, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xF0, 0x0F, 0x71, 0xE0, 0x03,
  0xB9, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0x38, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xC7, 0x80, 0x0E, 0xE1, 0xF8, 0x3E,
  0x70, 0x7F, 0xFE, 0x38, 0x0F, 0xFC, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x81, 0xEE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xC0, 0x1E, 0x70, 0x00,
  0x2F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC1, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x30, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x37, 0x3C,
  0x00, 0x77, 0x1F, 0x03, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF, 0x07, 0x00,
  0x20, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1E, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x39, 0xC0,
  0x01, 0xF0, 0x00, 0x73, 0x80, 0x03, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x03, 0x8F, 0x00, 0x1D, 0xC0, 0x07, 0x0E, 0x00, 0x3B, 0x80, 0x0E, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x38, 0x03, 0x8E,
  0x00, 0xE0, 0x70, 0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x0F, 0x0E, 0x01, 0xC1, 0xC0,
  0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x00, 0xE6, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x80,
  0xF0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x81, 0xC0,
  0x01, 0xC1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0xBF, 0xFE, 0x00, 0x7C, 0x3F, 0xC0, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 40, 14, 4, -39 },
  { 26, 12, 14, 20, 4, -39 },
  { 47, 33, 39, 36, 1, -39 },
  { 208, 24, 45, 31, 3, -42 },
  { 343, 39, 41, 45, 3, -40 },
  { 543, 35, 41, 39, 3, -40 },
  { 723, 3, 14, 11, 4, -39 },
  { 729, 11, 48, 15, 2, -39 },
  { 795, 11, 48, 15, 2, -39 },
  { 861, 24, 24, 30, 3, -42 },
  { 933, 25, 26, 31, 3, -32 },
  { 1015, 7, 13, 12, 2, -6 },
  { 1027, 14, 3, 18, 2, -16 },
  { 1033, 5, 6, 13, 4, -5 },
  { 1037, 17, 39, 19, 1, -39 },
  { 1120, 25, 41, 31, 3, -40 },
  { 1249, 14, 39, 31, 5, -39 },
  { 1318, 25, 40, 31, 3, -40 },
  { 1443, 25, 41, 31, 3, -40 },
  { 1572, 30, 39, 31, 1, -39 },
  { 1719, 24, 40, 31, 4, -39 },
  { 1839, 26, 41, 31, 3, -40 },
  { 1973, 25, 39, 31, 3, -39 },
  { 2095, 25, 41, 31, 3, -40 },
  { 2224, 25, 41, 31, 3, -40 },
  { 2353, 5, 31, 13, 4, -30 },
  { 2373, 7, 37, 13, 2, -30 },
  { 2406, 25, 26, 31, 3, -33 },
  { 2488, 25, 13, 31, 3, -26 },
  { 2529, 25, 26, 31, 3, -33 },
  { 2611, 21, 41, 23, 1, -40 },
  { 2719, 43, 44, 49, 3, -39 },
  { 2956, 33, 39, 33, 0, -39 },
  { 3117, 27, 39, 35, 5, -39 },
  { 3249, 30, 41, 34, 3, -40 },
  { 3403, 31, 39, 39, 5, -39 },
  { 3555, 22, 39, 30, 5, -39 },
  { 3663, 22, 39, 28, 5, -39 },
  { 3771, 33, 41, 40, 3, -40 },
  { 3941, 29, 39, 40, 5, -39 },
  { 4083, 11, 39, 17, 3, -39 },
  { 4137, 14, 49, 14, -5, -39 },
  { 4223, 27, 39, 32, 5, -39 },
  { 4355, 22, 39, 28, 5, -39 },
  { 4463, 37, 39, 48, 5, -39 },
  { 4644, 30, 39, 40, 5, -39 },
  { 4791, 36, 41, 42, 3, -40 },
  { 4976, 24, 39, 32, 5, -39 },
  { 5093, 36, 49, 42, 3, -40 },
  { 5314, 27, 39, 33, 5, -39 },
  { 5446, 24, 41, 30, 3, -40 },
  { 5569, 29, 39, 29, 0, -39 },
  { 5711, 30, 40, 40, 5, -39 },
  { 5861, 32, 39, 32, 0, -39 },
  { 6017, 47, 39, 50, 1, -39 },
  { 6247, 30, 39, 30, 0, -39 },
  { 6394, 29, 39, 29, 0, -39 },
  { 6536, 27, 39, 32, 2, -39 },
  { 6668, 11, 48, 18, 5, -39 },
  { 6734, 17, 39, 19, 1, -39 },
  { 6817, 12, 48, 18, 1, -39 },
  { 6889, 27, 25, 31, 2, -40 },
  { 6974, 23, 2, 23, 0, 5 },
  { 6980, 10, 9, 15, 2, -42 },
  { 6992, 22, 31, 29, 3, -30 },
  { 7078, 25, 43, 33, 5, -42 },
  { 7213, 21, 31, 26, 3, -30 },
  { 7295, 25, 43, 33, 3, -42 },
  { 7430, 24, 31, 30, 3, -30 },
  { 7523, 19, 42, 17, 1, -42 },
  { 7623, 25, 43, 33, 3, -30 },
  { 7758, 23, 42, 33, 5, -42 },
  { 7879, 5, 40, 13, 4, -40 },
  { 7904, 12, 53, 13, -3, -40 },
  { 7984, 22, 42, 27, 5, -42 },
  { 8100, 3, 42, 13, 5, -42 },
  { 8116, 40, 30, 49, 5, -30 },
  { 8266, 23, 30, 33, 5, -30 },
  { 8353, 26, 31, 32, 3, -30 },
  { 8454, 25, 43, 33, 5, -30 },
  { 8589, 25, 43, 33, 3, -30 },
  { 8724, 16, 30, 22, 5, -30 },
  { 8784, 20, 31, 26, 3, -30 },
  { 8862, 16, 37, 19, 1, -36 },
  { 8936, 24, 30, 33, 4, -29 },
  { 9026, 26, 29, 26, 0, -29 },
  { 9121, 39, 29, 40, 1, -29 },
  { 9263, 25, 29, 28, 1, -29 },
  { 9354, 26, 42, 26, 0, -29 },
  { 9491, 21, 29, 25, 2, -29 },
  { 9568, 17, 48, 20, 1, -39 },
  { 9670, 2, 56, 30, 14, -42 },
  { 9684, 16, 48, 20, 2, -39 },
  { 9780, 25, 6, 31, 3, -22 },
};

const GFXfont NotoSans_Light55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light55pt7bBitmaps,
  (GFXglyph *)NotoSans_Light55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_LIGHT55PT7B_H_
