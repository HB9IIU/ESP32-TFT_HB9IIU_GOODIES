#ifndef _NOTOSANS_LIGHT34PT7B_H_
#define _NOTOSANS_LIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x01, 0xBF, 0xC3, 0xC3,
  0xC3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x43, 0x00, 0x81, 0x80, 0x18, 0x10,
  0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x10, 0x30, 0x03, 0x03,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00,
  0x81, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0xFF, 0xC3, 0x97, 0xCC, 0x20, 0xB0, 0x40, 0x60, 0x80, 0xC1, 0x01,
  0x82, 0x01, 0x84, 0x03, 0x88, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x9C, 0x01, 0x0C, 0x02, 0x1C, 0x04, 0x18, 0x08, 0x30, 0x10, 0x60, 0x21,
  0xB0, 0x47, 0x7F, 0xFC, 0x3F, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x63, 0x00, 0x40, 0xC1, 0x80, 0xC0,
  0xC1, 0x80, 0x80, 0xC0, 0x81, 0x80, 0xC0, 0x83, 0x00, 0xC0, 0xC3, 0x00,
  0xC0, 0xC6, 0x00, 0xC0, 0x86, 0x00, 0xC0, 0x8C, 0x78, 0xC1, 0x88, 0xFC,
  0x41, 0x99, 0x86, 0x63, 0x11, 0x06, 0x3F, 0x33, 0x02, 0x1C, 0x63, 0x03,
  0x00, 0x63, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3, 0x03, 0x01, 0x83, 0x03,
  0x01, 0x03, 0x03, 0x03, 0x01, 0x02, 0x02, 0x01, 0x86, 0x06, 0x01, 0xCC,
  0x0C, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xC3, 0x80, 0x06,
  0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x07,
  0x00, 0x18, 0x18, 0x00, 0x31, 0xC0, 0x00, 0x6E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x73, 0x00, 0x67, 0x06, 0x03, 0x18, 0x0C, 0x0C, 0xC0,
  0x18, 0x33, 0x00, 0x31, 0x8C, 0x00, 0x66, 0x30, 0x00, 0xF0, 0xC0, 0x01,
  0x83, 0x80, 0x0F, 0x07, 0x00, 0xE6, 0x0F, 0xBF, 0x0C, 0x1F, 0xF0, 0x1C,
  0xFD, 0x55, 0x40, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC1, 0x83, 0x03, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x0C, 0x18, 0x30, 0xC3, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x18, 0x21, 0xFE, 0x5F, 0x8F, 0xF8, 0x03, 0x80,
  0x0D, 0x00, 0x33, 0x00, 0x63, 0x01, 0x87, 0x07, 0x07, 0x04, 0x08, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x33, 0x66, 0x6C,
  0xFF, 0xFF, 0xC0, 0xDF, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x18, 0x38, 0x30, 0x1C, 0x60, 0x0C,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x0C, 0x30, 0x18,
  0x1E, 0x78, 0x0F, 0xE0, 0x03, 0x0F, 0x1D, 0x39, 0xE1, 0x41, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x00, 0x3F, 0xC1, 0xE1, 0xE7, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x7F, 0xE3, 0xC0, 0xE6, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xA0, 0x07, 0x7C, 0xFC,
  0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xCF, 0x81, 0xFF, 0xC1, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xD0,
  0x03, 0xBE, 0x3E, 0x3F, 0xF0, 0x00, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x06, 0x38, 0x0C, 0x1E, 0x78, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xE0,
  0xE3, 0x80, 0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x60, 0x0C,
  0x60, 0x30, 0x71, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0x8E, 0x0C, 0x07, 0x30,
  0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xD8, 0x03, 0x1E, 0x3C, 0x1F, 0xF0, 0x03, 0x00, 0x3F, 0xC0, 0xE0, 0xE3,
  0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xEE, 0x06, 0xCF, 0xF9, 0x87, 0xC3,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x1C, 0x20, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFC,
  0x39, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x33, 0x18,
  0xC4, 0x60, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x06, 0x0F,
  0xFC, 0xE0, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80,
  0xFF, 0x83, 0x60, 0x70, 0x60, 0xF0, 0x30, 0x18, 0x3C, 0x0C, 0x06, 0x07,
  0x06, 0x01, 0x81, 0xC1, 0x80, 0x60, 0x70, 0x60, 0x10, 0x1C, 0x18, 0x04,
  0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x78, 0x6C, 0x0E,
  0x33, 0x31, 0x01, 0xF8, 0xF8, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x34, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xFF, 0xF8, 0x60, 0x7E, 0x30,
  0x03, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x06, 0x60, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x0C, 0x01, 0xE6, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x6C, 0x00, 0x76, 0x00, 0x73, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0xFF, 0xF0, 0x78, 0x1C, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x3F, 0x83,
  0x00, 0x3C, 0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x07, 0x60, 0x01, 0xCC, 0x00, 0x71, 0x80, 0x3C, 0x3F,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x07, 0x80, 0xE0,
  0xE0, 0x02, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x37, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0E,
  0x00, 0x30, 0x7F, 0x7F, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x7F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0xFE, 0xFC, 0xC0, 0x03, 0xE0, 0x03, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x03, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63,
  0x00, 0x33, 0x80, 0x1B, 0xE0, 0x0F, 0x38, 0x07, 0x0C, 0x03, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x06, 0x18, 0x03, 0x8C, 0x00,
  0xC6, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x40, 0x00, 0x7E, 0xC0, 0x00,
  0xFD, 0x80, 0x03, 0x79, 0x80, 0x06, 0xF3, 0x00, 0x09, 0xE6, 0x00, 0x33,
  0xC6, 0x00, 0x67, 0x8C, 0x01, 0x8F, 0x0C, 0x03, 0x1E, 0x18, 0x04, 0x3C,
  0x30, 0x18, 0x78, 0x30, 0x30, 0xF0, 0x60, 0xC1, 0xE0, 0x61, 0x83, 0xC0,
  0xC3, 0x07, 0x81, 0x8C, 0x0F, 0x01, 0x98, 0x1E, 0x03, 0x60, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x0C, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x1C,
  0x60, 0x07, 0x1C, 0x01, 0xC3, 0x00, 0x70, 0x60, 0x1C, 0x1C, 0x07, 0x03,
  0x01, 0xC0, 0x60, 0x70, 0x1C, 0x1C, 0x03, 0x07, 0x00, 0x61, 0xC0, 0x1C,
  0x70, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x1D, 0xC0, 0x03, 0x70, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x3C,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30,
  0x00, 0x30, 0x60, 0x01, 0xC1, 0xE0, 0x0E, 0x01, 0xF3, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xE1, 0x83, 0xF3, 0x00, 0x76, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0xEF,
  0xFF, 0x1F, 0xF8, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0xE0,
  0x0E, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0xFF, 0xF0, 0x60, 0xFC, 0x30, 0x07, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x07, 0x18,
  0x0F, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0x01, 0x81, 0x80, 0xE0, 0xC0, 0x30,
  0x60, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00,
  0x1D, 0x80, 0x07, 0x01, 0x80, 0x3F, 0xF8, 0xE0, 0x73, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xA0, 0x07, 0x7E, 0x7C,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x01, 0x8E, 0x00, 0xC1, 0xFB, 0xE0,
  0x1F, 0xF0, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x38, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x19, 0x80, 0x01,
  0x98, 0x00, 0x1B, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x38, 0x01, 0x98, 0x03, 0xC0,
  0x0C, 0xC0, 0x1E, 0x00, 0x66, 0x00, 0xD8, 0x03, 0x30, 0x04, 0xC0, 0x30,
  0xC0, 0x66, 0x01, 0x86, 0x03, 0x10, 0x0C, 0x30, 0x18, 0xC0, 0xC1, 0x81,
  0x86, 0x06, 0x06, 0x0C, 0x30, 0x30, 0x30, 0x60, 0xC1, 0x81, 0x82, 0x06,
  0x18, 0x0C, 0x30, 0x30, 0xC0, 0x31, 0x80, 0x86, 0x01, 0x8C, 0x06, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0x36, 0x01, 0x98, 0x01, 0xB0, 0x06, 0xC0, 0x0D,
  0x80, 0x34, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0C,
  0x0C, 0x03, 0x80, 0xC0, 0x60, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x60, 0x00, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x77,
  0x00, 0x07, 0xE0, 0x00, 0xD8, 0x00, 0x67, 0x00, 0x18, 0xC0, 0x0C, 0x18,
  0x07, 0x06, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0xE0, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0xFE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x58, 0x00, 0x64, 0x00, 0x23, 0x00, 0x30,
  0x80, 0x10, 0x60, 0x18, 0x10, 0x08, 0x0C, 0x0C, 0x02, 0x04, 0x01, 0x86,
  0x00, 0x42, 0x00, 0x33, 0x00, 0x0B, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0x1F, 0xE3, 0xC3, 0x88, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x0F, 0x1F, 0xFB, 0xC0, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0D, 0x71, 0xC9, 0xFC, 0x40, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xCF, 0xF1, 0xB8, 0xF3, 0xC0, 0x77, 0x00, 0x6E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0x78, 0x0E, 0xDE, 0x79, 0x9F, 0xC0,
  0x0F, 0xF8, 0xF1, 0xCE, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x1E, 0x78, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0xE6, 0x78,
  0x64, 0xC0, 0x2B, 0x00, 0x76, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xD8,
  0x03, 0xB8, 0x05, 0x3E, 0x72, 0x1F, 0xC4, 0x0F, 0xE0, 0x38, 0x70, 0xC0,
  0x73, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C,
  0x01, 0x1F, 0x3C, 0x1F, 0xF0, 0x01, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xE2, 0x78, 0x74,
  0xC0, 0x2B, 0x00, 0x76, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0x98, 0x0F, 0x3E, 0x76, 0x1F, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xA0, 0x0E, 0x7F, 0xF8, 0x3F, 0xC0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xCF,
  0xF3, 0x70, 0xEF, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x10, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0xFE, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3B, 0x01,
  0xCC, 0x0E, 0x30, 0x70, 0xC1, 0x83, 0x0C, 0x0C, 0x60, 0x33, 0x00, 0xDE,
  0x03, 0xD8, 0x0E, 0x30, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x06, 0x30,
  0x0C, 0xC0, 0x3B, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xCF, 0xE1, 0xFC, 0x6C, 0x39, 0xC7, 0x3C, 0x0F, 0x80, 0xDC, 0x03, 0x80,
  0x6C, 0x01, 0xC0, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x30,
  0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x03,
  0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07, 0x80,
  0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xC0, 0xCF, 0xF3, 0x70,
  0xEF, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x10, 0x0F, 0xF0, 0x1C, 0x38, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x1E, 0x78, 0x0F, 0xF0, 0xCF, 0xF1, 0xB8, 0x73, 0xC0, 0x77, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0x78, 0x0E, 0xDC,
  0x79, 0x9F, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0xE2, 0x78, 0xE4, 0xC0, 0x2B,
  0x00, 0x76, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0xB8, 0x0F,
  0x3C, 0x76, 0x1F, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0xCF, 0xF7, 0x9F, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F, 0xF7, 0x07, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0xF0, 0xEF, 0xFC, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x0F, 0xFE, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xE2, 0x0F, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xD8, 0x0F, 0x78, 0xE4, 0xFF, 0x10,
  0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0xE0, 0x1C, 0x03, 0xB0, 0x0E, 0x01, 0x98, 0x07, 0x00, 0xCC, 0x02, 0xC0,
  0x63, 0x03, 0x60, 0x61, 0x81, 0x90, 0x30, 0xC0, 0x8C, 0x18, 0x30, 0xC6,
  0x0C, 0x18, 0x61, 0x0C, 0x0C, 0x20, 0xC6, 0x06, 0x30, 0x63, 0x01, 0x98,
  0x31, 0x00, 0xC8, 0x0D, 0x80, 0x6C, 0x06, 0xC0, 0x16, 0x03, 0x60, 0x0E,
  0x00, 0xA0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0xC0,
  0x18, 0xC0, 0x60, 0xC1, 0x81, 0xC3, 0x01, 0x8C, 0x01, 0xB0, 0x03, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x73, 0x00, 0xC6, 0x03, 0x06, 0x0C,
  0x06, 0x18, 0x0E, 0x60, 0x0D, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0xBC, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E, 0x0E, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xE0, 0x0C, 0x0E, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC1, 0xE0, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0x83, 0x81, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 24, 8, 3, -24 },
  { 10, 8, 9, 12, 2, -24 },
  { 19, 20, 24, 22, 1, -24 },
  { 79, 15, 28, 19, 2, -26 },
  { 132, 24, 25, 28, 2, -25 },
  { 207, 22, 25, 24, 2, -25 },
  { 276, 2, 9, 7, 2, -24 },
  { 279, 7, 29, 9, 1, -24 },
  { 305, 7, 29, 9, 1, -24 },
  { 331, 15, 15, 19, 2, -26 },
  { 360, 16, 16, 19, 2, -20 },
  { 392, 4, 8, 8, 1, -4 },
  { 396, 9, 2, 11, 1, -10 },
  { 399, 3, 3, 8, 3, -3 },
  { 401, 11, 24, 12, 0, -24 },
  { 434, 16, 25, 19, 2, -25 },
  { 484, 8, 24, 19, 3, -24 },
  { 508, 15, 25, 19, 2, -25 },
  { 555, 15, 25, 19, 2, -25 },
  { 602, 18, 24, 19, 1, -24 },
  { 656, 15, 24, 19, 2, -24 },
  { 701, 16, 25, 19, 2, -25 },
  { 751, 16, 24, 19, 2, -24 },
  { 799, 15, 25, 19, 2, -25 },
  { 846, 15, 25, 19, 2, -25 },
  { 893, 3, 18, 8, 3, -18 },
  { 900, 5, 22, 8, 1, -18 },
  { 914, 16, 16, 19, 2, -20 },
  { 946, 16, 8, 19, 2, -16 },
  { 962, 16, 16, 19, 2, -20 },
  { 994, 12, 25, 14, 1, -25 },
  { 1032, 26, 27, 30, 2, -24 },
  { 1120, 21, 24, 21, 0, -24 },
  { 1183, 17, 24, 21, 3, -24 },
  { 1234, 18, 25, 21, 2, -25 },
  { 1291, 19, 24, 24, 3, -24 },
  { 1348, 14, 24, 19, 3, -24 },
  { 1390, 14, 24, 17, 3, -24 },
  { 1432, 20, 25, 25, 2, -25 },
  { 1495, 18, 24, 25, 3, -24 },
  { 1549, 7, 24, 11, 2, -24 },
  { 1570, 8, 30, 9, -3, -24 },
  { 1600, 17, 24, 20, 3, -24 },
  { 1651, 14, 24, 18, 3, -24 },
  { 1693, 23, 24, 30, 3, -24 },
  { 1762, 18, 24, 25, 3, -24 },
  { 1816, 22, 25, 26, 2, -25 },
  { 1885, 15, 24, 20, 3, -24 },
  { 1930, 22, 31, 26, 2, -25 },
  { 2016, 17, 24, 20, 3, -24 },
  { 2067, 15, 25, 19, 2, -25 },
  { 2114, 18, 24, 18, 0, -24 },
  { 2168, 18, 24, 25, 3, -24 },
  { 2222, 20, 24, 20, 0, -24 },
  { 2282, 29, 24, 31, 1, -24 },
  { 2369, 19, 24, 19, 0, -24 },
  { 2426, 18, 24, 18, 0, -24 },
  { 2480, 17, 24, 20, 1, -24 },
  { 2531, 7, 29, 11, 3, -24 },
  { 2557, 11, 24, 12, 0, -24 },
  { 2590, 7, 29, 11, 1, -24 },
  { 2616, 17, 15, 19, 1, -24 },
  { 2648, 14, 2, 14, 0, 3 },
  { 2652, 7, 5, 9, 1, -26 },
  { 2657, 13, 18, 18, 2, -18 },
  { 2687, 15, 26, 20, 3, -26 },
  { 2736, 13, 18, 16, 2, -18 },
  { 2766, 15, 26, 20, 2, -26 },
  { 2815, 15, 18, 19, 2, -18 },
  { 2849, 12, 26, 11, 0, -26 },
  { 2888, 15, 26, 20, 2, -18 },
  { 2937, 14, 26, 20, 3, -26 },
  { 2983, 2, 25, 8, 3, -25 },
  { 2990, 7, 33, 8, -2, -25 },
  { 3019, 14, 26, 17, 3, -26 },
  { 3065, 2, 26, 8, 3, -26 },
  { 3072, 25, 18, 30, 3, -18 },
  { 3129, 14, 18, 20, 3, -18 },
  { 3161, 16, 18, 20, 2, -18 },
  { 3197, 15, 26, 20, 3, -18 },
  { 3246, 15, 26, 20, 2, -18 },
  { 3295, 10, 18, 13, 3, -18 },
  { 3318, 12, 18, 16, 2, -18 },
  { 3345, 11, 22, 12, 0, -22 },
  { 3376, 14, 18, 20, 3, -18 },
  { 3408, 16, 18, 16, 0, -18 },
  { 3444, 25, 18, 25, 0, -18 },
  { 3501, 15, 18, 17, 1, -18 },
  { 3535, 16, 26, 16, 0, -18 },
  { 3587, 13, 18, 16, 1, -18 },
  { 3617, 10, 29, 12, 1, -24 },
  { 3654, 2, 34, 18, 8, -26 },
  { 3663, 10, 29, 12, 1, -24 },
  { 3700, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_Light34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light34pt7bBitmaps,
  (GFXglyph *)NotoSans_Light34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_LIGHT34PT7B_H_
