#ifndef _NOTOSANS_LIGHT52PT7B_H_
#define _NOTOSANS_LIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x00, 0x00, 0x27, 0xBF, 0xFF,
  0x10, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0,
  0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x30, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0x8C, 0x1E, 0x3C, 0x18, 0x04, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x03,
  0x80, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0x3C, 0x18, 0x00, 0x3C, 0x30, 0x00, 0x3E, 0x60, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0C,
  0xFC, 0x00, 0x18, 0x7C, 0x00, 0x30, 0x3C, 0x00, 0x60, 0x38, 0x00, 0xC0,
  0x70, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0C, 0x07,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x3D, 0x80, 0x60, 0xF3, 0xF8, 0xCF, 0xC7,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x38, 0x03, 0x83, 0x80,
  0x03, 0x00, 0x70, 0x18, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0xE0,
  0x70, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0x0E, 0x1C, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0xE0, 0xE0, 0x0C, 0x38, 0x7F,
  0x8E, 0x01, 0xC3, 0x8F, 0xFC, 0x60, 0x1C, 0x71, 0xC0, 0xE7, 0x01, 0x86,
  0x1C, 0x0E, 0x38, 0x38, 0xE3, 0x80, 0x73, 0xFF, 0x0C, 0x38, 0x07, 0x1F,
  0xE1, 0xC3, 0x80, 0x70, 0x30, 0x18, 0x30, 0x03, 0x00, 0x03, 0x83, 0x00,
  0x30, 0x00, 0x70, 0x30, 0x03, 0x00, 0x07, 0x03, 0x00, 0x30, 0x00, 0xE0,
  0x30, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x18, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x0E, 0x00,
  0x1E, 0x1E, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x70, 0xF0, 0x3C, 0x00, 0x70, 0xF0,
  0x0F, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0x1C, 0x70, 0x00, 0xF0, 0x1C, 0x78,
  0x00, 0x3C, 0x0E, 0x38, 0x00, 0x0F, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x0E,
  0x00, 0x00, 0xF7, 0x07, 0x00, 0x00, 0x3F, 0x83, 0x80, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x07, 0xBC,
  0x0F, 0x00, 0x0F, 0x8F, 0x03, 0xF0, 0x3F, 0x83, 0xC0, 0xFF, 0xFF, 0x00,
  0xF0, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xDB, 0x6C, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1E, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x18, 0x06,
  0xFC, 0x30, 0xFF, 0xFF, 0x6F, 0xFC, 0x7F, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x03,
  0x87, 0x80, 0x0F, 0x07, 0x00, 0x3C, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0C, 0x00, 0x40, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x73, 0xCF, 0x38,
  0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x27, 0xBF,
  0xFF, 0x10, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x0F, 0x70, 0xF3, 0x8F, 0x1D, 0xF0,
  0xFE, 0x07, 0x60, 0x3A, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0,
  0x1F, 0x07, 0x80, 0x0F, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x3F, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x20, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x7C, 0xFE, 0x01, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x71, 0x80, 0x03,
  0xE3, 0xE0, 0x1F, 0x87, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xF0,
  0x04, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x7F,
  0x80, 0x61, 0xFF, 0xE0, 0xE7, 0xF3, 0xF8, 0xEF, 0x00, 0x7C, 0xEC, 0x00,
  0x1C, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x07, 0xC1,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x0F, 0x81,
  0xE0, 0x07, 0xE7, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x1F, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x76, 0x3E, 0x00,
  0xEE, 0x1F, 0xFF, 0xCE, 0x07, 0xFF, 0x0E, 0x01, 0xFC, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x20, 0x1F, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xF7, 0xFF,
  0xE2, 0x00, 0x1C, 0x7C, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x3C,
  0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x07, 0xC4, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x1F, 0x00, 0x0E, 0x38, 0x00, 0xFF, 0xF8, 0x06, 0x30, 0x01, 0xFF,
  0xF8, 0x07, 0x70, 0x03, 0xC0, 0x38, 0x07, 0x70, 0x07, 0x00, 0x38, 0x07,
  0x60, 0x0E, 0x00, 0x38, 0x03, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x1C,
  0x00, 0x30, 0x03, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0xE0, 0x18, 0x00, 0x30,
  0x03, 0xE0, 0x38, 0x00, 0x30, 0x03, 0xC0, 0x38, 0x00, 0x30, 0x03, 0xC0,
  0x38, 0x00, 0x70, 0x07, 0xC0, 0x38, 0x00, 0x70, 0x07, 0xE0, 0x18, 0x00,
  0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x06, 0xE0, 0x1C, 0x00, 0xF8, 0x0E,
  0xE0, 0x0E, 0x01, 0xD8, 0x1C, 0x60, 0x0F, 0x03, 0x9C, 0x3C, 0x70, 0x07,
  0xFF, 0x0F, 0xF8, 0x70, 0x01, 0xFE, 0x07, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x3E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x60, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x20, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xFC, 0x0E, 0x00,
  0x01, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0x80, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x0F,
  0x80, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x38, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x3D, 0x87, 0xCF, 0xFC, 0x7F, 0xC0, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00,
  0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE3, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x0E, 0xEF, 0x00, 0x03,
  0xF1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x01, 0xE0,
  0x03, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x00, 0x7F, 0xDC,
  0x00, 0x00, 0x1D, 0xFB, 0x80, 0x00, 0x03, 0xBF, 0x38, 0x00, 0x00, 0x67,
  0xE7, 0x00, 0x00, 0x1C, 0xFC, 0x70, 0x00, 0x03, 0x9F, 0x8E, 0x00, 0x00,
  0xE3, 0xF1, 0xC0, 0x00, 0x1C, 0x7E, 0x1C, 0x00, 0x03, 0x0F, 0xC3, 0x80,
  0x00, 0xE1, 0xF8, 0x78, 0x00, 0x1C, 0x3F, 0x07, 0x00, 0x07, 0x07, 0xE0,
  0xE0, 0x00, 0xE0, 0xFC, 0x0E, 0x00, 0x1C, 0x1F, 0x81, 0xC0, 0x07, 0x03,
  0xF0, 0x3C, 0x00, 0xE0, 0x7E, 0x03, 0x80, 0x38, 0x0F, 0xC0, 0x70, 0x07,
  0x01, 0xF8, 0x07, 0x00, 0xE0, 0x3F, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x1C,
  0x07, 0x00, 0xFC, 0x01, 0xC1, 0xC0, 0x1F, 0x80, 0x38, 0x38, 0x03, 0xF0,
  0x03, 0x87, 0x00, 0x7E, 0x00, 0x71, 0xC0, 0x0F, 0xC0, 0x0E, 0x38, 0x01,
  0xF8, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7E, 0xE0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x07, 0xE3,
  0x80, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x0E, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x7E,
  0x03, 0xC0, 0x07, 0xE0, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0F,
  0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x03, 0x80, 0x7E, 0x00, 0x3C, 0x07,
  0xE0, 0x01, 0xC0, 0x7E, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0xF0, 0x7E, 0x00,
  0x07, 0x07, 0xE0, 0x00, 0x38, 0x7E, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x1C,
  0x7E, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x77, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0x00, 0x0F, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xF3, 0x80, 0x0F, 0xC7, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x15, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00,
  0x07, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x00, 0x8F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x73, 0x00, 0x03, 0xE7, 0xE0,
  0x3F, 0x8F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x78, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xE7, 0x80,
  0x01, 0xF8, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0x87, 0x00, 0x03, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x39,
  0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x06, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x38, 0x01, 0x81, 0xC0, 0x0E,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x0F,
  0x03, 0x80, 0x30, 0x1C, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xC0, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x78, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x00, 0x77, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xC0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFC, 0x7F, 0x03,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x01, 0xCF, 0x80, 0x07, 0x3C,
  0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xDC, 0x00, 0x3F, 0x78, 0x01, 0xDC,
  0xF8, 0x1E, 0x71, 0xFF, 0xF1, 0xC3, 0xFF, 0x07, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0F, 0xF0,
  0x18, 0x7F, 0xF8, 0x33, 0xF1, 0xF8, 0x67, 0x00, 0x78, 0xD8, 0x00, 0x79,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xCD, 0xC0, 0x0F, 0x19, 0xE0, 0x7C,
  0x31, 0xFF, 0xF0, 0x60, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x01, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x10,
  0xFC, 0x0F, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFF,
  0x07, 0x07, 0xFF, 0xC7, 0x0F, 0xE3, 0xE7, 0x1F, 0x00, 0x77, 0x3C, 0x00,
  0x37, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1E, 0x00,
  0x77, 0x1F, 0x81, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0xF8, 0x07,
  0x81, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1D, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x04, 0x1F, 0x80, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x07, 0x07, 0xFF,
  0xC7, 0x0F, 0xE7, 0xE7, 0x1F, 0x00, 0x77, 0x3C, 0x00, 0x3F, 0x38, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1E, 0x00, 0x77, 0x0F, 0x81,
  0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x10, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x78, 0x3E, 0x01,
  0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0xFC, 0x7E,
  0x33, 0x80, 0x3C, 0xD8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x6F, 0xFF, 0x60,
  0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x74, 0x1E, 0xFF, 0x9F,
  0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0x60,
  0x00, 0xF3, 0x00, 0x0F, 0x18, 0x00, 0xF0, 0xC0, 0x0F, 0x06, 0x00, 0xF0,
  0x30, 0x0F, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x07,
  0x00, 0x18, 0x70, 0x00, 0xC7, 0x80, 0x06, 0x7E, 0x00, 0x37, 0x70, 0x01,
  0xF1, 0xC0, 0x0F, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x80, 0xC0, 0x1E, 0x06, 0x00, 0x78, 0x30, 0x01, 0xC1, 0x80, 0x07, 0x0C,
  0x00, 0x3C, 0x60, 0x00, 0xF3, 0x00, 0x03, 0x98, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x06, 0x3F, 0xFC, 0x1F, 0xFE, 0x33, 0xE3,
  0xF1, 0xF1, 0xF9, 0xB8, 0x03, 0xDC, 0x01, 0xED, 0x80, 0x0E, 0xC0, 0x07,
  0x78, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xC0,
  0xFF, 0x03, 0x0F, 0xFF, 0x0C, 0x7C, 0x7E, 0x33, 0x80, 0x3C, 0xD8, 0x00,
  0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xF8,
  0xFC, 0x03, 0xE0, 0x0F, 0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0xC0,
  0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0xFF, 0x01, 0x87, 0xFF, 0x83, 0x1F, 0x1F, 0x86, 0x70, 0x07, 0x8D, 0xC0,
  0x07, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDE,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0x6C, 0x00, 0x3C, 0xDC, 0x00, 0xF1, 0x9E,
  0x07, 0xC3, 0x1F, 0xFF, 0x07, 0x0F, 0xFC, 0x0E, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0xC7,
  0x0F, 0xC3, 0xE7, 0x1E, 0x00, 0x77, 0x3C, 0x00, 0x37, 0x38, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1E, 0x00, 0x77, 0x1F, 0x81, 0xE7,
  0x0F, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x10, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xF6,
  0x70, 0x0D, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0x8F, 0xE3, 0x80, 0x06, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC1,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x40, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1B,
  0x38, 0x00, 0xEC, 0xF8, 0x0F, 0x31, 0xFF, 0xF8, 0xC1, 0xFF, 0x83, 0x00,
  0x40, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x03, 0xB8,
  0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x0D, 0x80,
  0x0E, 0x38, 0x00, 0xEE, 0x00, 0x71, 0xE0, 0x07, 0x70, 0x03, 0x87, 0x00,
  0x33, 0x80, 0x1C, 0x38, 0x03, 0x8C, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x0E,
  0x07, 0x00, 0xC3, 0x80, 0x70, 0x38, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0x70,
  0x70, 0x38, 0x0E, 0x03, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x0C, 0x0E, 0x01,
  0xC1, 0xC0, 0x70, 0xE0, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0x76, 0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0x7F, 0xF8, 0x03, 0xF1, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 38, 13, 4, -37 },
  { 25, 11, 13, 19, 4, -37 },
  { 43, 31, 37, 34, 1, -37 },
  { 187, 23, 42, 30, 3, -39 },
  { 308, 36, 39, 42, 3, -38 },
  { 484, 33, 39, 37, 3, -38 },
  { 645, 3, 13, 10, 4, -37 },
  { 650, 11, 45, 14, 2, -37 },
  { 712, 10, 45, 14, 2, -37 },
  { 769, 23, 22, 29, 3, -39 },
  { 833, 24, 25, 30, 3, -31 },
  { 908, 6, 13, 12, 2, -6 },
  { 918, 13, 2, 17, 2, -15 },
  { 922, 5, 6, 13, 4, -5 },
  { 926, 16, 37, 18, 1, -37 },
  { 1000, 24, 39, 30, 3, -38 },
  { 1117, 13, 37, 30, 5, -37 },
  { 1178, 23, 38, 30, 3, -38 },
  { 1288, 24, 39, 30, 2, -38 },
  { 1405, 28, 37, 30, 1, -37 },
  { 1535, 23, 38, 30, 4, -37 },
  { 1645, 24, 39, 30, 3, -38 },
  { 1762, 24, 37, 30, 3, -37 },
  { 1873, 24, 39, 30, 3, -38 },
  { 1990, 24, 39, 30, 3, -38 },
  { 2107, 5, 29, 13, 4, -28 },
  { 2126, 7, 35, 13, 2, -28 },
  { 2157, 24, 24, 30, 3, -31 },
  { 2229, 24, 13, 30, 3, -25 },
  { 2268, 24, 24, 30, 3, -31 },
  { 2340, 19, 39, 22, 1, -38 },
  { 2433, 40, 42, 46, 3, -37 },
  { 2643, 32, 37, 32, 0, -37 },
  { 2791, 25, 37, 33, 5, -37 },
  { 2907, 28, 39, 32, 3, -38 },
  { 3044, 29, 37, 37, 5, -37 },
  { 3179, 21, 37, 29, 5, -37 },
  { 3277, 21, 37, 26, 5, -37 },
  { 3375, 31, 39, 38, 3, -38 },
  { 3527, 27, 37, 38, 5, -37 },
  { 3652, 11, 37, 16, 3, -37 },
  { 3703, 13, 46, 13, -5, -37 },
  { 3778, 26, 37, 31, 5, -37 },
  { 3899, 21, 37, 27, 5, -37 },
  { 3997, 35, 37, 45, 5, -37 },
  { 4159, 28, 37, 38, 5, -37 },
  { 4289, 34, 39, 40, 3, -38 },
  { 4455, 23, 37, 31, 5, -37 },
  { 4562, 34, 47, 40, 3, -38 },
  { 4762, 25, 37, 31, 5, -37 },
  { 4878, 23, 39, 28, 3, -38 },
  { 4991, 27, 37, 28, 0, -37 },
  { 5116, 28, 38, 38, 5, -37 },
  { 5249, 30, 37, 30, 0, -37 },
  { 5388, 45, 37, 47, 1, -37 },
  { 5597, 28, 37, 29, 0, -37 },
  { 5727, 28, 37, 28, 0, -37 },
  { 5857, 26, 37, 30, 2, -37 },
  { 5978, 11, 45, 17, 4, -37 },
  { 6040, 16, 37, 18, 1, -37 },
  { 6114, 11, 45, 17, 1, -37 },
  { 6176, 26, 23, 30, 2, -37 },
  { 6251, 22, 2, 22, 0, 5 },
  { 6257, 10, 8, 14, 2, -40 },
  { 6267, 22, 29, 28, 2, -28 },
  { 6347, 23, 41, 31, 5, -40 },
  { 6465, 20, 29, 25, 3, -28 },
  { 6538, 24, 41, 31, 3, -40 },
  { 6661, 23, 29, 29, 3, -28 },
  { 6745, 18, 40, 16, 1, -40 },
  { 6835, 24, 40, 31, 3, -28 },
  { 6955, 22, 40, 31, 5, -40 },
  { 7065, 4, 38, 12, 4, -38 },
  { 7084, 11, 50, 12, -3, -38 },
  { 7153, 21, 40, 26, 5, -40 },
  { 7258, 3, 40, 12, 5, -40 },
  { 7273, 37, 28, 46, 5, -28 },
  { 7403, 22, 28, 31, 5, -28 },
  { 7480, 25, 29, 31, 3, -28 },
  { 7571, 23, 40, 31, 5, -28 },
  { 7686, 24, 40, 31, 3, -28 },
  { 7806, 15, 28, 20, 5, -28 },
  { 7859, 20, 29, 24, 2, -28 },
  { 7932, 15, 35, 18, 1, -34 },
  { 7998, 22, 29, 31, 4, -28 },
  { 8078, 24, 28, 24, 0, -28 },
  { 8162, 37, 28, 38, 1, -28 },
  { 8292, 24, 28, 26, 1, -28 },
  { 8376, 24, 41, 24, 0, -28 },
  { 8499, 20, 28, 24, 2, -28 },
  { 8569, 16, 45, 19, 1, -37 },
  { 8659, 2, 53, 28, 13, -40 },
  { 8673, 15, 45, 19, 2, -37 },
  { 8758, 24, 6, 30, 3, -21 },
};

const GFXfont NotoSans_Light52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light52pt7bBitmaps,
  (GFXglyph *)NotoSans_Light52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_LIGHT52PT7B_H_
