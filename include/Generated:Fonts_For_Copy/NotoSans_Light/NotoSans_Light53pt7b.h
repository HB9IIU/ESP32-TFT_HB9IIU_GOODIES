#ifndef _NOTOSANS_LIGHT53PT7B_H_
#define _NOTOSANS_LIGHT53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x00, 0x01, 0x3F, 0xFF,
  0xFC, 0x80, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0,
  0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF,
  0x87, 0xCE, 0x7E, 0x1E, 0x1C, 0x0C, 0x78, 0x38, 0x00, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x7C, 0x70, 0x00, 0x7E,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0x78, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x7B, 0x80, 0xE1, 0xE7,
  0xF1, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x07, 0x07, 0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x1C, 0x01, 0xC3, 0x87,
  0xF0, 0xE0, 0x0E, 0x18, 0x7F, 0xC3, 0x00, 0x61, 0xC7, 0x8F, 0x1C, 0x07,
  0x1C, 0x38, 0x1C, 0xE0, 0x38, 0xE3, 0x80, 0xE3, 0x87, 0x8E, 0x1C, 0x03,
  0x0F, 0xF8, 0x70, 0xC0, 0x1C, 0x3F, 0x87, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x70, 0x07, 0x00, 0x03, 0x83, 0x80, 0x38, 0x00, 0x18, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0xE0, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x30, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x18, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x1C, 0x00,
  0x07, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x07, 0x81, 0xF0, 0x01, 0xC3, 0xC0, 0x3E,
  0x00, 0x71, 0xE0, 0x07, 0xC0, 0x38, 0x70, 0x00, 0xF8, 0x0E, 0x3C, 0x00,
  0x1F, 0x07, 0x8E, 0x00, 0x03, 0xE1, 0xC3, 0x80, 0x00, 0x7C, 0xE0, 0xE0,
  0x00, 0x0F, 0xF8, 0x38, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x03, 0xEF,
  0x03, 0xE0, 0x03, 0xE1, 0xE0, 0x7E, 0x07, 0xF0, 0x3C, 0x0F, 0xFF, 0xF0,
  0x0F, 0x80, 0xFF, 0xF0, 0x01, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x6D, 0x80, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x1C, 0x03, 0xF8,
  0x38, 0x3F, 0xFE, 0x73, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x03, 0xC7,
  0x80, 0x07, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3,
  0x9C, 0x71, 0xC6, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0xFF,
  0xFF, 0x90, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0x7B, 0x8F, 0x9C, 0xF0, 0xEF, 0x07, 0xF0, 0x3A, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x7C, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x20, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xF0,
  0x7E, 0x0F, 0x80, 0x07, 0x87, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x40,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x39, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3D, 0x00, 0x00, 0xF3, 0x00, 0x07, 0xC7,
  0xC0, 0x3F, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x01, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1,
  0xFF, 0xC0, 0x73, 0xFF, 0xF0, 0x73, 0xE0, 0x7C, 0x3B, 0x80, 0x0F, 0x1D,
  0x80, 0x03, 0xCF, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x0F, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xF7, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x0F, 0x81, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0x83, 0xE0, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78,
  0x00, 0x3F, 0x3C, 0x00, 0x77, 0x1E, 0x01, 0xE7, 0x0F, 0xFF, 0xC7, 0x07,
  0xFF, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x20, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x37, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x27, 0xFF, 0xFF, 0x90, 0x18, 0x7C, 0xF9,
  0xF3, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C,
  0x38, 0x61, 0xC3, 0x86, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7E, 0x1F, 0xC6, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x07, 0xFE, 0x00, 0xE3, 0x80, 0x0F, 0xFF, 0x80, 0x31, 0x80,
  0x1F, 0x03, 0xC0, 0x1D, 0xC0, 0x1E, 0x00, 0x60, 0x0E, 0xE0, 0x0E, 0x00,
  0x30, 0x07, 0x60, 0x0E, 0x00, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x01,
  0xC0, 0x03, 0x80, 0x1F, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x80, 0x60, 0x00,
  0xE0, 0x0F, 0xC0, 0x30, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x03,
  0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xB8, 0x07, 0x00, 0x1E, 0x01, 0xDC, 0x03,
  0xC0, 0x1F, 0x00, 0xEE, 0x00, 0xE0, 0x0D, 0xC0, 0xE3, 0x00, 0x3C, 0x1C,
  0x70, 0xE1, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xE0, 0x03, 0xFC, 0x0F, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0x80, 0x03, 0xF8, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x01, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xE0, 0x00,
  0x3E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x20,
  0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xC0, 0x01, 0xFC, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x0F, 0x87, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x40,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x0E,
  0x0F, 0x80, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x38, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x01, 0xEC, 0x1F, 0x7F, 0xF3, 0xFE, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03,
  0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xE3, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x0E, 0x7F,
  0x00, 0x03, 0xB9, 0xE0, 0x00, 0xFC, 0x38, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xEE, 0x00, 0x00, 0x03, 0x7E, 0xE0, 0x00, 0x00, 0x77, 0xEE,
  0x00, 0x00, 0x07, 0x7E, 0x70, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x0E,
  0x7E, 0x38, 0x00, 0x00, 0xE7, 0xE3, 0x80, 0x00, 0x1C, 0x7E, 0x38, 0x00,
  0x01, 0xC7, 0xE1, 0xC0, 0x00, 0x38, 0x7E, 0x1C, 0x00, 0x03, 0x87, 0xE0,
  0xE0, 0x00, 0x38, 0x7E, 0x0E, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x70,
  0x7E, 0x07, 0x00, 0x0E, 0x07, 0xE0, 0x70, 0x00, 0xE0, 0x7E, 0x07, 0x80,
  0x0E, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x1C, 0x07, 0xE0,
  0x1C, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0xE0, 0x1E, 0x03, 0x80,
  0x7E, 0x00, 0xE0, 0x70, 0x07, 0xE0, 0x0E, 0x07, 0x00, 0x7E, 0x00, 0x70,
  0xE0, 0x07, 0xE0, 0x07, 0x0E, 0x00, 0x7E, 0x00, 0x78, 0xE0, 0x07, 0xE0,
  0x03, 0x9C, 0x00, 0x7E, 0x00, 0x39, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7E,
  0x70, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xE1, 0xC0,
  0x00, 0x7E, 0x1E, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xE0, 0x1C, 0x00, 0x7E, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x80,
  0x7E, 0x00, 0x3C, 0x07, 0xE0, 0x01, 0xC0, 0x7E, 0x00, 0x1E, 0x07, 0xE0,
  0x00, 0xF0, 0x7E, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x03,
  0xC7, 0xE0, 0x00, 0x1C, 0x7E, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x73, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0x00, 0x0F, 0xCE, 0x00, 0x07,
  0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x7B, 0x80, 0x03, 0xE7, 0x00, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xE8, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0xE0, 0x00, 0x7C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x1F, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xF1, 0xF0, 0x00, 0xE7,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7B, 0x00, 0x03, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x80, 0xFE, 0x07, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x37, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x30, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE3, 0x80, 0x03,
  0x81, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x03, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x60, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x60, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xC0, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x3B,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xB8,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xC0, 0x3C, 0x08, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xF0, 0x07, 0x3E, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC,
  0x00, 0x1F, 0x70, 0x00, 0x7D, 0xE0, 0x07, 0x73, 0xE0, 0x79, 0xC7, 0xFF,
  0xC3, 0x0F, 0xFE, 0x0C, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE7, 0xFF,
  0xE0, 0xEF, 0x01, 0xF0, 0xFC, 0x00, 0x78, 0xD8, 0x00, 0x3C, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0xD8, 0x00, 0x38, 0xDC, 0x00, 0x78, 0xCF, 0x01,
  0xF0, 0xC7, 0xFF, 0xE0, 0xC1, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x80, 0xE1, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x43, 0xF0, 0x3C, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x07, 0x03, 0xFF, 0x87, 0x07, 0xFF, 0xE7, 0x0F,
  0x80, 0xF7, 0x1E, 0x00, 0x37, 0x3C, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x37, 0x0F, 0x80, 0xE7, 0x07,
  0xFF, 0xC3, 0x03, 0xFF, 0x83, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80,
  0x07, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x3F,
  0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0x81, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0x83, 0x07, 0xFF, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00, 0x3F, 0x3C,
  0x00, 0x1F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x77, 0x0F, 0x81, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x20,
  0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x80, 0xE1,
  0xFF, 0xC3, 0x9F, 0xFF, 0x8E, 0xF0, 0x1F, 0x3F, 0x00, 0x1E, 0xD8, 0x00,
  0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x6F, 0xFF, 0x70, 0x00, 0x00, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70,
  0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xDF, 0xF3, 0xFC, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x70, 0x00,
  0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0xF0, 0x38,
  0x0F, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x7E, 0x00, 0x3F, 0x78, 0x01, 0xF1,
  0xE0, 0x0F, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x1E, 0x03, 0x0F, 0xFC, 0x03, 0xFF, 0x0C, 0x7F, 0xFC,
  0x3F, 0xFF, 0x33, 0xC0, 0xF9, 0xE0, 0x3C, 0xDC, 0x01, 0xEE, 0x00, 0x7B,
  0xE0, 0x03, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3E, 0x03, 0x07, 0xFF, 0x0C,
  0x7F, 0xFE, 0x33, 0xC0, 0x7C, 0xDC, 0x00, 0x7B, 0xE0, 0x00, 0xEF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03,
  0xF0, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0xFF, 0xE0, 0xCF, 0x01, 0xF0,
  0xCC, 0x00, 0x78, 0xD8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x3C,
  0xD8, 0x00, 0x38, 0xFE, 0x00, 0x78, 0xEF, 0x81, 0xF0, 0xE7, 0xFF, 0xE0,
  0xE1, 0xFF, 0x80, 0xE0, 0x10, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x83,
  0x07, 0xFF, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00, 0x37, 0x3C, 0x00, 0x1F,
  0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x1E, 0x00, 0x77,
  0x0F, 0x81, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x7D, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x1C, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0xF3, 0xE0, 0x0E, 0x38, 0x00, 0x27, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0E,
  0xF8, 0x03, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x81, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x10, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0xBC, 0x00, 0x3F, 0x3C, 0x00, 0xEE, 0x7E, 0x07,
  0x9C, 0x7F, 0xFE, 0x38, 0x3F, 0xF0, 0x70, 0x02, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x1E, 0xE0, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x0D, 0xC0,
  0x07, 0x38, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x07, 0x30, 0x03, 0x87, 0x00,
  0x39, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x1C, 0x70, 0x07,
  0x07, 0x00, 0xE1, 0xC0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x8E, 0x00, 0x39,
  0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xB8,
  0x00, 0x76, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x38,
  0x0E, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0xC1, 0xC0,
  0x01, 0xC3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xC0,
  0x07, 0x80, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCF, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7F, 0x8F, 0xC0, 0x0F, 0xFE, 0x80, 0x03,
  0xFC,
};

const GFXglyph NotoSans_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 39, 13, 4, -38 },
  { 26, 12, 14, 19, 4, -38 },
  { 47, 32, 38, 34, 1, -38 },
  { 199, 23, 43, 30, 3, -40 },
  { 323, 37, 39, 43, 3, -38 },
  { 504, 34, 39, 38, 3, -38 },
  { 670, 3, 14, 11, 4, -38 },
  { 676, 11, 46, 15, 2, -38 },
  { 740, 11, 46, 15, 2, -38 },
  { 804, 23, 22, 29, 3, -40 },
  { 868, 24, 25, 30, 3, -31 },
  { 943, 6, 13, 12, 2, -6 },
  { 953, 13, 3, 17, 2, -16 },
  { 958, 5, 6, 13, 4, -5 },
  { 962, 17, 38, 18, 1, -38 },
  { 1043, 24, 39, 30, 3, -38 },
  { 1160, 13, 38, 30, 5, -38 },
  { 1222, 24, 38, 30, 3, -38 },
  { 1336, 25, 39, 30, 2, -38 },
  { 1458, 28, 38, 30, 1, -38 },
  { 1591, 23, 39, 30, 4, -38 },
  { 1704, 25, 39, 30, 3, -38 },
  { 1826, 24, 38, 30, 3, -38 },
  { 1940, 24, 39, 30, 3, -38 },
  { 2057, 24, 39, 30, 3, -38 },
  { 2174, 5, 30, 13, 4, -29 },
  { 2193, 7, 36, 13, 2, -29 },
  { 2225, 24, 25, 30, 3, -32 },
  { 2300, 24, 13, 30, 3, -25 },
  { 2339, 24, 25, 30, 3, -32 },
  { 2414, 20, 39, 22, 1, -38 },
  { 2512, 41, 43, 47, 3, -38 },
  { 2733, 32, 38, 32, 0, -38 },
  { 2885, 26, 38, 34, 5, -38 },
  { 3009, 28, 39, 33, 3, -38 },
  { 3146, 29, 38, 38, 5, -38 },
  { 3284, 21, 38, 29, 5, -38 },
  { 3384, 21, 38, 27, 5, -38 },
  { 3484, 31, 39, 38, 3, -38 },
  { 3636, 28, 38, 38, 5, -38 },
  { 3769, 11, 38, 16, 3, -38 },
  { 3822, 13, 48, 13, -5, -38 },
  { 3900, 26, 38, 31, 5, -38 },
  { 4024, 21, 38, 27, 5, -38 },
  { 4124, 36, 38, 46, 5, -38 },
  { 4295, 28, 38, 39, 5, -38 },
  { 4428, 34, 39, 41, 3, -38 },
  { 4594, 23, 38, 31, 5, -38 },
  { 4704, 34, 47, 41, 3, -38 },
  { 4904, 26, 38, 32, 5, -38 },
  { 5028, 23, 39, 29, 3, -38 },
  { 5141, 28, 38, 28, 0, -38 },
  { 5274, 28, 39, 38, 5, -38 },
  { 5411, 31, 38, 31, 0, -38 },
  { 5559, 46, 38, 48, 1, -38 },
  { 5778, 29, 38, 29, 0, -38 },
  { 5916, 28, 38, 28, 0, -38 },
  { 6049, 26, 38, 30, 2, -38 },
  { 6173, 12, 46, 17, 4, -38 },
  { 6242, 17, 38, 18, 1, -38 },
  { 6323, 12, 46, 17, 1, -38 },
  { 6392, 26, 24, 30, 2, -38 },
  { 6470, 22, 2, 22, 0, 5 },
  { 6476, 10, 9, 14, 2, -41 },
  { 6488, 22, 30, 28, 2, -29 },
  { 6571, 24, 41, 32, 5, -40 },
  { 6694, 21, 30, 25, 3, -29 },
  { 6773, 24, 41, 32, 3, -40 },
  { 6896, 23, 30, 29, 3, -29 },
  { 6983, 18, 41, 16, 1, -41 },
  { 7076, 24, 42, 32, 3, -29 },
  { 7202, 22, 40, 32, 5, -40 },
  { 7312, 4, 39, 12, 4, -39 },
  { 7332, 11, 52, 12, -3, -39 },
  { 7404, 21, 40, 26, 5, -40 },
  { 7509, 3, 40, 12, 5, -40 },
  { 7524, 38, 29, 47, 5, -29 },
  { 7662, 22, 29, 32, 5, -29 },
  { 7742, 25, 30, 31, 3, -29 },
  { 7836, 24, 42, 32, 5, -29 },
  { 7962, 24, 42, 32, 3, -29 },
  { 8088, 15, 29, 21, 5, -29 },
  { 8143, 20, 30, 25, 2, -29 },
  { 8218, 16, 36, 18, 1, -35 },
  { 8290, 23, 29, 32, 4, -28 },
  { 8374, 25, 28, 25, 0, -28 },
  { 8462, 37, 28, 39, 1, -28 },
  { 8592, 24, 28, 27, 1, -28 },
  { 8676, 25, 41, 25, 0, -28 },
  { 8805, 20, 28, 25, 2, -28 },
  { 8875, 16, 46, 19, 1, -38 },
  { 8967, 3, 53, 29, 13, -40 },
  { 8987, 16, 46, 19, 2, -38 },
  { 9079, 24, 6, 30, 3, -22 },
};

const GFXfont NotoSans_Light53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light53pt7bBitmaps,
  (GFXglyph *)NotoSans_Light53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_LIGHT53PT7B_H_
