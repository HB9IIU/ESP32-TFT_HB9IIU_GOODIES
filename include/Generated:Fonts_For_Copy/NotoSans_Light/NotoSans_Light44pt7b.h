#ifndef _NOTOSANS_LIGHT44PT7B_H_
#define _NOTOSANS_LIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x62,
  0x20, 0x00, 0x07, 0x7F, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x34, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFC,
  0xF9, 0x87, 0x1C, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x1F, 0x30, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x67, 0xC0,
  0x0C, 0x3C, 0x01, 0x83, 0x80, 0x30, 0x38, 0x06, 0x07, 0x00, 0xC0, 0xE0,
  0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xEC, 0x0C, 0x79, 0xFF, 0xFE, 0x3F,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x40, 0x3F, 0x80, 0x03, 0x00, 0xE3, 0x80,
  0x0E, 0x03, 0x83, 0x80, 0x18, 0x06, 0x03, 0x00, 0x70, 0x0C, 0x06, 0x00,
  0xC0, 0x18, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x06, 0x00, 0xE0, 0x18, 0x18,
  0x01, 0xC0, 0x30, 0x70, 0x03, 0x80, 0x60, 0xC0, 0x07, 0x00, 0xC3, 0x80,
  0x0E, 0x01, 0x86, 0x00, 0x0C, 0x07, 0x1C, 0x7E, 0x18, 0x0C, 0x31, 0xFE,
  0x30, 0x18, 0xE7, 0x0E, 0x30, 0x71, 0x8C, 0x0C, 0x71, 0xC6, 0x38, 0x1C,
  0x7F, 0x1C, 0x60, 0x18, 0x7C, 0x30, 0xC0, 0x30, 0x00, 0xE1, 0x80, 0x60,
  0x01, 0x83, 0x00, 0xC0, 0x07, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x03, 0x00,
  0x38, 0x18, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x00, 0xE0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x38, 0x01, 0xC3, 0x80, 0x60,
  0x01, 0xFE, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x01,
  0x80, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x0C, 0x78, 0x1C, 0x01,
  0xC7, 0x00, 0xE0, 0x1C, 0xE0, 0x07, 0x01, 0x8E, 0x00, 0x38, 0x38, 0xC0,
  0x01, 0xC3, 0x0C, 0x00, 0x0E, 0x70, 0xC0, 0x00, 0x7E, 0x0C, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0xE0, 0x70, 0x00, 0xF7, 0x07,
  0xC0, 0x3C, 0x38, 0x1F, 0xFF, 0x81, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF6, 0xC9, 0x00, 0x07, 0x83, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0xF0, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E,
  0x06, 0x07, 0x03, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x70, 0x60, 0x7F, 0xE6,
  0x7F, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0x98, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x80,
  0xC0, 0x30, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xCC,
  0xE7, 0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xF0, 0x77, 0xF7, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xE3,
  0xE0, 0x3C, 0x03, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x01, 0x8E,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80,
  0x03, 0x0E, 0x00, 0x38, 0x30, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x01, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0x73, 0xCE,
  0xF1, 0xF8, 0x3A, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0x1F, 0x87, 0x80, 0x38, 0x20, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xFF,
  0xF0, 0x3F, 0x0F, 0x8F, 0x00, 0x3C, 0x60, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x80, 0x01, 0xEE, 0x00, 0x7C, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x83, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x06, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x40, 0x01, 0xCE, 0x00, 0xF9, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xE0, 0xC0, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x3F,
  0xE0, 0xCF, 0xFF, 0x8D, 0xC0, 0x3C, 0xD8, 0x00, 0xCF, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0E,
  0x38, 0x01, 0xC1, 0xE0, 0x38, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0x1F, 0x83, 0x80, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x70, 0x01, 0xC3,
  0x80, 0x38, 0x3C, 0x07, 0x00, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x01, 0xE0, 0xF0, 0x38, 0x03, 0x87, 0x00, 0x1C, 0xE0, 0x00,
  0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x6E, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x80, 0x38, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x0F, 0x03,
  0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x38, 0x01, 0xB1, 0xE0,
  0x73, 0x0F, 0xFE, 0x30, 0x3F, 0x83, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x67, 0xF7, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xF7,
  0x39, 0xDE, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x73, 0xB9, 0xCE, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0xF8, 0xFE, 0xFC, 0x40, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x78, 0x01, 0x87, 0x00, 0x7F, 0xF0, 0x18, 0xC0, 0x1F,
  0x1E, 0x03, 0x38, 0x07, 0x00, 0xC0, 0x66, 0x01, 0xC0, 0x18, 0x0C, 0xC0,
  0x70, 0x07, 0x01, 0xD8, 0x0C, 0x00, 0xE0, 0x1B, 0x01, 0x80, 0x1C, 0x03,
  0xE0, 0x70, 0x03, 0x80, 0xFC, 0x0E, 0x00, 0x60, 0x1F, 0x81, 0xC0, 0x0C,
  0x03, 0x70, 0x38, 0x01, 0x80, 0x6E, 0x03, 0x00, 0x30, 0x0C, 0xC0, 0x60,
  0x0F, 0x03, 0x98, 0x0E, 0x01, 0xE0, 0x63, 0x00, 0xE0, 0x6C, 0x1C, 0x60,
  0x1F, 0xF8, 0xFF, 0x06, 0x00, 0xFE, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x38, 0x00, 0xF9, 0xC0, 0x01, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xB8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0,
  0x01, 0xEE, 0x00, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xF8, 0x3C, 0x00, 0x20, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x38, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x0E, 0x01, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0xF8, 0x00, 0x60, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0xCF, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x30, 0xF0, 0x00, 0x18, 0x3F, 0x00,
  0x3C, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x80, 0xFF, 0x9F, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xEC, 0x79, 0xFE, 0x3F, 0x80, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0xFC, 0x00, 0x3F,
  0x78, 0x00, 0xF8, 0xE0, 0x03, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x06, 0xFF, 0x00, 0x00, 0x1B, 0xEC, 0x00, 0x00,
  0xFF, 0xB8, 0x00, 0x03, 0x7E, 0xE0, 0x00, 0x1D, 0xF9, 0x80, 0x00, 0x67,
  0xE7, 0x00, 0x01, 0x9F, 0x8C, 0x00, 0x0E, 0x7E, 0x38, 0x00, 0x31, 0xF8,
  0xE0, 0x01, 0xC7, 0xE1, 0x80, 0x06, 0x1F, 0x87, 0x00, 0x18, 0x7E, 0x0C,
  0x00, 0xE1, 0xF8, 0x38, 0x03, 0x07, 0xE0, 0xE0, 0x1C, 0x1F, 0x81, 0x80,
  0x60, 0x7E, 0x07, 0x01, 0x81, 0xF8, 0x0C, 0x0E, 0x07, 0xE0, 0x38, 0x30,
  0x1F, 0x80, 0xE1, 0xC0, 0x7E, 0x01, 0x86, 0x01, 0xF8, 0x07, 0x18, 0x07,
  0xE0, 0x1C, 0xE0, 0x1F, 0x80, 0x33, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00,
  0x30, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07,
  0xE7, 0x00, 0x07, 0xE3, 0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07,
  0xE0, 0xE0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x38, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07,
  0xE0, 0x07, 0x07, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xC7,
  0xE0, 0x00, 0xE7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x38, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0xCE,
  0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x01, 0xF1, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0x9C, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0x38, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xDF, 0xE3, 0xC0, 0x04, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xCF, 0x00, 0x7C, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x1F, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x60, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x03, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1D, 0x80, 0x01,
  0xE0, 0x00, 0xE6, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x3E, 0x00, 0x0E,
  0x70, 0x00, 0xD8, 0x00, 0x30, 0xC0, 0x03, 0x70, 0x01, 0xC3, 0x00, 0x1C,
  0xC0, 0x07, 0x0E, 0x00, 0x73, 0x00, 0x18, 0x38, 0x01, 0x8E, 0x00, 0x60,
  0x60, 0x06, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x60, 0x0E, 0x07, 0x00, 0xC1,
  0x80, 0x30, 0x1C, 0x03, 0x07, 0x01, 0xC0, 0x30, 0x1C, 0x0C, 0x07, 0x00,
  0xE0, 0x70, 0x30, 0x1C, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x06, 0x06, 0x03,
  0x83, 0x80, 0x18, 0x38, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x18, 0x38, 0x01,
  0xC3, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x03,
  0x1C, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x01,
  0xB8, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0x81, 0xC0,
  0x01, 0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0x80,
  0x03, 0x81, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC7, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0xFF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xFF, 0xFC, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x73, 0x00,
  0x01, 0x98, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xF0, 0x03, 0xFF, 0x83,
  0xF9, 0xF0, 0x40, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x01, 0xFC, 0x1F, 0xFF, 0x1F, 0xC0,
  0xCF, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x06, 0xDE, 0x03, 0x33, 0xFF, 0x8C, 0x7F,
  0xC3, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x0F, 0x80, 0xC7, 0xFE, 0x0C, 0xF0, 0xF8, 0xDC, 0x03, 0xCF, 0x00, 0x1C,
  0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0,
  0x01, 0xCD, 0x80, 0x1C, 0xDC, 0x07, 0x8C, 0xFF, 0xF0, 0xC3, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xF3, 0xC7, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x08, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x1F, 0x07, 0x0F, 0xFC, 0x71, 0xF0, 0xF7, 0x3C, 0x03, 0x77,
  0x00, 0x1F, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x07, 0x71, 0xFF, 0xE7, 0x07,
  0xFC, 0x70, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7C, 0x3C, 0x1E, 0x01, 0xC3,
  0x00, 0x18, 0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x01, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0x78, 0x07, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x07, 0xFF, 0x8F, 0xFF, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x8C, 0x7C, 0x7D, 0x9E, 0x01,
  0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xB8, 0x00, 0x77, 0x80, 0x1E, 0x78, 0x0E, 0xC7, 0xFF, 0x98, 0x3F, 0xE3,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x73, 0x00, 0x1E, 0x7F, 0xFF, 0x87, 0xFF, 0xC0,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x1F, 0x03, 0x1F, 0xFC, 0x67, 0x8F, 0xCD, 0x80, 0x39, 0xE0, 0x03,
  0xBC, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x6F, 0x76,
  0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x03, 0x03, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0xFE,
  0x7E, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x2C, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x0E, 0x0C, 0x07,
  0x03, 0x03, 0x80, 0xC1, 0xE0, 0x30, 0x70, 0x0C, 0x38, 0x03, 0x1C, 0x00,
  0xCF, 0x00, 0x37, 0xE0, 0x0F, 0x9C, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x30,
  0x1C, 0x0C, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00,
  0x73, 0x00, 0x0E, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0xC7, 0xFC, 0x1F, 0xF8, 0xCF,
  0x1E, 0x3E, 0x7C, 0xD8, 0x07, 0x70, 0x0E, 0xF0, 0x03, 0x60, 0x0E, 0xE0,
  0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0,
  0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0xF8, 0x18, 0xFF, 0xE3, 0x3C, 0x7E, 0x6E, 0x01,
  0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0x1F, 0x83, 0xC0, 0x3C, 0x78, 0x00,
  0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x0C, 0x7F, 0xF0, 0xCF, 0x0F, 0x8D, 0xC0, 0x3C, 0xD8, 0x01,
  0xCF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEF,
  0x00, 0x1C, 0xD8, 0x01, 0xCD, 0xC0, 0x78, 0xCF, 0xFF, 0x0C, 0x3F, 0xC0,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE3, 0x0F, 0x87, 0xB1, 0xC0, 0x1B, 0x38,
  0x00, 0xF3, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00,
  0x73, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x3B, 0x0F, 0xFF, 0x30, 0x3F,
  0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x01, 0xF6, 0x3F, 0xF3, 0xFD, 0xB8, 0x0D, 0x80, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x8F, 0x07, 0xCE,
  0x00, 0x46, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x77, 0x00, 0x73, 0xFF, 0xF8, 0xFF, 0xF0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1B, 0x78, 0x0E, 0xCF, 0xFF, 0x31, 0xFF, 0x0C,
  0xE0, 0x00, 0x3B, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xE0, 0x00,
  0x76, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x1B, 0x80, 0x1F, 0x00,
  0x73, 0x00, 0x36, 0x00, 0xE7, 0x00, 0x6C, 0x01, 0x8E, 0x01, 0xDC, 0x03,
  0x0C, 0x03, 0x38, 0x0E, 0x18, 0x06, 0x30, 0x1C, 0x38, 0x1C, 0x60, 0x30,
  0x70, 0x30, 0xE0, 0x60, 0x60, 0x60, 0xC1, 0xC0, 0xC1, 0xC1, 0x83, 0x81,
  0xC3, 0x03, 0x86, 0x01, 0x86, 0x03, 0x0C, 0x03, 0x1C, 0x06, 0x38, 0x07,
  0x30, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0xC0, 0x0D, 0xC0, 0x19, 0x80, 0x1B,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF3, 0x80, 0x1C,
  0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E,
  0x00, 0x39, 0xC0, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x06,
  0x07, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x9C, 0x00,
  0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0x60, 0x07, 0x03,
  0x80, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x06,
  0x00, 0x70, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x0F, 0xC0, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x03, 0xE0, 0x3C, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x3F, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x0B,
  0xFF, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x7F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 31, 11, 3, -31 },
  { 17, 10, 11, 16, 3, -31 },
  { 31, 26, 31, 28, 1, -31 },
  { 132, 19, 36, 25, 3, -33 },
  { 218, 31, 32, 36, 2, -32 },
  { 342, 28, 32, 32, 3, -32 },
  { 454, 3, 11, 9, 3, -31 },
  { 459, 9, 38, 12, 2, -31 },
  { 502, 9, 38, 12, 1, -31 },
  { 545, 20, 18, 24, 2, -33 },
  { 590, 21, 21, 25, 2, -26 },
  { 646, 5, 11, 10, 2, -5 },
  { 653, 10, 2, 14, 2, -13 },
  { 656, 4, 4, 11, 3, -4 },
  { 658, 14, 31, 15, 1, -31 },
  { 713, 21, 32, 25, 2, -32 },
  { 797, 11, 31, 25, 4, -31 },
  { 840, 20, 32, 25, 2, -32 },
  { 920, 20, 32, 25, 2, -32 },
  { 1000, 23, 32, 25, 1, -32 },
  { 1092, 19, 31, 25, 3, -31 },
  { 1166, 20, 32, 25, 3, -32 },
  { 1246, 21, 31, 25, 2, -31 },
  { 1328, 20, 32, 25, 3, -32 },
  { 1408, 20, 32, 25, 2, -32 },
  { 1488, 4, 24, 11, 3, -24 },
  { 1500, 5, 30, 11, 2, -24 },
  { 1519, 21, 20, 25, 2, -26 },
  { 1572, 21, 11, 25, 2, -21 },
  { 1601, 21, 20, 25, 2, -26 },
  { 1654, 16, 32, 19, 1, -32 },
  { 1718, 35, 35, 39, 2, -31 },
  { 1872, 27, 32, 27, 0, -32 },
  { 1980, 21, 31, 28, 4, -31 },
  { 2062, 23, 32, 27, 3, -32 },
  { 2154, 25, 31, 31, 4, -31 },
  { 2251, 18, 31, 24, 4, -31 },
  { 2321, 18, 31, 22, 4, -31 },
  { 2391, 25, 32, 32, 3, -32 },
  { 2491, 23, 31, 32, 4, -31 },
  { 2581, 9, 31, 14, 2, -31 },
  { 2616, 11, 39, 11, -4, -31 },
  { 2670, 22, 31, 26, 4, -31 },
  { 2756, 18, 31, 23, 4, -31 },
  { 2826, 30, 31, 38, 4, -31 },
  { 2943, 24, 31, 32, 4, -31 },
  { 3036, 28, 32, 34, 3, -32 },
  { 3148, 20, 31, 26, 4, -31 },
  { 3226, 28, 39, 34, 3, -32 },
  { 3363, 21, 31, 26, 4, -31 },
  { 3445, 20, 32, 24, 2, -32 },
  { 3525, 23, 31, 23, 0, -31 },
  { 3615, 24, 31, 32, 4, -31 },
  { 3708, 26, 31, 26, 0, -31 },
  { 3809, 38, 31, 40, 1, -31 },
  { 3957, 24, 31, 24, 0, -31 },
  { 4050, 24, 31, 24, 0, -31 },
  { 4143, 22, 31, 25, 2, -31 },
  { 4229, 9, 38, 14, 4, -31 },
  { 4272, 14, 31, 15, 1, -31 },
  { 4327, 9, 38, 14, 1, -31 },
  { 4370, 21, 20, 25, 2, -32 },
  { 4423, 18, 2, 18, 0, 4 },
  { 4428, 8, 7, 12, 2, -34 },
  { 4435, 18, 24, 24, 2, -24 },
  { 4489, 20, 33, 26, 4, -33 },
  { 4572, 17, 24, 21, 3, -24 },
  { 4623, 20, 33, 26, 3, -33 },
  { 4706, 19, 24, 24, 3, -24 },
  { 4763, 15, 34, 14, 1, -34 },
  { 4827, 19, 35, 26, 3, -24 },
  { 4911, 19, 33, 26, 4, -33 },
  { 4990, 4, 32, 10, 3, -32 },
  { 5006, 9, 43, 10, -2, -32 },
  { 5055, 18, 33, 22, 4, -33 },
  { 5130, 2, 33, 10, 4, -33 },
  { 5139, 32, 24, 39, 4, -24 },
  { 5235, 19, 24, 26, 4, -24 },
  { 5292, 20, 24, 26, 3, -24 },
  { 5352, 20, 34, 26, 4, -24 },
  { 5437, 20, 34, 26, 2, -24 },
  { 5522, 13, 24, 17, 4, -24 },
  { 5561, 17, 24, 21, 2, -24 },
  { 5612, 13, 29, 15, 1, -29 },
  { 5660, 18, 23, 26, 4, -23 },
  { 5712, 21, 23, 21, 0, -23 },
  { 5773, 31, 23, 32, 1, -23 },
  { 5863, 20, 23, 22, 1, -23 },
  { 5921, 21, 34, 21, 0, -23 },
  { 6011, 17, 23, 20, 2, -23 },
  { 6060, 13, 38, 16, 1, -31 },
  { 6122, 2, 45, 24, 11, -34 },
  { 6134, 14, 38, 16, 1, -31 },
  { 6201, 21, 5, 25, 2, -18 },
};

const GFXfont NotoSans_Light44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light44pt7bBitmaps,
  (GFXglyph *)NotoSans_Light44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_LIGHT44PT7B_H_
