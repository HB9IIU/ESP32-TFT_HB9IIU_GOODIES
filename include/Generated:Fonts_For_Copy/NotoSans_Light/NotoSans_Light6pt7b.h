#ifndef _NOTOSANS_LIGHT6PT7B_H_
#define _NOTOSANS_LIGHT6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xFA, 0x5F, 0x3E, 0xD5, 0x9A, 0xA0, 0xE4, 0xBF,
  0x80, 0xF8, 0xF8, 0x55, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6,
  0xF0, 0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xE8, 0xF0, 0xFE, 0xF0,
  0xE5, 0x20, 0xEA, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F,
  0x00, 0xD5, 0x7F, 0xF7, 0x47, 0x00, 0x46, 0x69, 0xFF, 0xF8, 0x86, 0xF6,
  0xE0, 0xFB, 0xFA, 0xFA, 0x97, 0xBE, 0xD0, 0xEB, 0x55, 0xC0, 0xD2, 0x70,
  0xAB, 0x9B, 0xBD, 0xB7, 0xD0, 0xF9, 0x97, 0xFA, 0xF9, 0x97, 0x10, 0xFF,
  0xF8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xAD, 0x56, 0xA0, 0xA9,
  0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0, 0xA5, 0xF8, 0x54, 0xE0, 0x80,
  0x7F, 0x80, 0xAF, 0xC0, 0xF3, 0x80, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80,
  0xF6, 0xB0, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE, 0xC0, 0xF8, 0xFD, 0xD0, 0xFC,
  0xF7, 0x80, 0xFE, 0xF7, 0x90, 0xE0, 0xCB, 0x80, 0xEB, 0xB7, 0x80, 0xB9,
  0x00, 0xBF, 0x50, 0xAA, 0x80, 0xB9, 0x60, 0xEB, 0x80, 0x59, 0x40, 0xFC,
  0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 3, 3, 3, 0, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 3, 3, 3, 0, -4 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 2, 4, 3, 0, -4 },
  { 50, 5, 5, 5, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 1, -4 },
  { 61, 2, 4, 3, 1, -4 },
  { 62, 2, 4, 3, 1, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 1, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, -1, -4 },
  { 70, 3, 4, 4, 1, -4 },
  { 72, 2, 4, 3, 1, -4 },
  { 73, 4, 4, 5, 1, -4 },
  { 75, 3, 4, 4, 1, -4 },
  { 77, 4, 4, 5, 0, -4 },
  { 79, 2, 4, 4, 1, -4 },
  { 80, 4, 5, 5, 0, -4 },
  { 83, 2, 4, 4, 1, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 4, 1, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 5, 4, 5, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 2, 4, 2, 0, -4 },
  { 104, 1, 5, 2, 0, -4 },
  { 105, 3, 2, 3, 0, -4 },
  { 106, 3, 1, 3, 0, 0 },
  { 107, 1, 1, 2, 0, -5 },
  { 108, 3, 3, 3, 0, -3 },
  { 110, 2, 5, 4, 1, -5 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 5, 4, 0, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 2, 5, 2, 0, -5 },
  { 120, 3, 4, 4, 0, -3 },
  { 122, 2, 5, 4, 1, -5 },
  { 124, 1, 4, 1, 0, -4 },
  { 125, 1, 5, 1, 0, -4 },
  { 126, 2, 5, 3, 1, -5 },
  { 128, 1, 5, 1, 0, -5 },
  { 129, 4, 3, 5, 1, -3 },
  { 131, 2, 3, 4, 1, -3 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 2, 4, 4, 1, -3 },
  { 135, 3, 4, 4, 0, -3 },
  { 137, 1, 3, 2, 1, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 2, 4, 2, 0, -4 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 4, 3, 4, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 4, 3, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 2, 5, 2, 0, -4 },
  { 155, 1, 6, 3, 1, -5 },
  { 156, 2, 5, 2, 0, -4 },
  { 158, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Light6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light6pt7bBitmaps,
  (GFXglyph *)NotoSans_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_LIGHT6PT7B_H_
