#ifndef _NOTOSANS_LIGHT68PT7B_H_
#define _NOTOSANS_LIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF,
  0xFF, 0x7C, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0,
  0x18, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x1C, 0x0F, 0x83, 0xE0, 0x70, 0x06, 0x1F,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00,
  0x01, 0xF0, 0x1C, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x0F, 0xF7, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x73, 0xFC, 0x00, 0x01, 0xC3, 0xF8, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80,
  0x01, 0xC0, 0x3C, 0xC0, 0x07, 0x03, 0xF3, 0xE0, 0x1C, 0x3F, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x70, 0x1F, 0x00,
  0xF0, 0x01, 0xE0, 0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0xFF, 0xF0,
  0x70, 0x01, 0xC1, 0xE1, 0xF0, 0xF8, 0x70, 0x03, 0xC1, 0xC3, 0xC0, 0x78,
  0x78, 0x03, 0xC3, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x87, 0x80, 0x1C,
  0x3E, 0x0F, 0x07, 0x07, 0x80, 0x1E, 0x1F, 0xFF, 0x0F, 0x07, 0x00, 0x1E,
  0x0F, 0xFE, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0xF8, 0x1E, 0x0F, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x38, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE0,
  0x1E, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xE7, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x3E, 0x01, 0xFE, 0x00, 0x7F, 0x81,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x03, 0xBF, 0x01, 0xC0, 0x7E, 0xFF,
  0x87, 0x0F, 0xFF, 0xFF, 0xDD, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xFF, 0xFD, 0xF3, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0xEF, 0x07, 0xCF, 0x1F, 0x8F, 0x3F, 0x0F, 0x7C,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x3E, 0x08, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0C, 0x00,
  0x00, 0x3E, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF4, 0x00, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x20,
  0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x01, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xE0, 0x07, 0x03, 0xFF, 0xF0, 0x0E,
  0x1F, 0xFF, 0xF8, 0x3C, 0x7E, 0x03, 0xF8, 0x79, 0xE0, 0x00, 0xF8, 0xF7,
  0x80, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x00, 0xF7, 0xE0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xDE,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x01, 0xDE, 0x7E,
  0x00, 0x0F, 0x3C, 0x7E, 0x00, 0x7C, 0x70, 0x7F, 0xFF, 0xF0, 0xE0, 0x3F,
  0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x07, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x04, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x39, 0xFF, 0xFF, 0xFD, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x7F, 0xFF, 0xFF, 0x7C, 0xE0, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0x00, 0x07, 0xE2, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0x87, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1E, 0x38, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x9E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0xE7, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xC0,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07,
  0x70, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xDC, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1E, 0xE0, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0xE7, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x3C, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x79, 0xE0, 0x03, 0xC0, 0x07, 0xB8, 0x07, 0x87, 0x00,
  0x0F, 0x00, 0x79, 0xC0, 0x78, 0x38, 0x00, 0x7F, 0x1F, 0x8F, 0xCF, 0xC1,
  0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFD,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x01,
  0xE0, 0x0F, 0xC0, 0x00, 0x02, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x20, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x78, 0x00,
  0x01, 0xFE, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x01,
  0xF8, 0x3C, 0x00, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x60, 0x7E, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC7, 0xF0,
  0x00, 0x01, 0xE7, 0xF8, 0x00, 0x00, 0xF7, 0xBE, 0x00, 0x00, 0x7F, 0x8F,
  0x80, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0xF0,
  0x00, 0x00, 0x00, 0x7B, 0xF9, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0x3F, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0x3C, 0x00,
  0x00, 0x00, 0xE3, 0xFC, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x3F, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xFF, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xFC, 0x3C, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x3F, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xFC, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x00, 0xE0,
  0x3F, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3F,
  0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFC,
  0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xFC, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x00, 0xFE, 0x7C,
  0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x0F,
  0xE1, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x78, 0x00,
  0x00, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0xFF, 0x01,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0x00,
  0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x1E, 0x0F,
  0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00,
  0x78, 0xFF, 0x00, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0x00, 0x3E, 0xFF, 0x00,
  0x00, 0x01, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0xFC, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x03, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x87, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xF1, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xEF, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x60, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x0F,
  0x1F, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x78,
  0x00, 0x07, 0xF7, 0x80, 0x00, 0x7F, 0x7C, 0x00, 0x1E, 0xF3, 0xF0, 0x07,
  0xC7, 0x1F, 0xFF, 0xF8, 0x70, 0xFF, 0xFF, 0x07, 0x07, 0xFF, 0xC0, 0x70,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xF8, 0x00, 0xF0, 0x3F, 0xFE, 0x01, 0xE1, 0xFF, 0xFE,
  0x03, 0xC7, 0xFB, 0xFF, 0x07, 0x9E, 0x00, 0x3F, 0x0F, 0x78, 0x00, 0x3E,
  0x1F, 0xC0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x1E, 0x3F, 0x80, 0x00, 0x7C, 0x73, 0x80, 0x01, 0xF0, 0xE7, 0xC0, 0x0F,
  0xC1, 0xC7, 0xFF, 0xFF, 0x03, 0x83, 0xFF, 0xFC, 0x07, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0x83, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x41, 0xFC, 0x00, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x0F, 0x00,
  0x7F, 0xFC, 0x1E, 0x03, 0xFF, 0xFC, 0x3C, 0x1F, 0xFB, 0xFC, 0x78, 0x7F,
  0x00, 0x3C, 0xF0, 0xF8, 0x00, 0x1D, 0xE3, 0xE0, 0x00, 0x1F, 0xCF, 0x80,
  0x00, 0x3F, 0x9E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF0, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF3,
  0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xEF, 0x0F, 0xE0, 0x07, 0x9E, 0x0F, 0xFF, 0xFE, 0x3C, 0x07,
  0xFF, 0xF8, 0x38, 0x07, 0xFF, 0xC0, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x10, 0x1F, 0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x0E, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x1C, 0x07, 0xFF, 0xF8, 0x78, 0x3F, 0xF7,
  0xFC, 0xF0, 0xFE, 0x00, 0x7D, 0xE1, 0xF0, 0x00, 0x3B, 0xC7, 0xC0, 0x00,
  0x3F, 0x9F, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x8F, 0x80,
  0x00, 0xEF, 0x1F, 0x80, 0x03, 0xDE, 0x1F, 0xC0, 0x1F, 0x3C, 0x1F, 0xFF,
  0xFC, 0x78, 0x0F, 0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x10, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x3F,
  0xFE, 0x07, 0x87, 0xFF, 0xFC, 0x3C, 0x7F, 0xBF, 0xF1, 0xE7, 0x80, 0x0F,
  0xCF, 0x70, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xDF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x21, 0xEF, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00,
  0x10, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x20, 0x7E, 0x7F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0xF3, 0xF8, 0x00, 0x1E, 0x7F, 0x80, 0x03, 0xDE, 0xF0,
  0x00, 0x7F, 0x8F, 0x00, 0x0F, 0xE1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3E,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x38, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x1C, 0x7F, 0xBF, 0xE1, 0xFF,
  0x7F, 0xCE, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xB8, 0x00, 0x7C, 0xE0,
  0x00, 0xFB, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xF0, 0x07, 0x01, 0xFF, 0xF0, 0x38, 0x3F, 0xFF, 0xE1, 0xC3,
  0xFD, 0xFF, 0x8E, 0x3C, 0x00, 0x7E, 0x7B, 0x80, 0x01, 0xF3, 0xF8, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xC0, 0x7F, 0xFC, 0x03, 0x83, 0xFF, 0xFE, 0x07, 0x0F,
  0xF7, 0xFE, 0x0E, 0x3C, 0x00, 0x7E, 0x1E, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x7C, 0x7F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x3C, 0x7F,
  0x80, 0x00, 0xF8, 0xF7, 0x80, 0x03, 0xE1, 0xE7, 0xC0, 0x1F, 0x83, 0xC7,
  0xFF, 0xFE, 0x07, 0x87, 0xFF, 0xF8, 0x0F, 0x03, 0xFF, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x1C, 0x07, 0xFF, 0xF8,
  0x78, 0x3F, 0xF7, 0xF8, 0xF0, 0xFC, 0x00, 0x79, 0xE1, 0xF0, 0x00, 0x7B,
  0xC7, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x8F, 0x00, 0x00, 0xEF, 0x1F, 0x80, 0x03, 0xDE, 0x1F, 0x80, 0x1F,
  0x3C, 0x1F, 0xFF, 0xFC, 0x78, 0x1F, 0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0x81,
  0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xEE, 0x07, 0xFF, 0xE0, 0xFF, 0xEE, 0x1F,
  0xFE, 0xE3, 0xE0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7,
  0xFC, 0x3F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x47, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x07, 0x77,
  0xC0, 0x00, 0xF7, 0x3F, 0x00, 0x3E, 0x71, 0xFF, 0xFF, 0xC7, 0x0F, 0xFF,
  0xF0, 0x70, 0x3F, 0xFE, 0x07, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x38,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0,
  0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0,
  0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x01, 0xE3, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x77, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x05, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xA0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 50, 17, 5, -49 },
  { 39, 15, 18, 25, 5, -49 },
  { 73, 40, 49, 44, 2, -49 },
  { 318, 30, 56, 39, 4, -52 },
  { 528, 48, 50, 55, 4, -49 },
  { 828, 44, 50, 49, 4, -49 },
  { 1103, 4, 18, 14, 5, -49 },
  { 1112, 14, 60, 19, 3, -49 },
  { 1217, 14, 60, 19, 2, -49 },
  { 1322, 30, 29, 37, 4, -52 },
  { 1431, 31, 32, 39, 4, -40 },
  { 1555, 8, 17, 15, 3, -8 },
  { 1572, 16, 3, 22, 3, -20 },
  { 1578, 6, 7, 17, 5, -6 },
  { 1584, 22, 49, 24, 1, -49 },
  { 1719, 31, 50, 39, 4, -49 },
  { 1913, 16, 49, 39, 7, -49 },
  { 2011, 30, 49, 39, 4, -49 },
  { 2195, 31, 50, 39, 3, -49 },
  { 2389, 36, 49, 39, 2, -49 },
  { 2610, 30, 50, 39, 5, -49 },
  { 2798, 31, 50, 39, 4, -49 },
  { 2992, 32, 49, 39, 3, -49 },
  { 3188, 31, 50, 39, 4, -49 },
  { 3382, 31, 50, 39, 4, -49 },
  { 3576, 6, 38, 17, 5, -37 },
  { 3605, 9, 46, 17, 2, -37 },
  { 3657, 31, 32, 39, 4, -41 },
  { 3781, 31, 17, 39, 4, -32 },
  { 3847, 31, 32, 39, 4, -41 },
  { 3971, 25, 50, 29, 2, -49 },
  { 4128, 53, 54, 60, 4, -48 },
  { 4486, 41, 49, 41, 0, -49 },
  { 4738, 32, 49, 43, 7, -49 },
  { 4934, 36, 50, 42, 4, -49 },
  { 5159, 37, 49, 48, 7, -49 },
  { 5386, 26, 49, 38, 7, -49 },
  { 5546, 27, 49, 34, 7, -49 },
  { 5712, 40, 50, 49, 4, -49 },
  { 5962, 35, 49, 49, 7, -49 },
  { 6177, 15, 49, 21, 3, -49 },
  { 6269, 17, 61, 17, -6, -49 },
  { 6399, 33, 49, 40, 7, -49 },
  { 6602, 27, 49, 35, 7, -49 },
  { 6768, 46, 49, 59, 7, -49 },
  { 7050, 36, 49, 50, 7, -49 },
  { 7271, 44, 50, 52, 4, -49 },
  { 7546, 29, 49, 40, 7, -49 },
  { 7724, 44, 61, 52, 4, -49 },
  { 8060, 32, 49, 41, 7, -49 },
  { 8256, 30, 50, 37, 4, -49 },
  { 8444, 36, 49, 36, 0, -49 },
  { 8665, 37, 50, 49, 6, -49 },
  { 8897, 40, 49, 40, 0, -49 },
  { 9142, 58, 49, 61, 2, -49 },
  { 9498, 37, 49, 37, 0, -49 },
  { 9725, 36, 49, 36, 0, -49 },
  { 9946, 33, 49, 39, 3, -49 },
  { 10149, 14, 60, 22, 6, -49 },
  { 10254, 22, 49, 24, 1, -49 },
  { 10389, 14, 60, 22, 2, -49 },
  { 10494, 33, 30, 39, 3, -49 },
  { 10618, 29, 3, 28, 0, 6 },
  { 10629, 12, 11, 18, 3, -52 },
  { 10646, 28, 38, 36, 3, -37 },
  { 10779, 31, 53, 41, 6, -52 },
  { 10985, 26, 38, 32, 4, -37 },
  { 11109, 31, 53, 41, 4, -52 },
  { 11315, 30, 38, 38, 4, -37 },
  { 11458, 24, 52, 21, 1, -52 },
  { 11614, 31, 53, 41, 4, -37 },
  { 11820, 29, 52, 41, 6, -52 },
  { 12009, 6, 50, 16, 5, -50 },
  { 12047, 15, 66, 16, -4, -50 },
  { 12171, 27, 52, 34, 6, -52 },
  { 12347, 4, 52, 16, 6, -52 },
  { 12373, 49, 37, 61, 6, -37 },
  { 12600, 29, 37, 41, 6, -37 },
  { 12735, 32, 38, 40, 4, -37 },
  { 12887, 31, 53, 41, 6, -37 },
  { 13093, 31, 53, 41, 4, -37 },
  { 13299, 20, 37, 27, 6, -37 },
  { 13392, 26, 38, 32, 3, -37 },
  { 13516, 20, 46, 23, 1, -45 },
  { 13631, 28, 37, 41, 6, -36 },
  { 13761, 32, 36, 32, 0, -36 },
  { 13905, 48, 36, 50, 1, -36 },
  { 14121, 32, 36, 34, 1, -36 },
  { 14265, 32, 52, 32, 0, -36 },
  { 14473, 26, 36, 31, 3, -36 },
  { 14590, 20, 60, 24, 2, -49 },
  { 14740, 3, 69, 37, 17, -52 },
  { 14766, 21, 60, 24, 2, -49 },
  { 14924, 31, 8, 39, 4, -28 },
};

const GFXfont NotoSans_Light68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light68pt7bBitmaps,
  (GFXglyph *)NotoSans_Light68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_LIGHT68PT7B_H_
