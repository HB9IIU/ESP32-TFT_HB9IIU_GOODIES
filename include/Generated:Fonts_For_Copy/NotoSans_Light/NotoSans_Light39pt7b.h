#ifndef _NOTOSANS_LIGHT39PT7B_H_
#define _NOTOSANS_LIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x00, 0x0E, 0xFE, 0xC3, 0xE1, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86,
  0xC1, 0x60, 0x80, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xFC, 0x06, 0x02, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x7E, 0x01, 0xFF, 0xF1, 0xE6,
  0x79, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x38, 0x30, 0x0C,
  0x18, 0x07, 0x0C, 0x01, 0xC6, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x31, 0xC0, 0x18, 0x70, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x06, 0x01, 0x83, 0x00, 0xC3, 0xC0, 0x63, 0x9E, 0x37, 0xCF, 0xFF, 0x80,
  0xFE, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x1F, 0x00, 0x0E, 0x03,
  0xB8, 0x00, 0xC0, 0x60, 0xC0, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x06, 0x0E, 0x00,
  0xC0, 0x60, 0xC0, 0x0C, 0x06, 0x18, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x06,
  0x30, 0xF0, 0x40, 0x63, 0x3F, 0xC6, 0x0C, 0x63, 0x0C, 0x60, 0xC6, 0x60,
  0x63, 0xF8, 0xC6, 0x06, 0x1F, 0x1C, 0x60, 0x60, 0x01, 0x84, 0x02, 0x00,
  0x30, 0xC0, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x06, 0x04,
  0x02, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x06, 0x06, 0x01, 0x80, 0x60, 0x60,
  0x38, 0x03, 0x0C, 0x03, 0x00, 0x39, 0xC0, 0x60, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x78, 0x70, 0x06,
  0x30, 0x1C, 0x07, 0x38, 0x07, 0x03, 0x18, 0x01, 0xC3, 0x9C, 0x00, 0x71,
  0x8E, 0x00, 0x1D, 0xC7, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0xF0, 0x70, 0x01, 0xDC, 0x1C, 0x03, 0xC7, 0x07, 0xFF, 0xC1, 0xC1, 0xFF,
  0x80, 0x70, 0xFF, 0xFF, 0xF0, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x30,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x07, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0xE0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x03, 0x83, 0x07, 0xF9, 0x3F, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x6C, 0x00, 0x63, 0x00, 0x70, 0xC0, 0x30, 0x70, 0x38, 0x1C, 0x08,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x37, 0x77, 0x66, 0xEC, 0xC8,
  0xFF, 0xFF, 0xC0, 0xEF, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0x30, 0x03, 0x1C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07,
  0x60, 0x01, 0x98, 0x00, 0x67, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x07, 0x07,
  0x03, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0x81, 0xC3, 0xE3, 0xB3, 0x9F,
  0x0F, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0x80, 0xE1, 0x80, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0x00, 0xE1,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0xB0, 0x03, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80,
  0x01, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0xFE,
  0x3F, 0xFF, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0D, 0xFC, 0x0F,
  0xFF, 0x83, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x60, 0x0F, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x8F,
  0xF0, 0x67, 0xFF, 0x3B, 0x00, 0xCF, 0x80, 0x1B, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x37,
  0x00, 0x1C, 0xC0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xFF, 0xE0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x70, 0xC0,
  0x0E, 0x70, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03,
  0x8C, 0x00, 0xC1, 0xC0, 0x60, 0x38, 0x70, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0xF7, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x1C, 0x00, 0x66, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x03,
  0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0x80, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0x18, 0x00, 0x6E, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01,
  0xDC, 0x00, 0xF3, 0x80, 0x6C, 0x7D, 0xF3, 0x0F, 0xF1, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0xBF, 0x80, 0xFF, 0x80, 0xEF, 0xE4,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x39, 0xCE, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x63, 0x39, 0x8C,
  0x66, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xE3, 0xFF, 0xCC, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x07, 0xF8, 0x0C, 0x60,
  0x3F, 0xF8, 0x19, 0x80, 0xE0, 0x30, 0x33, 0x01, 0x80, 0x60, 0x66, 0x06,
  0x00, 0xC0, 0x58, 0x0C, 0x01, 0x80, 0xF0, 0x30, 0x03, 0x01, 0xE0, 0x60,
  0x06, 0x02, 0xC0, 0xC0, 0x18, 0x0D, 0x81, 0x80, 0x30, 0x1B, 0x03, 0x00,
  0x60, 0x36, 0x07, 0x00, 0xC0, 0x6C, 0x06, 0x03, 0xC1, 0x8C, 0x0E, 0x0D,
  0x87, 0x18, 0x0F, 0xF1, 0xFC, 0x30, 0x03, 0x81, 0xE0, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x01, 0x81,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0x00, 0x7C, 0x60,
  0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x01, 0xD8, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x03, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF0, 0x30, 0x0F, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x0E, 0xC0, 0x03, 0x98, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xF0, 0x0E, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30, 0x07, 0xC1, 0x80, 0x07, 0x8C,
  0x00, 0x1E, 0x60, 0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x00,
  0x03, 0x98, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0x7F, 0xFE, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0x00, 0x30, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x0F, 0x00, 0x1C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0xFF,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x07, 0x7F, 0x3F, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x33, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0,
  0xE0, 0x18, 0x38, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0xF0, 0x01, 0xBE,
  0x00, 0x3E, 0xE0, 0x07, 0x8E, 0x00, 0xE0, 0xE0, 0x18, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x1C, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x03, 0x86, 0x00,
  0x38, 0xC0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x70, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xD8, 0x00, 0x06, 0xF6, 0x00, 0x01, 0xBC,
  0xC0, 0x00, 0xCF, 0x30, 0x00, 0x33, 0xCE, 0x00, 0x1C, 0xF1, 0x80, 0x06,
  0x3C, 0x60, 0x01, 0x8F, 0x0C, 0x00, 0xC3, 0xC3, 0x00, 0x30, 0xF0, 0xE0,
  0x1C, 0x3C, 0x18, 0x06, 0x0F, 0x06, 0x01, 0x83, 0xC1, 0xC0, 0xC0, 0xF0,
  0x30, 0x30, 0x3C, 0x0E, 0x1C, 0x0F, 0x01, 0x86, 0x03, 0xC0, 0x61, 0x80,
  0xF0, 0x1C, 0xC0, 0x3C, 0x03, 0x30, 0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7D, 0x80, 0x03,
  0xEE, 0x00, 0x1F, 0x38, 0x00, 0xF8, 0xC0, 0x07, 0xC7, 0x00, 0x3E, 0x1C,
  0x01, 0xF0, 0xE0, 0x0F, 0x83, 0x80, 0x7C, 0x0E, 0x03, 0xE0, 0x70, 0x1F,
  0x01, 0xC0, 0xF8, 0x07, 0x07, 0xC0, 0x38, 0x3E, 0x00, 0xE1, 0xF0, 0x03,
  0x8F, 0x80, 0x1C, 0x7C, 0x00, 0x73, 0xE0, 0x01, 0xDF, 0x00, 0x0E, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x30, 0x0F, 0x98, 0x01, 0xEC, 0x00, 0x76, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76,
  0x00, 0x73, 0x03, 0xF1, 0xFF, 0xE0, 0xFF, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0xF8, 0x60, 0x03, 0x8C,
  0x00, 0x31, 0x80, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x03, 0x98,
  0x00, 0x73, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x38, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xE0, 0x60,
  0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00, 0x38, 0xC0,
  0x03, 0x18, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x70, 0x07, 0xFE, 0x0F,
  0xFF, 0xCF, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x60, 0x07, 0xBF, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x70, 0x00,
  0xE1, 0xE0, 0x1E, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x07, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x38,
  0x00, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0x70, 0x00, 0xEC, 0x00, 0x6C, 0x00, 0x66, 0x00,
  0x36, 0x00, 0x33, 0x80, 0x1B, 0x00, 0x38, 0xC0, 0x1D, 0x80, 0x1C, 0x60,
  0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x1C, 0x03, 0x18, 0x07, 0x06,
  0x03, 0x8E, 0x03, 0x03, 0x01, 0x83, 0x01, 0x81, 0xC0, 0xC1, 0x80, 0xC0,
  0xE0, 0x60, 0xC0, 0xE0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x30, 0x18, 0x30,
  0x0E, 0x18, 0x0C, 0x38, 0x03, 0x1C, 0x07, 0x1C, 0x01, 0x8C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x67, 0x00, 0x1B, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x03,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x39, 0x80, 0x03, 0x8E, 0x00, 0x18, 0x30, 0x01,
  0xC0, 0xC0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xE0, 0x60, 0x03,
  0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xCC, 0x00, 0x0C,
  0x70, 0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x60, 0x38, 0x07, 0x00, 0xC0,
  0x30, 0x07, 0x03, 0x00, 0x18, 0x38, 0x00, 0x61, 0x80, 0x03, 0x98, 0x00,
  0x0D, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C,
  0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x70, 0x06, 0x01, 0x80,
  0x70, 0x06, 0x03, 0x00, 0x30, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00,
  0x18, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8,
  0x00, 0x33, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xC1, 0xC1,
  0xC1, 0xC1, 0x81, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x38, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x03, 0xFF,
  0x1F, 0xFF, 0x38, 0x03, 0x70, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1B, 0x7F, 0xF3, 0x3F, 0xE3, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0xFE, 0x0E, 0x7F, 0xE3, 0xB0,
  0x1C, 0xF8, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xBC, 0x00, 0x6F, 0x00, 0x3B, 0x60,
  0x1C, 0xCF, 0xFE, 0x31, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x78, 0x09,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x08, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xFC, 0x30, 0xFF, 0xCC, 0x70,
  0x1B, 0x38, 0x03, 0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x3C, 0xE0,
  0x1B, 0x1F, 0xFC, 0xC1, 0xFE, 0x30, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0x03,
  0x87, 0x00, 0xE3, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x41, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x70, 0x41, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xFF, 0xCF, 0xFF, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xF8, 0xC3, 0xFF,
  0x31, 0xC0, 0x6C, 0xE0, 0x0F, 0x70, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xCC, 0x00,
  0xF3, 0x80, 0x6C, 0x7F, 0xF3, 0x07, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x80, 0x1C, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x71,
  0xFC, 0x39, 0xFF, 0x9F, 0x80, 0xEF, 0x80, 0x37, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0C, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0xFE, 0xFC, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00, 0xEF, 0x00,
  0xFB, 0x80, 0xF1, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xF0, 0x1F, 0x86,
  0x7F, 0xE3, 0xFF, 0x37, 0x07, 0xB8, 0x3D, 0xE0, 0x1F, 0x00, 0x6F, 0x00,
  0x78, 0x03, 0x70, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0x80, 0xC3, 0xF8, 0x63, 0xFF, 0x33, 0x01, 0xDB, 0x00, 0x6F, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x18, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01,
  0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06,
  0x70, 0x01, 0xC7, 0x00, 0x70, 0x70, 0x1C, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0xC3, 0xF8, 0x31, 0xFF, 0x8C, 0xC0, 0x73, 0x60, 0x0E, 0xF0, 0x01, 0xB8,
  0x00, 0x6E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x06,
  0xF0, 0x01, 0xBC, 0x00, 0xEF, 0xC0, 0x73, 0xBF, 0xF8, 0xE3, 0xFC, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0xC3, 0xFF,
  0x31, 0xC0, 0xEC, 0xE0, 0x0F, 0x70, 0x03, 0xD8, 0x00, 0x76, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xCC, 0x00,
  0xF3, 0x80, 0x6C, 0x7F, 0xF3, 0x07, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0xC3, 0xFC, 0x7F, 0xCC, 0x0D, 0x80, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0xF9, 0xC0, 0x27, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1A, 0x00, 0x77,
  0xEF, 0xC7, 0xFE, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03,
  0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xB0, 0x03, 0xDC, 0x03, 0x67,
  0xFF, 0x31, 0xFF, 0x18, 0xC0, 0x00, 0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x1C, 0x18, 0x06,
  0x03, 0x03, 0x80, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00,
  0x71, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80,
  0x38, 0x03, 0xF0, 0x0D, 0x80, 0x66, 0x01, 0xB0, 0x0C, 0xC0, 0x36, 0x03,
  0x9C, 0x0C, 0x60, 0x61, 0x81, 0x8C, 0x0C, 0x30, 0x31, 0x81, 0x86, 0x0E,
  0x38, 0x70, 0xE1, 0x83, 0x0C, 0x0C, 0x30, 0x61, 0x81, 0x8E, 0x0E, 0x30,
  0x31, 0x80, 0xCE, 0x03, 0x30, 0x19, 0x80, 0x6E, 0x03, 0x30, 0x0D, 0x80,
  0x36, 0x01, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0xE0, 0x01, 0x9C, 0x00, 0xC3, 0x00, 0x70, 0x60, 0x38,
  0x1C, 0x0C, 0x03, 0x07, 0x00, 0x63, 0x80, 0x1C, 0xC0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0x70, 0x01, 0xCC, 0x00, 0xE1,
  0x80, 0x30, 0x70, 0x1C, 0x0C, 0x0E, 0x01, 0x83, 0x00, 0x71, 0x80, 0x0E,
  0xE0, 0x01, 0xC0, 0xC0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x06,
  0x30, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x1C, 0x1C, 0x06, 0x03,
  0x03, 0x80, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x0C, 0xE0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x1F, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0xF8, 0x0F, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xF0, 0x0F, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0xFC, 0x0F, 0x00, 0x3E, 0x00, 0x5F, 0xF0, 0x1C, 0x1F, 0xFE, 0x00,
  0xFE,
};

const GFXglyph NotoSans_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 28, 10, 3, -28 },
  { 15, 9, 10, 14, 3, -28 },
  { 27, 23, 28, 25, 1, -28 },
  { 108, 17, 32, 22, 2, -30 },
  { 176, 28, 28, 32, 2, -28 },
  { 274, 25, 28, 28, 2, -28 },
  { 362, 2, 10, 8, 3, -28 },
  { 365, 8, 34, 11, 2, -28 },
  { 399, 8, 34, 11, 1, -28 },
  { 433, 17, 17, 21, 2, -30 },
  { 470, 18, 18, 22, 2, -23 },
  { 511, 4, 10, 9, 2, -5 },
  { 516, 9, 2, 13, 2, -12 },
  { 519, 4, 3, 10, 3, -3 },
  { 521, 13, 28, 14, 0, -28 },
  { 567, 18, 28, 22, 2, -28 },
  { 630, 9, 28, 22, 4, -28 },
  { 662, 18, 28, 22, 2, -28 },
  { 725, 18, 28, 22, 2, -28 },
  { 788, 21, 28, 22, 1, -28 },
  { 862, 17, 28, 22, 3, -28 },
  { 922, 18, 28, 22, 2, -28 },
  { 985, 18, 28, 22, 2, -28 },
  { 1048, 18, 28, 22, 2, -28 },
  { 1111, 18, 28, 22, 2, -28 },
  { 1174, 4, 21, 10, 3, -21 },
  { 1185, 5, 26, 10, 1, -21 },
  { 1202, 18, 18, 22, 2, -23 },
  { 1243, 18, 10, 22, 2, -19 },
  { 1266, 18, 18, 22, 2, -23 },
  { 1307, 14, 28, 17, 1, -28 },
  { 1356, 31, 32, 35, 2, -28 },
  { 1480, 24, 28, 24, 0, -28 },
  { 1564, 19, 28, 25, 4, -28 },
  { 1631, 21, 28, 24, 2, -28 },
  { 1705, 21, 28, 28, 4, -28 },
  { 1779, 15, 28, 22, 4, -28 },
  { 1832, 15, 28, 20, 4, -28 },
  { 1885, 23, 28, 28, 2, -28 },
  { 1966, 20, 28, 28, 4, -28 },
  { 2036, 8, 28, 12, 2, -28 },
  { 2064, 9, 35, 10, -3, -28 },
  { 2104, 19, 28, 23, 4, -28 },
  { 2171, 15, 28, 20, 4, -28 },
  { 2224, 26, 28, 34, 4, -28 },
  { 2315, 21, 28, 28, 4, -28 },
  { 2389, 26, 28, 30, 2, -28 },
  { 2480, 17, 28, 23, 4, -28 },
  { 2540, 26, 35, 30, 2, -28 },
  { 2654, 19, 28, 23, 4, -28 },
  { 2721, 17, 28, 21, 2, -28 },
  { 2781, 20, 28, 21, 0, -28 },
  { 2851, 21, 28, 28, 4, -28 },
  { 2925, 23, 28, 23, 0, -28 },
  { 3006, 33, 28, 35, 1, -28 },
  { 3122, 21, 28, 21, 0, -28 },
  { 3196, 21, 28, 21, 0, -28 },
  { 3270, 20, 28, 22, 1, -28 },
  { 3340, 9, 34, 13, 3, -28 },
  { 3379, 13, 28, 14, 0, -28 },
  { 3425, 8, 34, 13, 1, -28 },
  { 3459, 19, 17, 22, 2, -28 },
  { 3500, 16, 1, 16, 0, 4 },
  { 3502, 7, 6, 10, 2, -30 },
  { 3508, 16, 21, 21, 2, -21 },
  { 3550, 18, 30, 23, 3, -30 },
  { 3618, 15, 21, 19, 2, -21 },
  { 3658, 18, 30, 23, 2, -30 },
  { 3726, 17, 21, 22, 2, -21 },
  { 3771, 14, 30, 12, 0, -30 },
  { 3824, 18, 30, 23, 2, -21 },
  { 3892, 17, 30, 23, 3, -30 },
  { 3956, 3, 28, 9, 3, -28 },
  { 3967, 8, 37, 9, -2, -28 },
  { 4004, 16, 30, 19, 3, -30 },
  { 4064, 3, 30, 9, 3, -30 },
  { 4076, 29, 21, 35, 3, -21 },
  { 4153, 17, 21, 23, 3, -21 },
  { 4198, 19, 21, 23, 2, -21 },
  { 4248, 18, 30, 23, 3, -21 },
  { 4316, 18, 30, 23, 2, -21 },
  { 4384, 12, 21, 15, 3, -21 },
  { 4416, 15, 21, 18, 2, -21 },
  { 4456, 12, 26, 13, 0, -26 },
  { 4495, 17, 21, 23, 3, -21 },
  { 4540, 18, 21, 18, 0, -21 },
  { 4588, 27, 21, 29, 1, -21 },
  { 4659, 18, 21, 20, 1, -21 },
  { 4707, 18, 30, 18, 0, -21 },
  { 4775, 14, 21, 18, 2, -21 },
  { 4812, 12, 34, 14, 1, -28 },
  { 4863, 2, 40, 21, 10, -30 },
  { 4873, 12, 34, 14, 1, -28 },
  { 4924, 18, 4, 22, 2, -16 },
};

const GFXfont NotoSans_Light39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light39pt7bBitmaps,
  (GFXglyph *)NotoSans_Light39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_LIGHT39PT7B_H_
