#ifndef _NOTOSANS_LIGHT50PT7B_H_
#define _NOTOSANS_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x20, 0xF0, 0x77, 0x07, 0x60,
  0x76, 0x07, 0x60, 0x76, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3,
  0xE3, 0x1F, 0x1E, 0x0C, 0x08, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x00,
  0x1E, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x7C, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x3E, 0x00, 0x0C,
  0x3C, 0x00, 0x30, 0x78, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0xC0, 0x0C, 0x07,
  0x00, 0x30, 0x1C, 0x00, 0xC0, 0xF0, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x80,
  0x30, 0xF3, 0xE0, 0xCF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xC0, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x01,
  0x80, 0x38, 0x1C, 0x00, 0x70, 0x06, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xC0,
  0x1C, 0x07, 0x00, 0x18, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x0E, 0x06, 0x00, 0x0C, 0x01, 0xC1, 0xC0, 0x01, 0x80, 0x38, 0x30,
  0x00, 0x30, 0x07, 0x0E, 0x1F, 0x07, 0x00, 0xE3, 0x87, 0xF8, 0xE0, 0x18,
  0x71, 0xE7, 0x8C, 0x07, 0x1C, 0x70, 0x31, 0xC0, 0xE3, 0x0C, 0x07, 0x1C,
  0x38, 0xE3, 0x80, 0x63, 0xFE, 0x18, 0x70, 0x0C, 0x1F, 0x87, 0x0C, 0x01,
  0xC0, 0x00, 0xC1, 0x80, 0x38, 0x00, 0x38, 0x30, 0x07, 0x00, 0x0E, 0x06,
  0x00, 0xE0, 0x01, 0xC0, 0xC0, 0x1C, 0x00, 0x70, 0x18, 0x03, 0x80, 0x0C,
  0x03, 0x00, 0x70, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x03, 0x81,
  0xC0, 0x38, 0x00, 0x70, 0x70, 0x07, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x1C, 0x3C, 0x07, 0x00, 0x1C, 0x78, 0x03, 0x80, 0x1C, 0x70, 0x01,
  0xC0, 0x38, 0xF0, 0x00, 0xE0, 0x38, 0xE0, 0x00, 0x70, 0x70, 0xE0, 0x00,
  0x3C, 0x70, 0xE0, 0x00, 0x1E, 0xE0, 0xE0, 0x00, 0x0F, 0xE0, 0xE0, 0x00,
  0x07, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x1E, 0xE0, 0x3C, 0x00, 0x3C, 0x70, 0x3F, 0x01, 0xF8, 0x38, 0x0F, 0xFF,
  0xE0, 0x1C, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x00, 0xF7, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x30, 0x0C, 0x06, 0xF8, 0x30, 0xFF, 0xFC, 0xDF, 0xF1, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0xE3, 0x80, 0x07, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x38, 0x07,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0xF3, 0xCE, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x20, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0x1F, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x71,
  0xE7, 0x78, 0x7F, 0x07, 0xE0, 0x74, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0x78, 0x60, 0x00, 0xF1,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFE, 0x0F, 0xC3, 0xE0, 0x03,
  0xC7, 0x00, 0x03, 0x84, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x79,
  0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x20, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0xF1, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x40, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x3F, 0xE0, 0x71, 0xFF, 0xF0, 0xE7,
  0x81, 0xF1, 0xDC, 0x00, 0xF3, 0xF0, 0x00, 0xE7, 0xC0, 0x00, 0xEF, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x78,
  0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7E, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x03, 0xC0, 0x1C,
  0x03, 0xC0, 0xF0, 0x03, 0xF7, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x78, 0x1F, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x0F, 0x1C,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7E, 0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0xD8, 0xE0,
  0x03, 0xB1, 0xF0, 0x1E, 0x61, 0xFF, 0xF9, 0xC0, 0xFF, 0xC3, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x40, 0x3E, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF2, 0x1C, 0xF3, 0xCF, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF3, 0xCE, 0x38, 0xE7, 0x1C, 0x71, 0x86, 0x38, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC3, 0xF8, 0xFC,
  0x30, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x00, 0x61, 0xC0, 0x0F, 0xFF, 0x80, 0xE7, 0x00, 0x3F, 0xFF, 0x01,
  0xCE, 0x00, 0xF0, 0x0C, 0x01, 0x98, 0x03, 0x80, 0x18, 0x03, 0x70, 0x0E,
  0x00, 0x30, 0x07, 0xE0, 0x1C, 0x00, 0x60, 0x0F, 0xC0, 0x70, 0x00, 0xC0,
  0x1F, 0x00, 0xE0, 0x01, 0x80, 0x3E, 0x01, 0xC0, 0x03, 0x00, 0x7C, 0x03,
  0x80, 0x06, 0x00, 0xF8, 0x07, 0x00, 0x1C, 0x01, 0xB0, 0x0E, 0x00, 0x38,
  0x03, 0x60, 0x1C, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x00, 0xE0, 0x1D, 0xC0,
  0x70, 0x03, 0xC0, 0x33, 0x80, 0x70, 0x07, 0x80, 0xE7, 0x00, 0xF0, 0x39,
  0x83, 0x86, 0x00, 0xFF, 0xE3, 0xFE, 0x0E, 0x00, 0xFF, 0x83, 0xF8, 0x1C,
  0x00, 0x10, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x7C, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xF0, 0x00, 0x60, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40,
  0x7F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0xFC, 0x0E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xC7, 0x00, 0x01,
  0xF0, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xC1, 0xFE, 0x03, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x38, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xF0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xEF,
  0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0D, 0xFB,
  0x00, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00, 0xE7,
  0xE7, 0x00, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x0C, 0x7E, 0x30, 0x00, 0x07,
  0x1F, 0x8E, 0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0xE1, 0xF8, 0x70, 0x00,
  0x38, 0x7E, 0x1C, 0x00, 0x0C, 0x1F, 0x87, 0x00, 0x07, 0x07, 0xE0, 0xE0,
  0x01, 0xC1, 0xF8, 0x38, 0x00, 0xE0, 0x7E, 0x07, 0x00, 0x38, 0x1F, 0x81,
  0xC0, 0x0C, 0x07, 0xE0, 0x70, 0x07, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7E,
  0x03, 0x80, 0xE0, 0x1F, 0x80, 0x70, 0x38, 0x07, 0xE0, 0x1C, 0x0C, 0x01,
  0xF8, 0x07, 0x07, 0x00, 0x7E, 0x00, 0xE1, 0xC0, 0x1F, 0x80, 0x38, 0xE0,
  0x07, 0xE0, 0x07, 0x38, 0x01, 0xF8, 0x01, 0xCC, 0x00, 0x7E, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xE0, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F,
  0x80, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xE0,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xE0, 0x3E, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xE0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xE3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07,
  0x3E, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80,
  0x07, 0x8E, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFC, 0xFF, 0x8F,
  0x00, 0x0C, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x80, 0x00, 0xF3, 0xE0, 0x1F,
  0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x76,
  0x00, 0x07, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xDC, 0x00,
  0x1C, 0x38, 0x00, 0x33, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x81, 0xC0,
  0x0E, 0x0C, 0x00, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x07, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x70,
  0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x06, 0x01, 0xC0, 0x70,
  0x03, 0x81, 0xC0, 0x18, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x0E, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x01, 0xD8, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0F, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x67,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81,
  0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xF1, 0xF8, 0x18, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xFC, 0x7C, 0x00, 0xE7, 0x80, 0x07,
  0x78, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7D, 0xC0, 0x03, 0xEF, 0x00, 0x37, 0x3C, 0x07, 0x39,
  0xFF, 0xF1, 0xC3, 0xFF, 0x0E, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x07, 0xF8, 0x0E, 0x3F, 0xFC, 0x1C, 0xFC, 0x7C,
  0x3B, 0x80, 0x3C, 0x76, 0x00, 0x1C, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0x78, 0x00, 0x0E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x73, 0xB0, 0x01,
  0xC7, 0x78, 0x0F, 0x8E, 0x3F, 0xFC, 0x1C, 0x3F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xDF, 0x8F, 0x80, 0x11, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x0F, 0xF0, 0x70, 0x7F, 0xF8, 0xE1, 0xF8, 0xF9,
  0xC7, 0x80, 0x3B, 0x9E, 0x00, 0x3F, 0x38, 0x00, 0x3E, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x3E, 0x70, 0x00, 0x7C, 0xF0, 0x01,
  0xB8, 0xF8, 0x0E, 0x70, 0xFF, 0xF8, 0xE0, 0x7F, 0xE1, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0x80, 0x38,
  0x3C, 0x00, 0x70, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x02, 0x0F, 0x80, 0x78, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xF0,
  0x60, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x01, 0xFE, 0x0E, 0x0F, 0xFF, 0x1C, 0x3F, 0x1F, 0x38,
  0xF0, 0x07, 0x73, 0xC0, 0x07, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7B, 0x80, 0x00,
  0xF7, 0x00, 0x01, 0xEE, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0x9E, 0x00, 0x37,
  0x1F, 0x01, 0xCE, 0x1F, 0xFF, 0x1C, 0x0F, 0xFC, 0x38, 0x01, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x79, 0x00, 0x01, 0xE1, 0x80, 0x07, 0x83, 0xFC,
  0xFE, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x3F, 0xC0, 0xE3, 0xFF, 0xC3, 0x9F, 0x9F, 0x8E, 0xE0,
  0x0F, 0x3F, 0x00, 0x1E, 0xF8, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0xF6, 0x00, 0x00, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3D, 0xDF, 0x3F, 0xC3, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0xEE, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00,
  0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xF8, 0x00, 0xEF, 0xC0, 0x07, 0x67,
  0x00, 0x3E, 0x1C, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xFE, 0x00, 0xFF, 0x07, 0x1F, 0xFC, 0x1F, 0xFE, 0x39, 0xF1, 0xF1,
  0xF1, 0xF9, 0xDC, 0x03, 0xDC, 0x01, 0xCF, 0xC0, 0x0E, 0xC0, 0x07, 0x7C,
  0x00, 0x7C, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0x01, 0xDE, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03,
  0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0x7C,
  0x7F, 0x3B, 0x80, 0x3C, 0xEC, 0x00, 0x7B, 0xE0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xE0, 0x7F, 0x01, 0xC7,
  0xFF, 0x83, 0x9F, 0x8F, 0xC7, 0x70, 0x07, 0x8E, 0xC0, 0x03, 0x9F, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDF, 0x00, 0x07, 0xBF,
  0x00, 0x0E, 0x77, 0x00, 0x38, 0xE7, 0x01, 0xF1, 0xC7, 0xFF, 0xC3, 0x87,
  0xFE, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x0E, 0x0F, 0xFF, 0x1C, 0x3F, 0x1F, 0x38, 0xF0, 0x07,
  0x73, 0xC0, 0x06, 0xEF, 0x00, 0x07, 0xDC, 0x00, 0x0F, 0xB8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x00, 0x07, 0xCE, 0x00, 0x1B, 0x9E, 0x00, 0x77, 0x1F, 0x03,
  0xCE, 0x1F, 0xFF, 0x1C, 0x0F, 0xFC, 0x38, 0x01, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0x70, 0x0E, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xFC, 0xFC, 0x3F, 0x1C, 0x00, 0x67, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0E, 0xF0, 0x07, 0xDF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xE0, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0x40, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0x6F, 0x00, 0x3B, 0x3E,
  0x07, 0x98, 0xFF, 0xF8, 0xC3, 0xFF, 0x06, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x18, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0xC0, 0x03, 0xB8, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1B,
  0x00, 0x1C, 0xE0, 0x03, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x61, 0xC0,
  0x1C, 0xC0, 0x1C, 0x38, 0x03, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x70,
  0x60, 0x1C, 0x30, 0x0C, 0x0E, 0x03, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x07, 0x0E, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x1C,
  0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x19, 0xC0,
  0x06, 0xE0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0xE0,
  0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01,
  0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x77,
  0x00, 0x00, 0xEF, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x8F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x83, 0xFC,
  0x7C, 0x00, 0xFF, 0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 37, 12, 4, -36 },
  { 20, 12, 13, 18, 3, -36 },
  { 40, 30, 36, 32, 1, -36 },
  { 175, 22, 41, 29, 3, -38 },
  { 288, 35, 37, 41, 3, -36 },
  { 450, 32, 37, 36, 3, -36 },
  { 598, 4, 13, 10, 3, -36 },
  { 605, 10, 44, 14, 2, -36 },
  { 660, 10, 44, 14, 2, -36 },
  { 715, 22, 21, 28, 3, -38 },
  { 773, 23, 23, 29, 3, -29 },
  { 840, 6, 12, 11, 2, -6 },
  { 849, 12, 3, 16, 2, -15 },
  { 854, 4, 5, 12, 4, -4 },
  { 857, 16, 36, 17, 1, -36 },
  { 929, 23, 37, 29, 3, -36 },
  { 1036, 12, 36, 29, 5, -36 },
  { 1090, 22, 36, 29, 3, -36 },
  { 1189, 23, 37, 29, 2, -36 },
  { 1296, 27, 36, 29, 1, -36 },
  { 1418, 23, 37, 29, 3, -36 },
  { 1525, 23, 37, 29, 3, -36 },
  { 1632, 23, 36, 29, 3, -36 },
  { 1736, 23, 37, 29, 3, -36 },
  { 1843, 23, 37, 29, 3, -36 },
  { 1950, 4, 28, 12, 4, -27 },
  { 1964, 6, 33, 12, 2, -27 },
  { 1989, 23, 24, 29, 3, -30 },
  { 2058, 23, 13, 29, 3, -24 },
  { 2096, 23, 24, 29, 3, -30 },
  { 2165, 19, 37, 21, 1, -36 },
  { 2253, 39, 41, 44, 3, -36 },
  { 2453, 30, 36, 30, 0, -36 },
  { 2588, 24, 36, 32, 5, -36 },
  { 2696, 27, 37, 31, 3, -36 },
  { 2821, 27, 36, 36, 5, -36 },
  { 2943, 20, 36, 28, 5, -36 },
  { 3033, 20, 36, 25, 5, -36 },
  { 3123, 29, 37, 36, 3, -36 },
  { 3258, 26, 36, 36, 5, -36 },
  { 3375, 10, 36, 16, 3, -36 },
  { 3420, 12, 45, 13, -4, -36 },
  { 3488, 24, 36, 29, 5, -36 },
  { 3596, 20, 36, 26, 5, -36 },
  { 3686, 34, 36, 44, 5, -36 },
  { 3839, 26, 36, 36, 5, -36 },
  { 3956, 32, 37, 38, 3, -36 },
  { 4104, 22, 36, 29, 5, -36 },
  { 4203, 32, 45, 38, 3, -36 },
  { 4383, 24, 36, 30, 5, -36 },
  { 4491, 22, 37, 27, 3, -36 },
  { 4593, 26, 36, 27, 0, -36 },
  { 4710, 26, 37, 36, 5, -36 },
  { 4831, 29, 36, 29, 0, -36 },
  { 4962, 43, 36, 45, 1, -36 },
  { 5156, 27, 36, 27, 0, -36 },
  { 5278, 27, 36, 27, 0, -36 },
  { 5400, 25, 36, 29, 2, -36 },
  { 5513, 11, 44, 16, 4, -36 },
  { 5574, 16, 36, 17, 1, -36 },
  { 5646, 11, 44, 16, 1, -36 },
  { 5707, 24, 22, 29, 2, -36 },
  { 5773, 21, 3, 21, 0, 4 },
  { 5781, 9, 8, 13, 2, -38 },
  { 5790, 21, 28, 27, 2, -27 },
  { 5864, 23, 39, 30, 4, -38 },
  { 5977, 19, 28, 24, 3, -27 },
  { 6044, 23, 39, 30, 3, -38 },
  { 6157, 22, 28, 28, 3, -27 },
  { 6234, 17, 38, 15, 1, -38 },
  { 6315, 23, 39, 30, 3, -27 },
  { 6428, 22, 38, 30, 4, -38 },
  { 6533, 4, 36, 12, 4, -36 },
  { 6551, 11, 48, 12, -3, -36 },
  { 6617, 21, 38, 25, 4, -38 },
  { 6717, 3, 38, 12, 4, -38 },
  { 6732, 37, 27, 45, 4, -27 },
  { 6857, 22, 27, 30, 4, -27 },
  { 6932, 24, 28, 30, 3, -27 },
  { 7016, 23, 39, 30, 4, -27 },
  { 7129, 23, 39, 30, 3, -27 },
  { 7242, 15, 27, 20, 4, -27 },
  { 7293, 19, 28, 23, 2, -27 },
  { 7360, 15, 34, 17, 1, -33 },
  { 7424, 21, 28, 30, 4, -27 },
  { 7498, 23, 27, 23, 0, -27 },
  { 7576, 35, 27, 37, 1, -27 },
  { 7695, 23, 27, 25, 1, -27 },
  { 7773, 24, 39, 23, 0, -27 },
  { 7890, 19, 27, 23, 2, -27 },
  { 7955, 15, 44, 18, 1, -36 },
  { 8038, 3, 50, 27, 12, -38 },
  { 8057, 15, 44, 18, 2, -36 },
  { 8140, 23, 5, 29, 3, -20 },
};

const GFXfont NotoSans_Light50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light50pt7bBitmaps,
  (GFXglyph *)NotoSans_Light50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_LIGHT50PT7B_H_
