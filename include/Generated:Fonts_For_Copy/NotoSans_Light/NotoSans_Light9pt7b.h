#ifndef _NOTOSANS_LIGHT9PT7B_H_
#define _NOTOSANS_LIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x28, 0xB5, 0x3E, 0x51, 0x40, 0x5F, 0x66, 0xFA, 0x45,
  0x52, 0xA5, 0xF5, 0xA5, 0x4B, 0x80, 0x45, 0x28, 0x8A, 0xCB, 0xA0, 0xC0,
  0x6A, 0xA4, 0xD5, 0x5C, 0x2F, 0x25, 0x27, 0xC8, 0x40, 0xC0, 0xE0, 0x80,
  0x25, 0x29, 0x00, 0x22, 0xA3, 0x18, 0xC5, 0xC0, 0xD5, 0x50, 0x64, 0x84,
  0x22, 0x23, 0xE0, 0x64, 0x82, 0xE0, 0x87, 0xC0, 0x11, 0x95, 0x27, 0x88,
  0xE8, 0xE1, 0x1E, 0x68, 0x8E, 0x99, 0xE0, 0xF8, 0x84, 0x42, 0x20, 0x69,
  0x96, 0xB9, 0xE0, 0x64, 0xA3, 0x17, 0x89, 0xC0, 0x88, 0x40, 0xA0, 0x3E,
  0x08, 0x30, 0xFF, 0xC0, 0xE0, 0xC9, 0x80, 0xE1, 0x12, 0x40, 0x40, 0x3E,
  0x59, 0xA5, 0xA5, 0xBE, 0x40, 0x3C, 0x21, 0x94, 0xF8, 0xC4, 0xF9, 0xE9,
  0x9F, 0x78, 0x88, 0x88, 0x70, 0xF4, 0x63, 0x18, 0xF8, 0xF3, 0xC9, 0xC0,
  0xF3, 0xC9, 0x00, 0x74, 0x61, 0x68, 0xC5, 0xE0, 0x8C, 0x7F, 0x18, 0xC4,
  0xD5, 0x70, 0x55, 0x57, 0x9A, 0xCA, 0xA9, 0x92, 0x49, 0xC0, 0x86, 0x3C,
  0xF5, 0xB6, 0x90, 0x8E, 0x6B, 0x59, 0xC4, 0x74, 0x63, 0x18, 0xC5, 0xC0,
  0xF9, 0xBC, 0x88, 0x74, 0x63, 0x18, 0xC5, 0xC2, 0x08, 0xF9, 0x9E, 0x99,
  0x78, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x8C, 0x63, 0x18, 0xF8,
  0x8C, 0x54, 0xA2, 0x10, 0x89, 0x99, 0x5A, 0x66, 0x26, 0x24, 0xDA, 0x88,
  0xA5, 0x44, 0x8A, 0x98, 0x42, 0x10, 0x78, 0x88, 0x44, 0x7C, 0xEA, 0xAC,
  0x89, 0x22, 0x40, 0xD5, 0x5C, 0x22, 0x95, 0x10, 0xF0, 0x90, 0x71, 0x79,
  0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xF2, 0x4E, 0x11, 0xF9, 0x99, 0xF0, 0xF7,
  0xCE, 0x6B, 0xA4, 0x90, 0xF9, 0x99, 0xF1, 0xE0, 0x88, 0xE9, 0x99, 0x90,
  0xBE, 0xBF, 0x80, 0x92, 0xED, 0xA8, 0xFE, 0xEE, 0x59, 0x65, 0x94, 0xE9,
  0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0x7C, 0x63, 0x17,
  0x84, 0x20, 0xEA, 0x80, 0x78, 0x61, 0xF0, 0x5D, 0x24, 0xC0, 0x99, 0x99,
  0xF0, 0x99, 0x56, 0x20, 0x93, 0x69, 0xB3, 0x64, 0x80, 0x95, 0x26, 0x90,
  0x99, 0x56, 0x24, 0xC0, 0x72, 0x24, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80,
  0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph NotoSans_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 5, 7, 6, 1, -7 },
  { 23, 1, 2, 2, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 5, 0, -7 },
  { 30, 5, 4, 5, 0, -5 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 3, 1, 3, 0, -3 },
  { 35, 1, 1, 2, 1, -1 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 5, 7, 5, 0, -7 },
  { 44, 2, 6, 5, 1, -6 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 4, 7, 5, 1, -7 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 4, 7, 5, 1, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 1, 5, 2, 1, -5 },
  { 81, 2, 6, 2, 0, -5 },
  { 83, 5, 4, 5, 0, -5 },
  { 86, 5, 2, 5, 0, -4 },
  { 88, 5, 4, 5, 0, -5 },
  { 91, 4, 7, 4, 0, -7 },
  { 95, 8, 7, 8, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 4, 7, 6, 1, -7 },
  { 113, 5, 6, 6, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 5, 7, 7, 1, -7 },
  { 128, 5, 6, 7, 1, -6 },
  { 132, 2, 6, 3, 0, -6 },
  { 134, 2, 8, 2, -1, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 3, 6, 5, 1, -6 },
  { 142, 6, 6, 8, 1, -6 },
  { 147, 5, 6, 7, 1, -6 },
  { 151, 5, 7, 7, 1, -7 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 5, 9, 7, 1, -7 },
  { 165, 4, 6, 5, 1, -6 },
  { 168, 4, 7, 5, 0, -7 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 5, 6, 7, 1, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 8, 6, 8, 0, -6 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 5, 6, 5, 0, -6 },
  { 202, 2, 7, 3, 1, -6 },
  { 204, 3, 6, 3, 0, -6 },
  { 207, 2, 7, 3, 0, -6 },
  { 209, 5, 4, 5, 0, -6 },
  { 212, 4, 1, 4, 0, 1 },
  { 213, 2, 2, 2, 0, -7 },
  { 214, 4, 5, 5, 0, -5 },
  { 217, 4, 7, 5, 1, -7 },
  { 221, 3, 5, 4, 1, -5 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 3, 5, 5, 1, -5 },
  { 229, 3, 7, 3, 0, -7 },
  { 232, 4, 7, 5, 1, -5 },
  { 236, 4, 7, 5, 1, -7 },
  { 240, 1, 7, 2, 1, -7 },
  { 241, 1, 9, 2, 0, -7 },
  { 243, 3, 7, 4, 1, -7 },
  { 246, 1, 7, 2, 1, -7 },
  { 247, 6, 5, 8, 1, -5 },
  { 251, 4, 5, 5, 1, -5 },
  { 254, 4, 5, 5, 1, -5 },
  { 257, 4, 7, 5, 1, -5 },
  { 261, 5, 7, 5, 0, -5 },
  { 266, 2, 5, 4, 1, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 3, 6, 3, 0, -6 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 7, 5, 7, 0, -5 },
  { 285, 4, 5, 5, 0, -5 },
  { 288, 4, 7, 4, 0, -5 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 3, 7, 3, 0, -6 },
  { 298, 1, 9, 5, 2, -7 },
  { 300, 3, 7, 3, 0, -6 },
  { 303, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Light9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light9pt7bBitmaps,
  (GFXglyph *)NotoSans_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_LIGHT9PT7B_H_
