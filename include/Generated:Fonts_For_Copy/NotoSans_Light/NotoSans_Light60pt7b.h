#ifndef _NOTOSANS_LIGHT60PT7B_H_
#define _NOTOSANS_LIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x03, 0xDF, 0xFF, 0xFE, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0x60, 0x39, 0x80, 0xE6, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0x1C, 0x1E, 0x1F,
  0x07, 0x00, 0x87, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0x3E,
  0x1C, 0x00, 0x07, 0xE7, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x71,
  0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x03, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x3C,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0xF2, 0x00, 0x70, 0x7C, 0xF8, 0x1C, 0x7E, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0xE0, 0xFE, 0x07, 0x00, 0x38, 0x38,
  0x7F, 0xE1, 0xC0, 0x0E, 0x1C, 0x3E, 0x7C, 0x70, 0x07, 0x0F, 0x1E, 0x07,
  0x8E, 0x01, 0xC3, 0x87, 0x00, 0xE3, 0xC0, 0xE1, 0xC3, 0xC0, 0x38, 0x78,
  0xF8, 0x70, 0xE0, 0x07, 0x0F, 0xFC, 0x38, 0x38, 0x01, 0xC1, 0xFE, 0x0E,
  0x0E, 0x00, 0x70, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1C, 0x0F, 0x81,
  0xE0, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x01,
  0xC1, 0xE0, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x01, 0xE0, 0x0E, 0x0F, 0x00,
  0x01, 0xE0, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x38, 0x00, 0x01, 0xE1,
  0xE0, 0xF0, 0x00, 0x01, 0xE3, 0xC1, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xC0,
  0x00, 0x01, 0xFC, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x01, 0xF1, 0xE0, 0x1F, 0x80, 0x0F, 0xC1, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xF0,
  0x01, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xF0, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x1B, 0xF0, 0x38, 0x3F, 0x7F, 0xE7, 0x3F,
  0xF7, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF7,
  0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xDC, 0x3E, 0x71, 0xF1,
  0xCF, 0x87, 0xF8, 0x1F, 0xC0, 0x76, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x60, 0x00, 0x1E,
  0x08, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xA0, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF8, 0xFF, 0xC7, 0xFE,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x30,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xF0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC7, 0x80, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x03, 0xC1, 0xFF, 0xC0,
  0x70, 0xFF, 0xFE, 0x0E, 0x3F, 0x07, 0xE1, 0xCF, 0x00, 0x1E, 0x3B, 0x80,
  0x01, 0xE7, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x1E,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0x38, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0xEF, 0x1F, 0x00, 0x1E, 0xE0, 0xFC, 0x07, 0xCE, 0x07, 0xFF, 0xF0,
  0xE0, 0x3F, 0xFE, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x1C, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xEF, 0xFF, 0xFF, 0x60, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1E, 0x00, 0x7E, 0x20, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0x83, 0x80,
  0x03, 0xFF, 0xF8, 0x03, 0x8F, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0x1C, 0x00,
  0x7E, 0x01, 0xE0, 0x0E, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x1D, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0x77, 0x00, 0x78, 0x00, 0x38, 0x00, 0xEE, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1E, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xEE, 0x00, 0x70, 0x00, 0x78, 0x01, 0xDC, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0x9C, 0x01, 0xE0, 0x03, 0xE0, 0x0E, 0x38, 0x01, 0xC0, 0x06,
  0xE0, 0x1C, 0x70, 0x03, 0xC0, 0x1D, 0xC0, 0x70, 0xE0, 0x03, 0xE0, 0xF1,
  0xC3, 0xE1, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xC0, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0x80, 0x00, 0x60, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x03, 0xFF, 0x0E, 0x00,
  0x00, 0xFC, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x9C, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x7C, 0x38, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x03, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x04, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x3F, 0xF0, 0x0E, 0x00, 0x00, 0xFC,
  0x07, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x1F,
  0x07, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x7F, 0x01, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x1F,
  0x80, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xEC, 0x3F, 0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x0F, 0x8E,
  0x00, 0x00, 0xF8, 0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0xF8, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x0E, 0x7F, 0x80,
  0x00, 0x77, 0xBE, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x00, 0x77,
  0xEF, 0x00, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00, 0x00, 0xE7, 0xE7, 0x80,
  0x00, 0x00, 0xE7, 0xE7, 0x80, 0x00, 0x01, 0xE7, 0xE3, 0x80, 0x00, 0x01,
  0xC7, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0xE1,
  0xE0, 0x00, 0x03, 0x87, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0xE0, 0xE0, 0x00,
  0x07, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0x07,
  0xE0, 0x78, 0x00, 0x0E, 0x07, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0xE0, 0x1C, 0x00, 0x3C,
  0x07, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00,
  0xF0, 0x07, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x0F, 0xE0, 0x78, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x3E, 0x00,
  0x0F, 0xE0, 0x1E, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0x80,
  0x0F, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x0F, 0xE0, 0x00, 0xF8,
  0x0F, 0xE0, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x3E,
  0x0F, 0xE0, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x0F,
  0x8F, 0xE0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x3F, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xBF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x07, 0xFC, 0x0E, 0x00,
  0x03, 0xF0, 0x70, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0xE0,
  0x70, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00,
  0x08, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF8, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x1C,
  0x07, 0x80, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0x1E, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x78,
  0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xF1, 0xFC, 0x0E, 0x00, 0x3E, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0x3F, 0x00, 0x07, 0x7C,
  0x00, 0x07, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x77, 0x7C, 0x00, 0xE7, 0x3F, 0x87, 0xE7, 0x1F,
  0xFF, 0x87, 0x0F, 0xFF, 0x03, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0xF0, 0x7F, 0xF0,
  0x0F, 0x1F, 0xFF, 0xC0, 0xF3, 0xF9, 0xFE, 0x0F, 0x78, 0x01, 0xF0, 0xFE,
  0x00, 0x0F, 0x8E, 0xC0, 0x00, 0x78, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1C, 0xF8, 0x00, 0x03,
  0xCF, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0x8E, 0xE0, 0x00, 0xF8, 0xE7,
  0x00, 0x1F, 0x0E, 0x3F, 0x1F, 0xE0, 0xE1, 0xFF, 0xFC, 0x0E, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x06, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x0F,
  0x00, 0x7F, 0xE0, 0xF0, 0x1F, 0xFF, 0x8F, 0x07, 0xFD, 0xFC, 0xF0, 0xFC,
  0x01, 0xEF, 0x1F, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x37, 0x3C, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F,
  0x38, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x77, 0x0F, 0x80, 0x0E, 0x70, 0x7F, 0x0F, 0xC7, 0x03, 0xFF, 0xF8,
  0x70, 0x0F, 0xFE, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x1F, 0x80,
  0x03, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xE0, 0x20, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0x01,
  0xFF, 0xF8, 0x70, 0x7F, 0xDF, 0xC7, 0x0F, 0x80, 0x1E, 0x70, 0xF0, 0x00,
  0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x01,
  0xEF, 0x07, 0xF0, 0xFC, 0xF0, 0x3F, 0xFF, 0x8F, 0x00, 0xFF, 0xE0, 0xF0,
  0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x07, 0xC1, 0xE0,
  0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x0F, 0x07,
  0xFF, 0x03, 0xC7, 0xFF, 0xF0, 0xF3, 0xF9, 0xFE, 0x3D, 0xE0, 0x07, 0xCF,
  0xE0, 0x00, 0xF3, 0xB0, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xBE, 0x00, 0x00,
  0xEF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x6F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x3E, 0x00, 0x07, 0xBF, 0x80, 0x03, 0xDD, 0xE0, 0x01, 0xFC, 0x78, 0x00,
  0xFC, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x0E, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E,
  0x3F, 0x3F, 0x87, 0xF3, 0xF8, 0xE7, 0x00, 0x7C, 0xF0, 0x07, 0xCE, 0xE0,
  0x03, 0xEE, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xEF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x38, 0x1F, 0xFC, 0x0E, 0x1F, 0xFF, 0xC3, 0x8F, 0xE7, 0xF8, 0xE7, 0x80,
  0x1F, 0x3B, 0x80, 0x03, 0xCF, 0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x0E, 0xF8,
  0x00, 0x03, 0xBE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0xE1, 0xFF, 0xFC, 0x0E,
  0x3F, 0x9F, 0xE0, 0xE7, 0x80, 0x1F, 0x0E, 0x70, 0x00, 0xF8, 0xEC, 0x00,
  0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x03, 0xCE,
  0xC0, 0x00, 0x78, 0xFE, 0x00, 0x0F, 0x8F, 0x78, 0x01, 0xF0, 0xF3, 0xF9,
  0xFE, 0x0F, 0x1F, 0xFF, 0xC0, 0xF0, 0x7F, 0xF0, 0x0F, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFE, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x7F, 0x9F, 0xC7,
  0x0F, 0x80, 0x1E, 0x71, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x01, 0xEF, 0x07, 0xF1, 0xFC, 0xF0, 0x3F,
  0xFF, 0x8F, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFB, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0x7C, 0x00, 0x39, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3B, 0x80, 0x03, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x70, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xEF, 0x00, 0x07, 0x73, 0xE0, 0x07, 0xB9, 0xFE, 0x3F, 0x9C,
  0x3F, 0xFF, 0x06, 0x0F, 0xFF, 0x03, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0xF7, 0x00, 0x01, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x78,
  0x00, 0x3F, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0xE0, 0x01, 0xE3, 0x80, 0x03,
  0xB8, 0x00, 0x78, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x3C, 0x00, 0x71, 0xC0,
  0x07, 0x0F, 0x00, 0x1C, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0xE0,
  0x78, 0x03, 0x87, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80,
  0x78, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x01, 0xC0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x1E, 0x0F,
  0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x03,
  0x87, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x3C, 0xF0,
  0x01, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E,
  0xF0, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x03, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00, 0xF0,
  0x07, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x3C,
  0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x17, 0xFF, 0xE0,
  0x03, 0xFC, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC8,
  0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 44, 15, 5, -43 },
  { 29, 14, 16, 22, 4, -43 },
  { 57, 35, 43, 39, 2, -43 },
  { 246, 26, 49, 34, 4, -46 },
  { 406, 42, 44, 49, 3, -43 },
  { 637, 39, 45, 43, 3, -44 },
  { 857, 4, 16, 12, 4, -43 },
  { 865, 13, 52, 17, 2, -43 },
  { 950, 12, 52, 17, 2, -43 },
  { 1028, 27, 26, 33, 3, -46 },
  { 1116, 28, 28, 34, 3, -35 },
  { 1214, 8, 15, 14, 2, -7 },
  { 1229, 15, 3, 19, 2, -18 },
  { 1235, 5, 6, 15, 5, -5 },
  { 1239, 19, 43, 21, 1, -43 },
  { 1342, 28, 45, 34, 3, -44 },
  { 1500, 14, 43, 34, 6, -43 },
  { 1576, 27, 43, 34, 3, -43 },
  { 1722, 27, 44, 34, 3, -43 },
  { 1871, 32, 43, 34, 1, -43 },
  { 2043, 27, 44, 34, 4, -43 },
  { 2192, 27, 45, 34, 4, -44 },
  { 2344, 28, 43, 34, 3, -43 },
  { 2495, 28, 44, 34, 3, -43 },
  { 2649, 28, 44, 34, 3, -43 },
  { 2803, 5, 33, 15, 5, -32 },
  { 2824, 8, 40, 15, 2, -32 },
  { 2864, 28, 28, 34, 3, -36 },
  { 2962, 28, 15, 34, 3, -29 },
  { 3015, 28, 28, 34, 3, -36 },
  { 3113, 22, 44, 25, 1, -43 },
  { 3234, 47, 49, 53, 3, -43 },
  { 3522, 36, 43, 36, 0, -43 },
  { 3716, 29, 43, 38, 6, -43 },
  { 3872, 32, 44, 37, 4, -43 },
  { 4048, 33, 43, 43, 6, -43 },
  { 4226, 24, 43, 33, 6, -43 },
  { 4355, 24, 43, 30, 6, -43 },
  { 4484, 35, 45, 43, 4, -44 },
  { 4681, 31, 43, 43, 6, -43 },
  { 4848, 13, 43, 19, 3, -43 },
  { 4918, 14, 54, 15, -5, -43 },
  { 5013, 29, 43, 35, 6, -43 },
  { 5169, 24, 43, 31, 6, -43 },
  { 5298, 40, 43, 52, 6, -43 },
  { 5513, 32, 43, 44, 6, -43 },
  { 5685, 38, 45, 46, 4, -44 },
  { 5899, 26, 43, 35, 6, -43 },
  { 6039, 38, 54, 46, 4, -44 },
  { 6296, 29, 43, 36, 6, -43 },
  { 6452, 27, 44, 33, 3, -43 },
  { 6601, 31, 43, 32, 0, -43 },
  { 6768, 32, 44, 43, 6, -43 },
  { 6944, 35, 43, 35, 0, -43 },
  { 7133, 52, 43, 54, 1, -43 },
  { 7413, 33, 43, 33, 0, -43 },
  { 7591, 32, 43, 32, 0, -43 },
  { 7763, 30, 43, 35, 2, -43 },
  { 7925, 13, 52, 19, 5, -43 },
  { 8010, 19, 43, 21, 1, -43 },
  { 8113, 13, 52, 19, 1, -43 },
  { 8198, 29, 27, 34, 3, -43 },
  { 8296, 25, 3, 25, 0, 5 },
  { 8306, 12, 10, 16, 2, -46 },
  { 8321, 24, 33, 32, 3, -32 },
  { 8420, 28, 47, 36, 5, -46 },
  { 8585, 24, 34, 29, 3, -33 },
  { 8687, 28, 47, 36, 3, -46 },
  { 8852, 27, 34, 33, 3, -33 },
  { 8967, 21, 46, 19, 1, -46 },
  { 9088, 28, 47, 36, 3, -33 },
  { 9253, 26, 46, 36, 5, -46 },
  { 9403, 4, 44, 14, 5, -44 },
  { 9425, 12, 58, 14, -3, -44 },
  { 9512, 25, 46, 30, 5, -46 },
  { 9656, 4, 46, 14, 5, -46 },
  { 9679, 44, 33, 54, 5, -33 },
  { 9861, 26, 33, 36, 5, -33 },
  { 9969, 29, 34, 35, 3, -33 },
  { 10093, 28, 47, 36, 5, -33 },
  { 10258, 28, 47, 36, 3, -33 },
  { 10423, 18, 32, 24, 5, -32 },
  { 10495, 22, 34, 28, 3, -33 },
  { 10589, 18, 41, 20, 1, -40 },
  { 10682, 25, 33, 36, 5, -32 },
  { 10786, 28, 32, 28, 0, -32 },
  { 10898, 42, 32, 44, 1, -32 },
  { 11066, 28, 32, 30, 1, -32 },
  { 11178, 28, 46, 28, 0, -32 },
  { 11339, 23, 32, 28, 2, -32 },
  { 11431, 17, 52, 22, 2, -43 },
  { 11542, 3, 61, 33, 15, -46 },
  { 11565, 18, 52, 22, 2, -43 },
  { 11682, 28, 6, 34, 3, -24 },
};

const GFXfont NotoSans_Light60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light60pt7bBitmaps,
  (GFXglyph *)NotoSans_Light60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_LIGHT60PT7B_H_
