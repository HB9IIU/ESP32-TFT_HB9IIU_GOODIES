#ifndef _NOTOSANS_LIGHT27PT7B_H_
#define _NOTOSANS_LIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x24, 0x92, 0x49, 0x24, 0x80, 0x1F, 0x00, 0xCE, 0x38, 0xE3,
  0x86, 0x18, 0x40, 0x02, 0x08, 0x02, 0x08, 0x06, 0x18, 0x06, 0x10, 0x04,
  0x10, 0x04, 0x10, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0xC0, 0x30, 0xC0, 0x04, 0x00, 0x80, 0x38, 0x3F, 0xFC, 0x45,
  0x88, 0x21, 0x04, 0x20, 0xC4, 0x0C, 0x80, 0xF0, 0x07, 0x80, 0x5C, 0x08,
  0xC1, 0x08, 0x21, 0x04, 0x20, 0x8F, 0x17, 0x7F, 0xC0, 0x40, 0x08, 0x01,
  0x00, 0x08, 0x00, 0x07, 0xC0, 0x61, 0x88, 0x08, 0x21, 0x83, 0x04, 0x10,
  0xC1, 0x82, 0x10, 0x30, 0x46, 0x06, 0x08, 0x80, 0x41, 0x33, 0x88, 0x64,
  0xD9, 0x89, 0xB1, 0x9F, 0x24, 0x10, 0x8C, 0x82, 0x01, 0x10, 0x40, 0x42,
  0x08, 0x18, 0x41, 0x02, 0x08, 0x20, 0xC1, 0x84, 0x10, 0x11, 0x86, 0x03,
  0xE0, 0x06, 0x00, 0x0F, 0xC0, 0x0C, 0x30, 0x04, 0x0C, 0x02, 0x06, 0x01,
  0x03, 0x00, 0xC3, 0x00, 0x23, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x0C, 0x60, 0x6C, 0x18, 0x34, 0x06, 0x32, 0x01, 0x99, 0x00, 0x78, 0x80,
  0x18, 0x60, 0x1E, 0x1C, 0x39, 0x87, 0xF0, 0x70, 0xEA, 0xA8, 0x1C, 0x43,
  0x08, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x86,
  0x08, 0x30, 0x41, 0xC0, 0xC3, 0x08, 0x61, 0x0C, 0x63, 0x08, 0x42, 0x10,
  0x84, 0x23, 0x18, 0xC4, 0x62, 0x33, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x42, 0x1F, 0xAF, 0x0F, 0x80, 0x70, 0x0D, 0x81, 0x88, 0x18, 0xC3,
  0x06, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF,
  0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x6D,
  0xA5, 0x80, 0xFE, 0xF8, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x00, 0x04, 0x03, 0xF8, 0x60, 0xC4, 0x06, 0xC0, 0x2C, 0x02, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x02, 0xC0, 0x66, 0x06, 0x30, 0xC1, 0xF8, 0x0C, 0xF6, 0x71, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x02,
  0x01, 0xFE, 0x18, 0x18, 0x80, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x06, 0x01, 0xFE, 0x38,
  0x18, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0xFC,
  0x07, 0xF0, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0xB0, 0x38, 0xFF, 0x80, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0xD8,
  0x02, 0x60, 0x19, 0x80, 0xC6, 0x02, 0x18, 0x10, 0x60, 0xC1, 0x86, 0x06,
  0x10, 0x18, 0x80, 0x63, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0D, 0xE0, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x6C, 0x1C, 0xFF, 0x80, 0x01, 0xC0, 0xFE, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x8F, 0x8B, 0x9C, 0xE0,
  0x6C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0x40, 0x36, 0x06, 0x30,
  0xC1, 0xF8, 0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x06, 0x03, 0xFC,
  0x60, 0xEC, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x66, 0x04, 0x31, 0x81, 0xF0,
  0x1B, 0x86, 0x0C, 0xC0, 0x68, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x06,
  0x60, 0xC3, 0xF8, 0x02, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x64, 0x03, 0x60,
  0x0B, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01, 0xD8, 0x1E, 0x7F, 0xB0, 0xE1,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x7E, 0x00,
  0x5F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x2D, 0x80, 0x00, 0x00, 0x06, 0xDA,
  0xD8, 0x00, 0x08, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x08, 0x3F, 0xC8, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0x00,
  0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x80,
  0xFC, 0x66, 0x0E, 0x60, 0x90, 0x60, 0x82, 0x43, 0x02, 0x09, 0x0C, 0x08,
  0x3C, 0x20, 0x20, 0xB0, 0x80, 0x82, 0x43, 0x02, 0x09, 0x0C, 0x18, 0x64,
  0x18, 0xD3, 0x18, 0x3C, 0x78, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30,
  0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x1F, 0xFC, 0x10, 0x0C,
  0x30, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01,
  0xFF, 0xC4, 0x07, 0x20, 0x0D, 0x00, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xD0,
  0x0C, 0xFF, 0x87, 0xFE, 0x20, 0x0D, 0x00, 0x68, 0x01, 0x40, 0x0E, 0x00,
  0x70, 0x06, 0x80, 0x34, 0x0F, 0x3F, 0xE0, 0x00, 0x80, 0x3F, 0xF1, 0xC0,
  0xCC, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x83, 0xFE, 0xFF, 0xC1, 0x01, 0xC2, 0x00, 0xC4,
  0x00, 0xC8, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0xA0, 0x02, 0x40, 0x0C,
  0x80, 0x71, 0x07, 0xC3, 0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x70, 0x19,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0x60, 0x02, 0x60, 0x04, 0x78, 0x18, 0x3F, 0xE0, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x0C, 0x3F, 0xBC, 0x80, 0x3C, 0x03, 0x20, 0x31, 0x03, 0x08, 0x30, 0x43,
  0x02, 0x30, 0x13, 0x00, 0xB8, 0x07, 0x60, 0x31, 0x81, 0x0C, 0x08, 0x30,
  0x40, 0xC2, 0x03, 0x10, 0x18, 0x80, 0x64, 0x01, 0xA0, 0x06, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xC0, 0x01,
  0xF8, 0x00, 0x7A, 0x00, 0x3E, 0xC0, 0x0B, 0xB0, 0x02, 0xE4, 0x01, 0xB9,
  0x80, 0x4E, 0x20, 0x33, 0x8C, 0x0C, 0xE3, 0x02, 0x38, 0x41, 0x8E, 0x18,
  0x43, 0x82, 0x30, 0xE0, 0xCC, 0x38, 0x32, 0x0E, 0x05, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x0C, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xEC, 0x03,
  0x98, 0x0E, 0x60, 0x38, 0xC0, 0xE1, 0x83, 0x86, 0x0E, 0x0C, 0x38, 0x18,
  0xE0, 0x63, 0x80, 0xCE, 0x01, 0x98, 0x06, 0x60, 0x0D, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x80, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x04, 0x80,
  0x06, 0x60, 0x03, 0x18, 0x03, 0x07, 0x07, 0x01, 0xFE, 0x00, 0xFF, 0x90,
  0x3A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x7B,
  0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x04, 0x80, 0x06, 0x60,
  0x03, 0x18, 0x03, 0x07, 0x07, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0xFF, 0x84, 0x0E, 0x20, 0x19,
  0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0xC7, 0xFC, 0x3F,
  0xC1, 0x06, 0x08, 0x18, 0x40, 0x42, 0x03, 0x10, 0x0C, 0x80, 0x64, 0x01,
  0xA0, 0x0E, 0x02, 0x01, 0xFF, 0x30, 0x36, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0xE0, 0xE7, 0xF8, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x02, 0x60, 0x19,
  0xC1, 0xC1, 0xFC, 0x00, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x04,
  0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x18, 0x08, 0x30,
  0x0C, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x30, 0x07, 0x80, 0x60, 0x0B,
  0x01, 0xE0, 0x32, 0x03, 0x40, 0x66, 0x04, 0x80, 0x8C, 0x09, 0x81, 0x18,
  0x33, 0x06, 0x10, 0x62, 0x0C, 0x30, 0x84, 0x10, 0x61, 0x0C, 0x60, 0x46,
  0x18, 0xC0, 0x88, 0x11, 0x81, 0x90, 0x32, 0x03, 0x60, 0x6C, 0x02, 0xC0,
  0x58, 0x05, 0x00, 0xA0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x0C, 0x40, 0x30, 0xC0, 0x60, 0xC1, 0x80, 0x82, 0x01, 0x8C,
  0x01, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x36, 0x00,
  0xC6, 0x01, 0x04, 0x06, 0x0C, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x1B, 0x00,
  0x18, 0xC0, 0x0D, 0x80, 0x32, 0x01, 0x8C, 0x04, 0x10, 0x30, 0x60, 0x80,
  0x86, 0x03, 0x10, 0x04, 0xC0, 0x1A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x3F, 0xFE, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0,
  0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xE0, 0x03, 0x00, 0x38, 0x01, 0x60, 0x19, 0x00, 0x8C, 0x0C, 0x20, 0x41,
  0x86, 0x04, 0x20, 0x33, 0x00, 0x90, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFC,
  0xC3, 0x08, 0x20, 0x80, 0x02, 0x07, 0xF8, 0x81, 0x80, 0x30, 0x02, 0x00,
  0x40, 0x08, 0xFF, 0x70, 0x28, 0x07, 0x00, 0xE0, 0x3C, 0x06, 0xC3, 0x4F,
  0xC8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0C,
  0x1B, 0xF8, 0xF0, 0x67, 0x01, 0xB0, 0x05, 0x80, 0x2C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x16, 0x01, 0xB8, 0x0D, 0xE0, 0xCC, 0xFC, 0x00,
  0x07, 0x0F, 0xF7, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x60, 0x1C, 0x11, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x0C, 0x33, 0xFB, 0x60, 0x7C, 0x07, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x77,
  0x0F, 0x3F, 0x90, 0x06, 0x07, 0xF1, 0x83, 0x20, 0x3C, 0x07, 0x00, 0x60,
  0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0xE0, 0xC7, 0xF8,
  0x03, 0x83, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFC, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x0E, 0x03, 0xFB, 0x60, 0x7C, 0x07, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x77, 0x0F,
  0x3F, 0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x6C, 0x0E, 0xFF, 0xC0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC3, 0x0D, 0xFC, 0xF0,
  0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x74, 0x0F, 0xFF, 0xFF, 0xFF,
  0x08, 0xC2, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x06, 0xC1, 0x98, 0x63, 0x18, 0x66, 0x0C, 0x81, 0xB8,
  0x39, 0x06, 0x30, 0xC3, 0x18, 0x33, 0x02, 0x60, 0x6C, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x0D, 0xFC, 0xFE, 0xF0, 0xD0, 0x6E,
  0x07, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30, 0x07, 0x0D, 0xFC, 0xF0, 0x6E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x07, 0x03, 0xFC, 0x60, 0x6C, 0x02, 0xC0,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x60,
  0x67, 0x0C, 0x1F, 0x80, 0x07, 0x06, 0xFE, 0x3C, 0x19, 0xC0, 0x6C, 0x01,
  0x60, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x05, 0xC0, 0x6E,
  0x03, 0x68, 0x73, 0x3F, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x0E, 0x03, 0xFB, 0x60, 0xFC, 0x07, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x76, 0x0F,
  0x3F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0xDF, 0xF0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x0F, 0x0F, 0xF6, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x30, 0x04, 0x01, 0x00, 0x70, 0x37, 0xF8, 0x10, 0x08, 0x04,
  0x06, 0x0F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x07, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x07,
  0x60, 0xF3, 0xF3, 0xC0, 0x1A, 0x01, 0x98, 0x0C, 0xC0, 0x42, 0x06, 0x18,
  0x20, 0x43, 0x03, 0x18, 0x18, 0x80, 0x4C, 0x03, 0x60, 0x0A, 0x00, 0x70,
  0x03, 0x00, 0xC0, 0x60, 0x36, 0x06, 0x06, 0x60, 0xF0, 0x66, 0x09, 0x04,
  0x20, 0x90, 0x43, 0x19, 0x8C, 0x31, 0x88, 0xC1, 0x10, 0x88, 0x13, 0x0C,
  0x81, 0xB0, 0xD8, 0x1A, 0x05, 0x80, 0xA0, 0x70, 0x0E, 0x07, 0x00, 0xC0,
  0x30, 0xC0, 0x76, 0x04, 0x30, 0xC1, 0x18, 0x19, 0x00, 0xF0, 0x06, 0x00,
  0xE0, 0x1B, 0x01, 0x98, 0x30, 0x86, 0x0C, 0x40, 0x6C, 0x03, 0xC0, 0x1A,
  0x01, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x18, 0x20, 0x43, 0x03, 0x18, 0x18,
  0x80, 0x4C, 0x03, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x01, 0xE0, 0x04, 0x00, 0x00, 0x7F, 0xC0, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x3F, 0xF0, 0x0F, 0x1C, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x30, 0xC0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x30, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x03, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0xE0, 0x3C, 0x0F, 0x3D, 0xE0, 0x7C,
};

const GFXglyph NotoSans_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 6, 7, 10, 2, -19 },
  { 15, 16, 19, 17, 1, -19 },
  { 53, 11, 23, 15, 2, -21 },
  { 85, 19, 20, 22, 1, -20 },
  { 133, 17, 20, 19, 2, -20 },
  { 176, 2, 7, 5, 2, -19 },
  { 178, 6, 23, 8, 1, -19 },
  { 196, 5, 23, 8, 1, -19 },
  { 211, 12, 12, 15, 1, -21 },
  { 229, 13, 13, 15, 1, -16 },
  { 251, 3, 6, 6, 1, -3 },
  { 254, 7, 1, 9, 1, -8 },
  { 255, 3, 2, 7, 2, -2 },
  { 256, 9, 19, 9, 0, -19 },
  { 278, 12, 20, 15, 2, -20 },
  { 308, 6, 19, 15, 3, -19 },
  { 323, 13, 20, 15, 1, -20 },
  { 356, 13, 20, 15, 1, -20 },
  { 389, 14, 19, 15, 1, -19 },
  { 423, 12, 19, 15, 2, -19 },
  { 452, 12, 20, 15, 2, -20 },
  { 482, 13, 19, 15, 1, -19 },
  { 513, 12, 20, 15, 2, -20 },
  { 543, 13, 20, 15, 1, -20 },
  { 576, 3, 15, 7, 2, -15 },
  { 582, 3, 18, 7, 1, -15 },
  { 589, 13, 13, 15, 1, -16 },
  { 611, 12, 7, 15, 2, -13 },
  { 622, 13, 13, 15, 1, -16 },
  { 644, 10, 20, 11, 1, -20 },
  { 669, 22, 22, 24, 1, -19 },
  { 730, 16, 19, 16, 0, -19 },
  { 768, 13, 19, 17, 3, -19 },
  { 799, 14, 20, 17, 2, -20 },
  { 834, 15, 19, 19, 3, -19 },
  { 870, 10, 19, 15, 3, -19 },
  { 894, 10, 19, 14, 3, -19 },
  { 918, 15, 20, 20, 2, -20 },
  { 956, 14, 19, 20, 3, -19 },
  { 990, 6, 19, 8, 1, -19 },
  { 1005, 6, 24, 7, -2, -19 },
  { 1023, 13, 19, 16, 3, -19 },
  { 1054, 10, 19, 14, 3, -19 },
  { 1078, 18, 19, 24, 3, -19 },
  { 1121, 14, 19, 20, 3, -19 },
  { 1155, 17, 20, 21, 2, -20 },
  { 1198, 11, 19, 16, 3, -19 },
  { 1225, 17, 25, 21, 2, -20 },
  { 1279, 13, 19, 16, 3, -19 },
  { 1310, 12, 20, 15, 1, -20 },
  { 1340, 14, 19, 14, 0, -19 },
  { 1374, 14, 19, 20, 3, -19 },
  { 1408, 16, 19, 16, 0, -19 },
  { 1446, 23, 19, 24, 1, -19 },
  { 1501, 15, 19, 15, 0, -19 },
  { 1537, 14, 19, 14, 0, -19 },
  { 1571, 13, 19, 16, 1, -19 },
  { 1602, 6, 23, 9, 2, -19 },
  { 1620, 9, 19, 9, 0, -19 },
  { 1642, 5, 23, 9, 1, -19 },
  { 1657, 13, 12, 15, 1, -19 },
  { 1677, 11, 2, 11, 0, 2 },
  { 1680, 5, 5, 7, 1, -21 },
  { 1684, 11, 15, 14, 1, -15 },
  { 1705, 13, 21, 16, 2, -21 },
  { 1740, 10, 15, 13, 2, -15 },
  { 1759, 12, 21, 16, 2, -21 },
  { 1791, 11, 15, 15, 2, -15 },
  { 1812, 10, 21, 8, 0, -21 },
  { 1839, 12, 21, 16, 2, -15 },
  { 1871, 12, 21, 16, 2, -21 },
  { 1903, 2, 20, 6, 2, -20 },
  { 1908, 5, 26, 6, -1, -20 },
  { 1925, 11, 21, 13, 2, -21 },
  { 1954, 2, 21, 6, 2, -21 },
  { 1960, 20, 15, 24, 2, -15 },
  { 1998, 12, 15, 16, 2, -15 },
  { 2021, 12, 15, 16, 2, -15 },
  { 2044, 13, 21, 16, 2, -15 },
  { 2079, 12, 21, 16, 2, -15 },
  { 2111, 8, 15, 11, 2, -15 },
  { 2126, 10, 15, 13, 1, -15 },
  { 2145, 9, 18, 9, 0, -18 },
  { 2166, 12, 14, 16, 2, -14 },
  { 2187, 13, 14, 13, 0, -14 },
  { 2210, 20, 14, 20, 0, -14 },
  { 2245, 12, 14, 14, 1, -14 },
  { 2266, 13, 21, 13, 0, -14 },
  { 2301, 10, 14, 13, 1, -14 },
  { 2319, 8, 23, 10, 1, -19 },
  { 2342, 1, 28, 15, 7, -21 },
  { 2346, 8, 23, 10, 1, -19 },
  { 2369, 13, 3, 15, 1, -11 },
};

const GFXfont NotoSans_Light27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light27pt7bBitmaps,
  (GFXglyph *)NotoSans_Light27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_LIGHT27PT7B_H_
