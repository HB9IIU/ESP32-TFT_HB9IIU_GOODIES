#ifndef _NOTOSANS_LIGHT48PT7B_H_
#define _NOTOSANS_LIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x76, 0x0E, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x60,
  0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x1C, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xF7, 0xF1, 0xE1, 0x81, 0x8E, 0x0C,
  0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0E,
  0x06, 0x00, 0x70, 0x30, 0x01, 0xC1, 0x80, 0x07, 0x8C, 0x00, 0x1F, 0x60,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x31, 0xF0, 0x01, 0x83, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x01,
  0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x30, 0x3A, 0x01,
  0x83, 0xDE, 0x0C, 0x7C, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x0E, 0x38, 0x00, 0x30, 0x0E,
  0x0E, 0x00, 0x38, 0x06, 0x03, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x1C, 0x03,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x18, 0x0E, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x07, 0x00, 0x18, 0x03, 0x03, 0x00,
  0x0C, 0x01, 0x83, 0x80, 0x06, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x61, 0xC3,
  0xE1, 0x80, 0x70, 0xC7, 0xFC, 0xE0, 0x38, 0xE3, 0x8E, 0x30, 0x18, 0xE3,
  0x83, 0x9C, 0x1C, 0x61, 0x80, 0xC7, 0x3C, 0x71, 0xC0, 0x71, 0xFC, 0x30,
  0xC0, 0x18, 0x38, 0x38, 0x60, 0x0C, 0x00, 0x18, 0x30, 0x06, 0x00, 0x1C,
  0x18, 0x03, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x0E, 0x06, 0x00, 0xC0, 0x0E,
  0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0x80, 0x0C, 0x06, 0x01,
  0xC0, 0x07, 0x07, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0xF0, 0x03, 0x8E, 0x00, 0xF0,
  0x0E, 0x3C, 0x00, 0xF0, 0x1C, 0x70, 0x00, 0xF0, 0x30, 0xE0, 0x00, 0xF0,
  0xE1, 0xC0, 0x00, 0xF3, 0x83, 0x80, 0x00, 0xF7, 0x07, 0x00, 0x00, 0xFC,
  0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x07, 0xF0,
  0x3C, 0x00, 0x3C, 0xF0, 0x3E, 0x03, 0xF0, 0xF0, 0x3F, 0xFF, 0x80, 0xF0,
  0x1F, 0xFC, 0x00, 0xF8, 0xFF, 0xF6, 0xDB, 0x6D, 0xB0, 0x03, 0xC0, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x9E, 0x0C, 0x1F,
  0x7F, 0x33, 0xFE, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xEC, 0x00, 0x03, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x03,
  0x80, 0x1C, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0x80, 0x20, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x38, 0xF3,
  0x8E, 0x38, 0xC7, 0x1C, 0x61, 0x8E, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xE0, 0xE0, 0x01, 0x87, 0x00, 0x07,
  0x1C, 0x00, 0x0C, 0x70, 0x00, 0x39, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x78, 0x0F, 0x03, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xB1,
  0xC6, 0xF0, 0xFC, 0x1F, 0x03, 0x40, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xE1, 0xF8, 0x07, 0x87, 0x00, 0x1E, 0x20, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0x00, 0x78,
  0x70, 0x00, 0x71, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xB0, 0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x20,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7B,
  0x00, 0x07, 0x9F, 0x00, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x1F, 0xF0, 0x38, 0xFF, 0xF0, 0xEF, 0x01, 0xE3, 0xB0, 0x01,
  0xCF, 0x80, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07,
  0x07, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0x00,
  0x78, 0x38, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x78, 0x01, 0xF7, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0xF9, 0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0xE7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x78,
  0x07, 0x87, 0x80, 0x1E, 0x38, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7B,
  0x80, 0x06, 0xCE, 0x00, 0x76, 0x7E, 0x1F, 0x30, 0xFF, 0xE3, 0x81, 0xFC,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x40, 0x1F, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x40, 0x38, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x71, 0xC7,
  0x1C, 0x63, 0x8C, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xC0, 0x3C, 0x40, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0xC0, 0x03, 0x8C, 0x00, 0x7F, 0xF0, 0x0C, 0xE0, 0x0F, 0xDF,
  0x80, 0x66, 0x00, 0xF0, 0x0C, 0x03, 0xB0, 0x0E, 0x00, 0x60, 0x1F, 0x80,
  0x70, 0x03, 0x00, 0x7C, 0x07, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x00, 0xC0,
  0x1E, 0x01, 0x80, 0x06, 0x00, 0xF0, 0x1C, 0x00, 0x30, 0x07, 0x80, 0xE0,
  0x03, 0x80, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0xE0, 0x38, 0x00, 0xE0, 0x1F,
  0x00, 0xC0, 0x07, 0x00, 0xD8, 0x06, 0x00, 0x78, 0x06, 0xC0, 0x38, 0x03,
  0xC0, 0x67, 0x00, 0xE0, 0x37, 0x07, 0x38, 0x07, 0xC7, 0x1C, 0xF0, 0xC0,
  0x1F, 0xF0, 0x7F, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x1F, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0x1C, 0x00, 0x1E, 0x38, 0x01, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xC0, 0x0F, 0xC3, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0x38, 0x00, 0x3E, 0x70, 0x0F, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7E,
  0x00, 0x70, 0x78, 0x00, 0x08, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0xFF,
  0x03, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x83, 0x81, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDC, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x70, 0x7C, 0x00, 0x07, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xC0, 0xFF, 0xEF, 0xF8, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x3C, 0xFF, 0x8F, 0xF0, 0x7C, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x73,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0x81,
  0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x39, 0xE0,
  0x00, 0x77, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF9, 0xC0, 0x03, 0xC1, 0xC0,
  0x07, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x07,
  0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00,
  0x3F, 0xDC, 0x00, 0x00, 0x37, 0xCE, 0x00, 0x00, 0x77, 0xCE, 0x00, 0x00,
  0x67, 0xC6, 0x00, 0x00, 0xE7, 0xC7, 0x00, 0x00, 0xE7, 0xC7, 0x00, 0x00,
  0xC7, 0xC3, 0x80, 0x01, 0xC7, 0xC3, 0x80, 0x01, 0x87, 0xC1, 0x80, 0x03,
  0x87, 0xC1, 0xC0, 0x03, 0x87, 0xC1, 0xC0, 0x03, 0x07, 0xC0, 0xE0, 0x07,
  0x07, 0xC0, 0xE0, 0x06, 0x07, 0xC0, 0x60, 0x0E, 0x07, 0xC0, 0x70, 0x0E,
  0x07, 0xC0, 0x70, 0x0C, 0x07, 0xC0, 0x38, 0x1C, 0x07, 0xC0, 0x38, 0x1C,
  0x07, 0xC0, 0x18, 0x38, 0x07, 0xC0, 0x1C, 0x38, 0x07, 0xC0, 0x1C, 0x30,
  0x07, 0xC0, 0x0E, 0x70, 0x07, 0xC0, 0x0E, 0x70, 0x07, 0xC0, 0x06, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0E,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x38, 0x07, 0xF1, 0xC0, 0x03, 0xCE, 0x00,
  0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x07, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80,
  0x3F, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0xE0, 0x1F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x07, 0xFF, 0xFC, 0x7C, 0x01, 0xC7, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xD0, 0x00, 0x3C, 0xF0, 0x07, 0xC7, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8F, 0x00, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB0, 0x00, 0x0E,
  0x00, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xCE, 0x00, 0x07, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x60, 0x00, 0x71, 0xC0, 0x03, 0xB8, 0x00, 0x38, 0xE0,
  0x01, 0xDC, 0x00, 0x38, 0x70, 0x00, 0xC6, 0x00, 0x1C, 0x38, 0x00, 0x63,
  0x00, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x38, 0xE0, 0x07,
  0x03, 0x80, 0x18, 0x30, 0x03, 0x80, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x01,
  0x80, 0x70, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x30,
  0x70, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x01, 0x87, 0x00, 0x0E, 0x18, 0x00,
  0xC3, 0x80, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x38, 0xC0,
  0x00, 0xE6, 0x00, 0x0C, 0xE0, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x1B,
  0x80, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0xE1, 0x80,
  0x01, 0x83, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x06, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x66, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0x8F, 0xC1, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x07, 0x3C, 0x00, 0x77, 0x80, 0x07, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0x70, 0x03, 0xF7, 0x80, 0xF7, 0x3F, 0xFE, 0x30, 0xFF, 0x83,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x0F, 0xE0, 0x38, 0xFF, 0xE0, 0xE7, 0xC7, 0xE3,
  0xB8, 0x03, 0x8F, 0x80, 0x07, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBE, 0x00, 0x1C, 0xFC, 0x00, 0xF3, 0xB8, 0x0F, 0x8C, 0x7F, 0xFC,
  0x30, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFE, 0x7C, 0x78, 0x01,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x1F, 0xC1, 0xC1, 0xFF, 0xC7, 0x0F,
  0x87, 0x9C, 0x78, 0x07, 0x73, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x70, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0xDC, 0x78, 0x0F, 0x70,
  0xFF, 0xF9, 0xC0, 0xFF, 0x87, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xE1,
  0xF0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xCC,
  0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x43, 0xE0, 0x0E, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x1C, 0x1F, 0xFC, 0x70, 0xFC, 0xF9,
  0xC7, 0x80, 0x77, 0x38, 0x00, 0x7D, 0xC0, 0x01, 0xF7, 0x00, 0x03, 0xD8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70,
  0x00, 0x3D, 0xE0, 0x01, 0xF3, 0xC0, 0x0D, 0xC7, 0x80, 0xF7, 0x0F, 0xFF,
  0x9C, 0x0F, 0xF8, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x71, 0x00,
  0x03, 0xC7, 0x80, 0x1E, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x3F, 0x81, 0xC7, 0xFF, 0x0E, 0x7C, 0xFE, 0x77,
  0x00, 0x73, 0xE0, 0x01, 0xDF, 0x00, 0x0E, 0xF0, 0x00, 0x37, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0xFF, 0xBF, 0x81,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0xDC,
  0x00, 0xFC, 0xE0, 0x0F, 0x87, 0x00, 0xF0, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E,
  0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xFC, 0x01,
  0xFC, 0x1C, 0x7F, 0xE0, 0xFF, 0xE3, 0xBE, 0x3E, 0x3E, 0x7E, 0x76, 0x01,
  0xEE, 0x01, 0xEF, 0x80, 0x1D, 0x80, 0x1D, 0xE0, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x1C, 0xC0, 0xFE, 0x07, 0x1F, 0xFC, 0x39, 0xE3, 0xF9, 0xDC,
  0x01, 0xCF, 0x80, 0x07, 0x7C, 0x00, 0x3B, 0xC0, 0x00, 0xDE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x3F, 0x80, 0xF0, 0x07, 0x83,
  0x80, 0x07, 0x0F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03,
  0x87, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0xC0, 0xFE, 0x03, 0x8F, 0xFE, 0x0E, 0x7C, 0x7E, 0x3B,
  0x80, 0x38, 0xF8, 0x00, 0x73, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xE0, 0x01, 0xCF, 0xC0, 0x0F, 0x3B, 0xC0, 0xF8, 0xE7, 0xFF, 0xC3,
  0x87, 0xFC, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x1C,
  0x1F, 0xFC, 0x71, 0xF8, 0x79, 0xC7, 0x00, 0x77, 0x38, 0x00, 0xFD, 0xC0,
  0x01, 0xF7, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0D,
  0xC7, 0x80, 0xE7, 0x0F, 0xFF, 0x1C, 0x1F, 0xF8, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F, 0xFB, 0x80, 0xFC, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0xF3, 0xE1, 0xF9, 0xE0, 0x02, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1E, 0xFF, 0xFF, 0x0F, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x01, 0xB3, 0xC0, 0x73, 0x3F, 0xFE, 0x30, 0xFF,
  0xC3, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01,
  0xC3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x60, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x6E, 0x00, 0x1E, 0x00, 0x39, 0x80, 0x07, 0x80, 0x0E, 0x70, 0x03, 0xF0,
  0x03, 0x9C, 0x00, 0xDC, 0x00, 0xC7, 0x00, 0x33, 0x00, 0x70, 0xC0, 0x1C,
  0xE0, 0x1C, 0x38, 0x06, 0x38, 0x06, 0x0E, 0x01, 0x86, 0x03, 0x83, 0x80,
  0xE1, 0x80, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x0C, 0x1C, 0x0C, 0x07,
  0x07, 0x03, 0x07, 0x00, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0x60, 0x38, 0x70,
  0x0E, 0x38, 0x06, 0x18, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x63, 0x00, 0x73,
  0x80, 0x1D, 0xC0, 0x0C, 0xC0, 0x07, 0x70, 0x03, 0xB0, 0x00, 0xD8, 0x00,
  0xFC, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xE3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0F, 0x0E, 0x00,
  0x1C, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xF0, 0x0F, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x3F, 0x00, 0xF8, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x81, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 35, 12, 4, -34 },
  { 19, 11, 12, 17, 3, -34 },
  { 36, 29, 34, 31, 1, -34 },
  { 160, 21, 39, 27, 3, -36 },
  { 263, 33, 35, 39, 3, -35 },
  { 408, 31, 35, 34, 3, -35 },
  { 544, 3, 12, 10, 3, -34 },
  { 549, 10, 42, 13, 2, -34 },
  { 602, 9, 42, 13, 2, -34 },
  { 650, 22, 20, 26, 2, -36 },
  { 705, 22, 22, 27, 3, -28 },
  { 766, 6, 12, 11, 2, -6 },
  { 775, 12, 2, 15, 2, -14 },
  { 778, 4, 5, 12, 4, -4 },
  { 781, 15, 34, 17, 1, -34 },
  { 845, 22, 35, 27, 3, -35 },
  { 942, 11, 34, 27, 5, -34 },
  { 989, 21, 35, 27, 3, -35 },
  { 1081, 22, 35, 27, 2, -35 },
  { 1178, 26, 34, 27, 1, -34 },
  { 1289, 21, 34, 27, 3, -34 },
  { 1379, 22, 35, 27, 3, -35 },
  { 1476, 23, 34, 27, 2, -34 },
  { 1574, 22, 35, 27, 3, -35 },
  { 1671, 21, 36, 27, 3, -35 },
  { 1766, 4, 27, 12, 4, -26 },
  { 1780, 6, 32, 12, 2, -26 },
  { 1804, 22, 23, 27, 3, -29 },
  { 1868, 22, 12, 27, 3, -23 },
  { 1901, 22, 23, 27, 3, -29 },
  { 1965, 18, 36, 20, 1, -35 },
  { 2046, 37, 39, 43, 3, -34 },
  { 2227, 29, 34, 29, 0, -34 },
  { 2351, 23, 34, 30, 5, -34 },
  { 2449, 25, 35, 30, 3, -35 },
  { 2559, 26, 34, 34, 5, -34 },
  { 2670, 19, 34, 27, 5, -34 },
  { 2751, 19, 34, 24, 5, -34 },
  { 2832, 28, 35, 35, 3, -35 },
  { 2955, 25, 34, 35, 5, -34 },
  { 3062, 11, 34, 15, 2, -34 },
  { 3109, 12, 43, 12, -4, -34 },
  { 3174, 23, 34, 28, 5, -34 },
  { 3272, 19, 34, 25, 5, -34 },
  { 3353, 32, 34, 42, 5, -34 },
  { 3489, 25, 34, 35, 5, -34 },
  { 3596, 31, 35, 37, 3, -35 },
  { 3732, 21, 34, 28, 5, -34 },
  { 3822, 31, 43, 37, 3, -35 },
  { 3989, 23, 34, 29, 5, -34 },
  { 4087, 21, 35, 26, 3, -35 },
  { 4179, 25, 34, 25, 0, -34 },
  { 4286, 26, 34, 35, 4, -34 },
  { 4397, 28, 34, 28, 0, -34 },
  { 4516, 41, 34, 43, 1, -34 },
  { 4691, 26, 34, 26, 0, -34 },
  { 4802, 26, 34, 26, 0, -34 },
  { 4913, 24, 34, 28, 2, -34 },
  { 5015, 10, 42, 15, 4, -34 },
  { 5068, 15, 34, 17, 1, -34 },
  { 5132, 10, 42, 15, 1, -34 },
  { 5185, 23, 22, 27, 2, -35 },
  { 5249, 20, 2, 20, 0, 4 },
  { 5254, 9, 8, 13, 2, -37 },
  { 5263, 20, 26, 26, 2, -26 },
  { 5328, 22, 36, 29, 4, -36 },
  { 5427, 18, 26, 23, 3, -26 },
  { 5486, 22, 36, 29, 3, -36 },
  { 5585, 21, 26, 27, 3, -26 },
  { 5654, 16, 37, 15, 1, -37 },
  { 5728, 22, 38, 29, 3, -26 },
  { 5833, 21, 36, 29, 4, -36 },
  { 5928, 3, 35, 11, 4, -35 },
  { 5942, 10, 47, 11, -3, -35 },
  { 6001, 20, 36, 24, 4, -36 },
  { 6091, 3, 36, 11, 4, -36 },
  { 6105, 35, 26, 43, 4, -26 },
  { 6219, 21, 26, 29, 4, -26 },
  { 6288, 23, 26, 28, 3, -26 },
  { 6363, 22, 37, 29, 4, -26 },
  { 6465, 22, 37, 29, 3, -26 },
  { 6567, 14, 26, 19, 4, -26 },
  { 6613, 18, 26, 23, 2, -26 },
  { 6672, 14, 32, 16, 1, -32 },
  { 6728, 20, 26, 29, 4, -26 },
  { 6793, 23, 26, 23, 0, -26 },
  { 6868, 34, 26, 35, 1, -26 },
  { 6979, 22, 26, 24, 1, -26 },
  { 7051, 23, 38, 23, 0, -26 },
  { 7161, 18, 26, 22, 2, -26 },
  { 7220, 15, 42, 17, 1, -34 },
  { 7299, 2, 49, 26, 12, -37 },
  { 7312, 14, 42, 17, 2, -34 },
  { 7386, 22, 6, 27, 3, -20 },
};

const GFXfont NotoSans_Light48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light48pt7bBitmaps,
  (GFXglyph *)NotoSans_Light48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_LIGHT48PT7B_H_
