#ifndef _NOTOSANS_LIGHT63PT7B_H_
#define _NOTOSANS_LIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7B, 0xEF, 0xFE, 0xF8, 0xC0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x3F, 0x0E, 0x1F, 0x87, 0x81, 0xC0, 0x21, 0xE0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x7E, 0x1C,
  0x00, 0x07, 0xFB, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xE7,
  0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x70, 0x1E, 0x00,
  0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00,
  0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x07, 0xDC, 0x01, 0xC1, 0xF3, 0xF8, 0x39, 0xFC,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x3C, 0x3E, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x03, 0x83, 0xC1, 0xFE, 0x07,
  0x00, 0x1C, 0x1C, 0x3F, 0xF8, 0x38, 0x01, 0xE1, 0xC3, 0xE1, 0xE0, 0xE0,
  0x0E, 0x1E, 0x1C, 0x07, 0x87, 0x00, 0xF0, 0xE1, 0xE0, 0x1C, 0x3C, 0x07,
  0x0F, 0x0E, 0x00, 0xF0, 0xF8, 0xF8, 0x70, 0x70, 0x03, 0x83, 0xFF, 0x87,
  0x87, 0x80, 0x1C, 0x0F, 0xF8, 0x38, 0x38, 0x00, 0xE0, 0x0C, 0x03, 0xC1,
  0xC0, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x00,
  0x0F, 0x87, 0x80, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3C, 0x1F, 0x81, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x3C,
  0x00, 0x7C, 0x00, 0x38, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0xF0,
  0xF0, 0x00, 0x03, 0xE1, 0xE0, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0xE0, 0x00,
  0x00, 0xFB, 0xC0, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7C,
  0x07, 0xFF, 0xFE, 0x00, 0x3E, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x70, 0x07, 0x7C, 0x07, 0x03, 0xFF, 0xF8, 0x61, 0xFF, 0xFF, 0xF6,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x1C, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x21, 0xEF, 0xBF, 0xFB, 0xE3, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3E, 0xE0,
  0xF9, 0xC3, 0xE3, 0x9F, 0x07, 0x7C, 0x0F, 0xF0, 0x1D, 0xC0, 0x39, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x1F, 0x02, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFB, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE1,
  0xC0, 0x00, 0x0F, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE6, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3B, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x87,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x03, 0xF8, 0x01, 0xE0, 0xFF, 0xF8, 0x0F, 0x1F,
  0xFF, 0xF0, 0x79, 0xF0, 0x0F, 0xC3, 0xDE, 0x00, 0x1F, 0x1D, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0x07, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x7F, 0x1F, 0x00, 0x0F, 0x78, 0x7E, 0x01, 0xF3, 0xC1, 0xFF, 0xFF,
  0x1E, 0x03, 0xFF, 0xE0, 0xF0, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7B, 0xEF, 0xBF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21,
  0xEF, 0xBF, 0xFB, 0xE3, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0x88, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xC1, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x70, 0x70, 0x00, 0xFF, 0x7F, 0x80,
  0x1E, 0x38, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x9C, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0xF7, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3D, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x0F, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xBC, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0xEF, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3B, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x0E, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x9C, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x71, 0xC0,
  0x0E, 0x00, 0x0F, 0x80, 0x1C, 0x70, 0x03, 0xC0, 0x03, 0x60, 0x0E, 0x1C,
  0x00, 0x78, 0x01, 0xDC, 0x03, 0x87, 0x00, 0x1F, 0x01, 0xE7, 0x03, 0xC0,
  0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xE0, 0x38, 0x00, 0x7F, 0xF8, 0x1F, 0xF0,
  0x0F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x0F, 0x00,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0xC0,
  0xF0, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x80, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x1E, 0x7F, 0x80, 0x00, 0x3D, 0xEF, 0x80, 0x00, 0x7F,
  0x8F, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3B, 0xFD, 0xC0, 0x00, 0x00, 0x07, 0x7F,
  0xBC, 0x00, 0x00, 0x01, 0xEF, 0xF3, 0x80, 0x00, 0x00, 0x39, 0xFE, 0x78,
  0x00, 0x00, 0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x01, 0xC7, 0xF8, 0xE0, 0x00,
  0x00, 0x38, 0xFF, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0xE3, 0xC0, 0x00, 0x01,
  0xC3, 0xFC, 0x3C, 0x00, 0x00, 0x78, 0x7F, 0x87, 0x80, 0x00, 0x0E, 0x0F,
  0xF0, 0x70, 0x00, 0x01, 0xC1, 0xFE, 0x0F, 0x00, 0x00, 0x78, 0x3F, 0xC1,
  0xE0, 0x00, 0x0E, 0x07, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xFF, 0x03, 0xC0,
  0x00, 0x70, 0x1F, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0xFC, 0x07, 0x80, 0x03,
  0xC0, 0x7F, 0x80, 0xF0, 0x00, 0x70, 0x0F, 0xF0, 0x0E, 0x00, 0x1E, 0x01,
  0xFE, 0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0x80, 0x1F, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0x0E, 0x03,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0x1C, 0x00,
  0x3F, 0xC0, 0x03, 0x87, 0x80, 0x07, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00,
  0x1E, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x0F, 0xF7, 0xC0,
  0x00, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xC7,
  0xC0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x00, 0xFF,
  0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x03,
  0xFC, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x1E, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xFC, 0x00,
  0x1E, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0xF0, 0x0F, 0xF0,
  0x00, 0x1E, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x00, 0xF0, 0x3F,
  0xC0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x00, 0xF0,
  0xFF, 0x00, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0x00,
  0xF3, 0xFC, 0x00, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x1F,
  0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xF4, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0x04, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFC, 0x0E, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0xF1, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xDE, 0x00, 0x0E, 0xF7, 0xC0, 0x07,
  0x3C, 0xFF, 0x1F, 0x87, 0x1F, 0xFF, 0xC1, 0xC1, 0xFF, 0xE0, 0x70, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xC0, 0x1E, 0x0F, 0xFF, 0x80,
  0xF1, 0xFF, 0xFF, 0x07, 0x9F, 0x00, 0xFC, 0x3D, 0xE0, 0x01, 0xF1, 0xEE,
  0x00, 0x07, 0x8F, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x00, 0xF3, 0xF0, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x1E, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F, 0x3F, 0x80,
  0x00, 0xF1, 0xEE, 0x00, 0x0F, 0x8F, 0x78, 0x00, 0xF8, 0x79, 0xFE, 0xFF,
  0x83, 0x83, 0xFF, 0xF8, 0x1C, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x1E,
  0x0F, 0x80, 0x02, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x7F,
  0xC0, 0x70, 0x1F, 0xFF, 0x07, 0x07, 0xFF, 0xFC, 0x70, 0xFE, 0x03, 0xE7,
  0x1F, 0x80, 0x0F, 0x71, 0xE0, 0x00, 0x77, 0x3C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x3C, 0x00, 0x03, 0x71, 0xE0, 0x00, 0x77, 0x1F, 0x80, 0x1E, 0x70, 0xFF,
  0xDF, 0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x83, 0xF0, 0x00, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x02, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x70, 0x1F, 0xFF, 0x87, 0x07, 0xFF, 0xFC, 0x70, 0xFE,
  0x03, 0xE7, 0x1F, 0x00, 0x0F, 0x71, 0xE0, 0x00, 0x77, 0x3C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x1F, 0x3C, 0x00, 0x03, 0x71, 0xE0, 0x00, 0x77, 0x1F, 0x80, 0x1E,
  0x70, 0xFF, 0xBF, 0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0xFE, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE4, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x03, 0xFE, 0x03, 0x83, 0xFF, 0xF0, 0xE3, 0xFF, 0xFE, 0x39,
  0xF0, 0x0F, 0xCE, 0xF0, 0x00, 0xFB, 0xB0, 0x00, 0x1E, 0xFC, 0x00, 0x03,
  0xBE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x77, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x00, 0x07,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x70, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE4, 0x1F, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x3E,
  0x01, 0xC0, 0x3E, 0x00, 0xE0, 0x3E, 0x00, 0x70, 0x3E, 0x00, 0x38, 0x1E,
  0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1F, 0x00, 0x03, 0x9F,
  0xC0, 0x01, 0xDF, 0xF0, 0x00, 0xFE, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x3E,
  0x07, 0x80, 0x1E, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x01, 0xC0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x38, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xCF, 0x01, 0xF8, 0xF8, 0x0F, 0xCE,
  0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0xC0, 0x3F, 0xE0, 0x38, 0x3F, 0xFF, 0x0E, 0x3F, 0xFF, 0xE3, 0x9F,
  0x00, 0xFC, 0xEF, 0x00, 0x0F, 0xBB, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x0E, 0x0F, 0xFF, 0x80, 0xE3,
  0xFF, 0xFE, 0x0E, 0x7C, 0x03, 0xF0, 0xEF, 0x00, 0x0F, 0x8E, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xCE, 0xE0, 0x00,
  0xF8, 0xE7, 0x80, 0x1F, 0x0E, 0x3F, 0xBF, 0xE0, 0xE1, 0xFF, 0xFC, 0x0E,
  0x07, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x70,
  0x1F, 0xFF, 0x07, 0x07, 0xFF, 0xFC, 0x70, 0xFC, 0x03, 0xE7, 0x1F, 0x00,
  0x0F, 0x73, 0xE0, 0x00, 0x77, 0x3C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x3C, 0x00,
  0x03, 0x71, 0xE0, 0x00, 0x77, 0x1F, 0x80, 0x1E, 0x70, 0xFF, 0xBF, 0xC7,
  0x03, 0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0x82, 0xEF, 0x00, 0x3B,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x04, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x7C, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xEF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xF7, 0x80, 0x00, 0xFE, 0x78,
  0x00, 0x3D, 0xCF, 0xC0, 0x0F, 0x38, 0xFF, 0xBF, 0xC7, 0x0F, 0xFF, 0xF0,
  0xE0, 0x7F, 0xF8, 0x1C, 0x01, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xDC, 0x00,
  0x1E, 0x38, 0x00, 0x1D, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0x3C, 0x00, 0x39, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x1C,
  0x00, 0x78, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x1C, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x1E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x73, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00,
  0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x01, 0xFF,
  0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFB, 0x00, 0x07, 0xFF, 0xC8, 0x00,
  0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 46, 16, 5, -45 },
  { 36, 15, 16, 23, 4, -45 },
  { 66, 37, 45, 41, 2, -45 },
  { 275, 27, 52, 36, 4, -48 },
  { 451, 45, 47, 51, 3, -46 },
  { 716, 40, 47, 45, 4, -46 },
  { 951, 4, 16, 13, 4, -45 },
  { 959, 12, 55, 18, 3, -45 },
  { 1042, 13, 55, 18, 2, -45 },
  { 1132, 28, 27, 35, 3, -48 },
  { 1227, 30, 30, 36, 3, -37 },
  { 1340, 7, 15, 14, 3, -7 },
  { 1354, 15, 4, 20, 3, -19 },
  { 1362, 6, 7, 15, 5, -6 },
  { 1368, 20, 45, 22, 1, -45 },
  { 1481, 28, 47, 36, 4, -46 },
  { 1646, 15, 45, 36, 6, -45 },
  { 1731, 29, 46, 36, 3, -46 },
  { 1898, 29, 47, 36, 3, -46 },
  { 2069, 34, 45, 36, 1, -45 },
  { 2261, 28, 46, 36, 4, -45 },
  { 2422, 29, 47, 36, 4, -46 },
  { 2593, 30, 45, 36, 3, -45 },
  { 2762, 28, 47, 36, 4, -46 },
  { 2927, 29, 47, 36, 3, -46 },
  { 3098, 6, 35, 15, 5, -34 },
  { 3125, 8, 42, 15, 2, -34 },
  { 3167, 30, 30, 36, 3, -38 },
  { 3280, 28, 16, 36, 4, -30 },
  { 3336, 30, 30, 36, 3, -38 },
  { 3449, 23, 47, 27, 2, -46 },
  { 3585, 50, 51, 56, 3, -45 },
  { 3904, 38, 45, 38, 0, -45 },
  { 4118, 30, 45, 40, 6, -45 },
  { 4287, 33, 47, 39, 4, -46 },
  { 4481, 35, 45, 45, 6, -45 },
  { 4678, 25, 45, 35, 6, -45 },
  { 4819, 25, 45, 32, 6, -45 },
  { 4960, 37, 47, 46, 4, -46 },
  { 5178, 33, 45, 46, 6, -45 },
  { 5364, 13, 45, 20, 3, -45 },
  { 5438, 16, 56, 16, -6, -45 },
  { 5550, 31, 45, 37, 6, -45 },
  { 5725, 25, 45, 32, 6, -45 },
  { 5866, 43, 45, 55, 6, -45 },
  { 6108, 34, 45, 46, 6, -45 },
  { 6300, 40, 47, 48, 4, -46 },
  { 6535, 28, 45, 37, 6, -45 },
  { 6693, 40, 57, 48, 4, -46 },
  { 6978, 30, 45, 38, 6, -45 },
  { 7147, 28, 47, 34, 3, -46 },
  { 7312, 33, 45, 33, 0, -45 },
  { 7498, 34, 46, 45, 6, -45 },
  { 7694, 37, 45, 37, 0, -45 },
  { 7903, 54, 45, 57, 1, -45 },
  { 8207, 34, 45, 35, 0, -45 },
  { 8399, 34, 45, 34, 0, -45 },
  { 8591, 32, 45, 36, 2, -45 },
  { 8771, 14, 55, 20, 5, -45 },
  { 8868, 20, 45, 22, 1, -45 },
  { 8981, 13, 55, 20, 2, -45 },
  { 9071, 30, 28, 36, 3, -45 },
  { 9176, 26, 3, 26, 0, 6 },
  { 9186, 11, 10, 17, 3, -48 },
  { 9200, 26, 35, 34, 3, -34 },
  { 9314, 29, 49, 38, 5, -48 },
  { 9492, 24, 35, 30, 4, -34 },
  { 9597, 28, 49, 38, 4, -48 },
  { 9769, 27, 35, 35, 4, -34 },
  { 9888, 22, 48, 19, 1, -48 },
  { 10020, 28, 49, 38, 4, -34 },
  { 10192, 26, 48, 38, 6, -48 },
  { 10348, 5, 46, 15, 5, -46 },
  { 10377, 13, 61, 15, -3, -46 },
  { 10477, 25, 48, 31, 6, -48 },
  { 10627, 3, 48, 15, 6, -48 },
  { 10645, 45, 34, 56, 6, -34 },
  { 10837, 26, 34, 38, 6, -34 },
  { 10948, 30, 35, 37, 4, -34 },
  { 11080, 28, 49, 38, 6, -34 },
  { 11252, 28, 49, 38, 4, -34 },
  { 11424, 18, 34, 25, 6, -34 },
  { 11501, 24, 35, 30, 3, -34 },
  { 11606, 19, 43, 21, 1, -42 },
  { 11709, 27, 35, 38, 5, -34 },
  { 11828, 30, 34, 30, 0, -34 },
  { 11956, 44, 34, 46, 1, -34 },
  { 12143, 29, 34, 32, 1, -34 },
  { 12267, 30, 49, 30, 0, -34 },
  { 12451, 24, 34, 29, 3, -34 },
  { 12553, 18, 55, 23, 2, -45 },
  { 12677, 4, 64, 34, 15, -48 },
  { 12709, 19, 55, 23, 2, -45 },
  { 12840, 30, 7, 36, 3, -26 },
};

const GFXfont NotoSans_Light63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light63pt7bBitmaps,
  (GFXglyph *)NotoSans_Light63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_LIGHT63PT7B_H_
