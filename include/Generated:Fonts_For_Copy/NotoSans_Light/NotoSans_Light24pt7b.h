#ifndef _NOTOSANS_LIGHT24PT7B_H_
#define _NOTOSANS_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC4, 0x04, 0x30,
  0x10, 0x80, 0x42, 0x03, 0x08, 0x08, 0x21, 0xFF, 0xF0, 0x84, 0x02, 0x10,
  0x08, 0x40, 0x41, 0x01, 0x0C, 0x3F, 0xFE, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x08, 0x60, 0x21, 0x00, 0x08, 0x03, 0x07, 0xFB, 0x22, 0x88, 0x22, 0x08,
  0x83, 0x20, 0x78, 0x07, 0x80, 0xB8, 0x22, 0x08, 0xC2, 0x30, 0x8E, 0x26,
  0xFF, 0x02, 0x00, 0x80, 0x3C, 0x04, 0x23, 0x04, 0x10, 0x86, 0x18, 0x42,
  0x0C, 0x23, 0x06, 0x11, 0x03, 0x09, 0x10, 0x84, 0xBE, 0x46, 0x91, 0x9E,
  0x48, 0x40, 0x4C, 0x20, 0x66, 0x10, 0x23, 0x08, 0x31, 0x84, 0x10, 0x42,
  0x10, 0x23, 0x18, 0x0F, 0x00, 0x1F, 0x80, 0x10, 0xC0, 0x30, 0x40, 0x20,
  0x40, 0x30, 0x40, 0x10, 0x80, 0x0B, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x23,
  0x06, 0x41, 0x86, 0xC0, 0xC4, 0xC0, 0x6C, 0xC0, 0x38, 0x40, 0x38, 0x70,
  0xEC, 0x1F, 0x87, 0xFC, 0x19, 0x88, 0xC4, 0x23, 0x18, 0x84, 0x21, 0x08,
  0x63, 0x08, 0x43, 0x08, 0x21, 0x80, 0xC2, 0x18, 0x43, 0x08, 0x42, 0x18,
  0xC6, 0x31, 0x88, 0x42, 0x31, 0x18, 0x88, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x62, 0x3F, 0xFE, 0x08, 0x02, 0x80, 0xD8, 0x31, 0x86, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x6D, 0x2D, 0x00, 0xFC, 0xF0, 0x03, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0xC0,
  0x1F, 0x86, 0x19, 0x81, 0x20, 0x34, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD8, 0x11, 0x86, 0x1F, 0x80,
  0x0C, 0x76, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x3F, 0x8C, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xE0, 0x3F, 0x98, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80, 0x30, 0x38,
  0x1F, 0x80, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x1E, 0x06, 0x7F,
  0x80, 0x00, 0x80, 0x18, 0x02, 0x80, 0x68, 0x04, 0x80, 0x88, 0x18, 0x83,
  0x08, 0x20, 0x84, 0x08, 0xC0, 0x8F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFC, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0E, 0x06, 0xFE,
  0x00, 0x0F, 0xC3, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0xC2, 0xFE,
  0xE0, 0x78, 0x07, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x19, 0x86, 0x1F,
  0x80, 0xFF, 0xE0, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x00, 0x1F, 0x84, 0x19, 0x81, 0xA0, 0x34, 0x06, 0xC0, 0x8C, 0x20, 0xF8,
  0x1F, 0x06, 0x19, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x50, 0x1B, 0x06, 0x1F,
  0x80, 0x3F, 0x8C, 0x19, 0x01, 0x60, 0x3C, 0x03, 0x80, 0x70, 0x0A, 0x03,
  0x60, 0xA7, 0xF4, 0x10, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x1C, 0x7E,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x01, 0xA5, 0xB4, 0x00,
  0x20, 0x18, 0x0C, 0x06, 0x07, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x70, 0x38, 0x1C,
  0x0C, 0x02, 0x00, 0x00, 0xFE, 0x83, 0x01, 0x01, 0x01, 0x01, 0x03, 0x06,
  0x08, 0x10, 0x10, 0x30, 0x00, 0x00, 0x00, 0x30, 0x30, 0x01, 0xFC, 0x00,
  0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x62, 0x00, 0x04, 0xC3, 0xF8, 0xD0,
  0xC3, 0x0A, 0x10, 0x61, 0xC6, 0x0C, 0x38, 0x81, 0x07, 0x10, 0x20, 0xE3,
  0x04, 0x3C, 0x21, 0x44, 0x87, 0xEF, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0A,
  0x00, 0x34, 0x00, 0x4C, 0x00, 0x88, 0x03, 0x18, 0x04, 0x10, 0x18, 0x20,
  0x20, 0x60, 0x7F, 0xC1, 0x80, 0x82, 0x01, 0x8C, 0x01, 0x10, 0x03, 0x20,
  0x02, 0xC0, 0x06, 0xFF, 0x8C, 0x0E, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02,
  0xC0, 0x6F, 0xF8, 0xFF, 0xCC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x2C, 0x0E, 0xFF, 0x80, 0x07, 0xF8, 0xE0, 0x4C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x81, 0x07, 0xF8, 0xFF, 0x83, 0x03,
  0x8C, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x00, 0x4C, 0x07, 0x30,
  0x70, 0xFF, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x07,
  0xFC, 0x38, 0x08, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0xFE, 0x81, 0xFD, 0x00, 0x1A, 0x00, 0x36, 0x00, 0x64,
  0x00, 0xCC, 0x01, 0x8E, 0x03, 0x07, 0xFC, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC6, 0xF0, 0xC0, 0x3C, 0x04, 0xC0, 0x8C, 0x10, 0xC3, 0x0C, 0x60, 0xCC,
  0x0D, 0x80, 0xFC, 0x0E, 0x60, 0xC2, 0x0C, 0x30, 0xC1, 0x8C, 0x0C, 0xC0,
  0x4C, 0x06, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFA, 0x00, 0xBD, 0x00,
  0x5E, 0xC0, 0x6F, 0x20, 0x27, 0x98, 0x33, 0xC4, 0x11, 0xE2, 0x08, 0xF1,
  0x8C, 0x78, 0x44, 0x3C, 0x26, 0x1E, 0x1A, 0x0F, 0x05, 0x07, 0x83, 0x83,
  0xC0, 0x81, 0x80, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xA0, 0x1D, 0x80, 0xE6,
  0x07, 0x10, 0x38, 0xC1, 0xC3, 0x0E, 0x08, 0x70, 0x63, 0x81, 0x9C, 0x04,
  0xE0, 0x37, 0x00, 0xF8, 0x03, 0xC0, 0x18, 0x0F, 0xF0, 0x18, 0x1C, 0x30,
  0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30,
  0x0C, 0x1C, 0x18, 0x07, 0xF0, 0xFF, 0x18, 0x3B, 0x01, 0x60, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x06, 0xC3, 0x9F, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x18, 0x1C, 0x30, 0x04, 0x60,
  0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C,
  0x18, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0xFF,
  0x8C, 0x1C, 0xC0, 0x4C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xFF,
  0x8F, 0xE0, 0xC3, 0x0C, 0x18, 0xC0, 0x8C, 0x0C, 0xC0, 0x4C, 0x06, 0xC0,
  0x30, 0x3F, 0xCC, 0x09, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1E, 0x06, 0xFF,
  0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x46, 0x0C, 0x1F, 0xC0, 0xC0, 0x0D, 0x00,
  0x24, 0x00, 0x98, 0x06, 0x20, 0x10, 0xC0, 0xC3, 0x03, 0x04, 0x08, 0x18,
  0x60, 0x21, 0x00, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00, 0x78, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x60, 0x38, 0x06, 0x03, 0xC0, 0xE0, 0x24, 0x0B,
  0x02, 0x40, 0xB0, 0x64, 0x19, 0x06, 0x61, 0x10, 0x42, 0x11, 0x84, 0x21,
  0x08, 0xC3, 0x30, 0x88, 0x32, 0x0C, 0x81, 0x20, 0xD8, 0x16, 0x05, 0x81,
  0xE0, 0x50, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x19,
  0x01, 0x8C, 0x08, 0x20, 0x81, 0x8C, 0x06, 0x40, 0x14, 0x00, 0xE0, 0x07,
  0x00, 0x28, 0x03, 0x60, 0x11, 0x81, 0x04, 0x18, 0x30, 0x80, 0xCC, 0x02,
  0xC0, 0x18, 0xC0, 0x1A, 0x01, 0x98, 0x08, 0x40, 0xC1, 0x04, 0x0C, 0x60,
  0x22, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06,
  0x02, 0x02, 0x01, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x3F, 0x80, 0x06, 0x00, 0x60, 0x0B, 0x01, 0x90, 0x11,
  0x83, 0x08, 0x20, 0xC6, 0x04, 0x40, 0x6C, 0x03, 0xFF, 0xC0, 0xC6, 0x30,
  0x1F, 0x18, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x13, 0xFD, 0x81, 0xC0, 0xF0,
  0x3C, 0x0D, 0x05, 0x7E, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x3E, 0x2C, 0x67, 0x02, 0xC0, 0x78, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0xF0, 0x1E, 0x02, 0xA0, 0xD3, 0xE0, 0x0F, 0xCE, 0x26, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC1, 0x1F, 0xC0, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x3E, 0x4C, 0x2B, 0x03, 0x40, 0x68,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x50, 0x0B, 0x03, 0x30, 0xA3, 0xE4,
  0x0F, 0x06, 0x39, 0x81, 0x20, 0x34, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x18, 0x21, 0xFC, 0x0F, 0x8C, 0x04, 0x02, 0x01, 0x07,
  0xF0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1F, 0x26, 0x15, 0x81, 0xA0, 0x14, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x28, 0x05, 0x81, 0x98, 0x51, 0xF2, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x6F, 0x78, 0x7C, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x27, 0xCB, 0x1B, 0x03, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0xB8, 0x2A, 0xAA, 0xAA, 0xA0, 0x10, 0xC4,
  0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0A,
  0xDC, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x68, 0x12, 0x08, 0x84,
  0x22, 0x09, 0x82, 0xE0, 0xEC, 0x31, 0x08, 0x22, 0x0C, 0x81, 0xA0, 0x30,
  0xFF, 0xFF, 0xC0, 0x9F, 0x1F, 0x58, 0xD8, 0xF0, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x9F, 0x2C, 0x6C, 0x0F, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x0F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x40, 0x34, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x8F, 0x16, 0x3A, 0x81,
  0x60, 0x3C, 0x07, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0x50,
  0x69, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F,
  0x26, 0x15, 0x81, 0xA0, 0x34, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28,
  0x05, 0x81, 0x98, 0x51, 0xF2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x9F, 0x62, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x00, 0x3F, 0x30, 0xF0, 0x18, 0x04, 0x03, 0x80, 0x78, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x3F, 0xF0, 0x10, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x1F, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3C, 0x0D, 0x85,
  0x3E, 0x40, 0xC0, 0x38, 0x0D, 0x01, 0x30, 0x22, 0x0C, 0x41, 0x0C, 0x60,
  0x88, 0x19, 0x01, 0x60, 0x28, 0x07, 0x00, 0x60, 0xC0, 0xC0, 0xA0, 0x60,
  0x50, 0x70, 0x6C, 0x2C, 0x22, 0x12, 0x11, 0x09, 0x08, 0x8C, 0xCC, 0x64,
  0x24, 0x12, 0x12, 0x0B, 0x0F, 0x07, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0x48, 0x11, 0x86, 0x19, 0x81, 0x20, 0x3C, 0x03, 0x00, 0xF0, 0x12,
  0x06, 0x21, 0x86, 0x20, 0x48, 0x06, 0xC0, 0x28, 0x0D, 0x01, 0x30, 0x22,
  0x0C, 0x61, 0x0C, 0x60, 0x88, 0x19, 0x01, 0x60, 0x28, 0x07, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x16, 0x03, 0x80, 0x00, 0xFF, 0x80, 0xC0,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0F, 0xF8,
  0x0E, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC3, 0x01, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x40, 0xE0, 0x60, 0xFF, 0xFF, 0xFF, 0xE0, 0x60,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x18, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC3, 0x0C, 0x00, 0x38, 0x3D, 0xCE, 0x07, 0x00,
};

const GFXglyph NotoSans_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 5, 6, 9, 2, -17 },
  { 10, 14, 17, 16, 1, -17 },
  { 40, 10, 19, 14, 2, -18 },
  { 64, 17, 17, 19, 1, -17 },
  { 101, 16, 17, 17, 1, -17 },
  { 135, 1, 6, 5, 2, -17 },
  { 136, 5, 21, 7, 1, -17 },
  { 150, 5, 21, 7, 1, -17 },
  { 164, 11, 10, 13, 1, -18 },
  { 178, 11, 11, 14, 1, -14 },
  { 194, 3, 6, 5, 1, -3 },
  { 197, 6, 1, 8, 1, -7 },
  { 198, 2, 2, 6, 2, -2 },
  { 199, 8, 17, 8, 0, -17 },
  { 216, 11, 17, 14, 1, -17 },
  { 240, 6, 17, 14, 2, -17 },
  { 253, 11, 17, 14, 1, -17 },
  { 277, 11, 17, 14, 1, -17 },
  { 301, 12, 17, 14, 1, -17 },
  { 327, 10, 17, 14, 2, -17 },
  { 349, 11, 17, 14, 1, -17 },
  { 373, 11, 17, 14, 1, -17 },
  { 397, 11, 17, 14, 1, -17 },
  { 421, 11, 17, 14, 1, -17 },
  { 445, 2, 13, 6, 2, -13 },
  { 449, 3, 16, 6, 1, -13 },
  { 455, 11, 11, 14, 1, -14 },
  { 471, 11, 6, 14, 1, -11 },
  { 480, 11, 11, 14, 1, -14 },
  { 496, 8, 17, 10, 1, -17 },
  { 513, 19, 19, 21, 1, -17 },
  { 559, 15, 17, 15, 0, -17 },
  { 591, 12, 17, 15, 2, -17 },
  { 617, 13, 17, 15, 1, -17 },
  { 645, 14, 17, 17, 2, -17 },
  { 675, 10, 17, 13, 2, -17 },
  { 697, 10, 17, 12, 2, -17 },
  { 719, 15, 17, 17, 1, -17 },
  { 751, 13, 17, 17, 2, -17 },
  { 779, 5, 17, 7, 1, -17 },
  { 790, 6, 21, 6, -2, -17 },
  { 806, 12, 17, 14, 2, -17 },
  { 832, 10, 17, 12, 2, -17 },
  { 854, 17, 17, 21, 2, -17 },
  { 891, 13, 17, 18, 2, -17 },
  { 919, 16, 17, 18, 1, -17 },
  { 953, 11, 17, 14, 2, -17 },
  { 977, 16, 21, 18, 1, -17 },
  { 1019, 12, 17, 14, 2, -17 },
  { 1045, 11, 17, 13, 1, -17 },
  { 1069, 13, 17, 13, 0, -17 },
  { 1097, 13, 17, 17, 2, -17 },
  { 1125, 14, 17, 14, 0, -17 },
  { 1155, 20, 17, 22, 1, -17 },
  { 1198, 13, 17, 13, 0, -17 },
  { 1226, 13, 17, 13, 0, -17 },
  { 1254, 12, 17, 14, 1, -17 },
  { 1280, 5, 21, 8, 2, -17 },
  { 1294, 8, 17, 8, 0, -17 },
  { 1311, 5, 21, 8, 1, -17 },
  { 1325, 12, 10, 14, 1, -17 },
  { 1340, 10, 1, 10, 0, 2 },
  { 1342, 4, 3, 6, 1, -18 },
  { 1344, 10, 13, 13, 1, -13 },
  { 1361, 11, 18, 14, 2, -18 },
  { 1386, 10, 13, 11, 1, -13 },
  { 1403, 11, 18, 14, 1, -18 },
  { 1428, 11, 13, 13, 1, -13 },
  { 1446, 9, 18, 7, 0, -18 },
  { 1467, 11, 19, 14, 1, -13 },
  { 1494, 10, 18, 14, 2, -18 },
  { 1517, 2, 18, 6, 2, -18 },
  { 1522, 5, 24, 6, -1, -18 },
  { 1537, 10, 18, 12, 2, -18 },
  { 1560, 1, 18, 6, 2, -18 },
  { 1563, 17, 13, 21, 2, -13 },
  { 1591, 10, 13, 14, 2, -13 },
  { 1608, 12, 13, 14, 1, -13 },
  { 1628, 11, 19, 14, 2, -13 },
  { 1655, 11, 19, 14, 1, -13 },
  { 1682, 7, 13, 9, 2, -13 },
  { 1694, 9, 13, 11, 1, -13 },
  { 1709, 8, 16, 8, 0, -16 },
  { 1725, 10, 13, 14, 2, -13 },
  { 1742, 11, 13, 11, 0, -13 },
  { 1760, 17, 13, 18, 0, -13 },
  { 1788, 11, 13, 12, 1, -13 },
  { 1806, 11, 19, 11, 0, -13 },
  { 1833, 9, 13, 11, 1, -13 },
  { 1848, 7, 21, 9, 1, -17 },
  { 1867, 1, 24, 13, 6, -18 },
  { 1870, 7, 21, 9, 1, -17 },
  { 1889, 11, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Light24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light24pt7bBitmaps,
  (GFXglyph *)NotoSans_Light24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_LIGHT24PT7B_H_
