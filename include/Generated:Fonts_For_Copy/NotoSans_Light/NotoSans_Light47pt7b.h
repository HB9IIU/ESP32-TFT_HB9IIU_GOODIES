#ifndef _NOTOSANS_LIGHT47PT7B_H_
#define _NOTOSANS_LIGHT47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x00, 0xEF, 0xFF, 0x40, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xD8, 0x3B, 0x07, 0x60, 0xEC, 0x19, 0x83, 0x30, 0x26,
  0x04, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x60, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x06,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x18, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xFE, 0x3C, 0x63, 0xC7, 0x06, 0x04, 0xE0, 0x60, 0x0E, 0x06,
  0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x86, 0x00, 0x3E, 0x60, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x06, 0x7C, 0x00, 0x61, 0xE0, 0x06, 0x0F,
  0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60,
  0x70, 0x06, 0x07, 0x80, 0x60, 0xEE, 0x06, 0x3C, 0xFF, 0xFF, 0x87, 0xFF,
  0xE0, 0x02, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x60, 0x1C, 0x38,
  0x00, 0x70, 0x0C, 0x0E, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x30, 0x06, 0x01,
  0x80, 0x38, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x70, 0x1C, 0x00, 0xC0,
  0x38, 0x0C, 0x00, 0x60, 0x0C, 0x0E, 0x00, 0x30, 0x06, 0x06, 0x00, 0x18,
  0x03, 0x07, 0x00, 0x0C, 0x03, 0x87, 0x00, 0x06, 0x01, 0xC3, 0x03, 0x03,
  0x00, 0xE3, 0x8F, 0xE1, 0x80, 0x61, 0x8F, 0xF8, 0xE0, 0x31, 0xC6, 0x0E,
  0x30, 0x38, 0xC7, 0x03, 0x9C, 0x38, 0xE3, 0x00, 0xC7, 0xF8, 0x61, 0x80,
  0x60, 0xF8, 0x71, 0xC0, 0x30, 0x00, 0x70, 0xE0, 0x1C, 0x00, 0x30, 0x70,
  0x0E, 0x00, 0x38, 0x38, 0x07, 0x00, 0x18, 0x1C, 0x03, 0x80, 0x1C, 0x0E,
  0x01, 0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x60, 0x06, 0x00,
  0xC0, 0x30, 0x07, 0x00, 0x60, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x00,
  0x0E, 0x1C, 0x03, 0x80, 0x07, 0xFC, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x07, 0x0E, 0x03,
  0x80, 0x1C, 0x70, 0x07, 0x00, 0x73, 0xC0, 0x0E, 0x01, 0x8E, 0x00, 0x1C,
  0x0E, 0x38, 0x00, 0x38, 0x30, 0xE0, 0x00, 0x71, 0xC3, 0x80, 0x00, 0xEE,
  0x0E, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0xFE, 0x07, 0x80, 0x07, 0x9C, 0x0F, 0x80, 0xFC, 0x38, 0x1F,
  0xFF, 0xC0, 0x70, 0x1F, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6,
  0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0xC0, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xC0,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x06, 0x07,
  0x7C, 0x31, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x66, 0x00, 0x07, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x1C, 0x03, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x39, 0xCE, 0x77, 0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xEF, 0xFF, 0x40, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xE3, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x00, 0x06, 0x1C,
  0x00, 0x70, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xF1, 0xEE, 0x79, 0xDC, 0x3F, 0x07,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE1, 0xF0, 0x07, 0x86, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03,
  0xF8, 0xFC, 0x3E, 0x00, 0x78, 0x60, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC8, 0x00, 0x0F, 0x3E, 0x00, 0xF8, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03,
  0x81, 0x80, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x30, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x72, 0x00, 0x07,
  0x9E, 0x00, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0xFC, 0x08, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x3F, 0x03, 0x8F, 0xFE,
  0x1C, 0xF8, 0xF8, 0xEE, 0x00, 0xE7, 0xC0, 0x03, 0xBC, 0x00, 0x0D, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1B, 0x00, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x00,
  0x03, 0x1C, 0x00, 0x38, 0x70, 0x03, 0x81, 0xE0, 0x7C, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xC3, 0xF0, 0x78, 0x03, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x1C, 0x0F,
  0x01, 0xC0, 0x3E, 0x3C, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0x81, 0xE0, 0x78, 0x03, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x80,
  0x7C, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xF8, 0x7C, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xC0, 0x01, 0xC7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0xF0, 0x03, 0x71, 0xE0, 0x3D, 0xC3,
  0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xF4, 0x3C, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x18, 0xE3, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0x9F, 0x8C, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x1F, 0xF0, 0x06, 0x70, 0x07, 0xFF, 0xC0, 0x66, 0x00, 0xF0, 0x1C,
  0x07, 0x60, 0x1C, 0x01, 0xC0, 0x3E, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x38,
  0x01, 0x80, 0x3C, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x70, 0x01, 0x80, 0x3C,
  0x07, 0x00, 0x18, 0x03, 0xC0, 0x70, 0x01, 0x80, 0x3C, 0x07, 0x00, 0x18,
  0x03, 0xC0, 0x70, 0x01, 0x80, 0x7C, 0x07, 0x00, 0x38, 0x07, 0xC0, 0x70,
  0x03, 0x80, 0x6C, 0x03, 0x00, 0x68, 0x0E, 0xC0, 0x38, 0x06, 0xC0, 0xCE,
  0x01, 0xE1, 0xCE, 0x38, 0x60, 0x0F, 0xF8, 0x7F, 0x86, 0x00, 0x3E, 0x03,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x30, 0x00, 0xF8, 0xC0, 0x00, 0xF3,
  0x00, 0x01, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x03,
  0xCC, 0x00, 0x1E, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0C,
  0x00, 0x1F, 0x30, 0x00, 0x1E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xEC, 0x00, 0x0F, 0x30,
  0x07, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0xF8, 0x00, 0x60, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0E,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0xF8, 0x30,
  0x00, 0x0F, 0x0C, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07,
  0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x78, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x1F, 0x03,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0x81, 0xF0, 0x00, 0x60, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x06, 0x1E, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x18, 0x1F, 0x80, 0x1F, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF1,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x74, 0x1E, 0xFF,
  0x9F, 0xE0, 0x60, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x01,
  0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x01, 0xC0,
  0x60, 0x07, 0x80, 0xC0, 0x1E, 0x01, 0x80, 0x78, 0x03, 0x01, 0xE0, 0x06,
  0x07, 0x80, 0x0C, 0x1E, 0x00, 0x18, 0x78, 0x00, 0x30, 0xE0, 0x00, 0x63,
  0xC0, 0x00, 0xCF, 0xC0, 0x01, 0xBB, 0xC0, 0x03, 0xE3, 0x80, 0x07, 0x83,
  0x80, 0x0E, 0x07, 0x80, 0x18, 0x07, 0x80, 0x30, 0x07, 0x00, 0x60, 0x07,
  0x00, 0xC0, 0x0F, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x0C, 0x00, 0x1E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0x3D, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFD, 0x80, 0x00, 0x03, 0x7B, 0x80, 0x00, 0x0E, 0xF7, 0x00,
  0x00, 0x19, 0xE7, 0x00, 0x00, 0x73, 0xCE, 0x00, 0x00, 0xE7, 0x8C, 0x00,
  0x01, 0x8F, 0x1C, 0x00, 0x07, 0x1E, 0x38, 0x00, 0x0C, 0x3C, 0x38, 0x00,
  0x38, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x60, 0x00, 0xC1, 0xE0, 0xE0, 0x03,
  0x83, 0xC1, 0xC0, 0x06, 0x07, 0x81, 0xC0, 0x1C, 0x0F, 0x03, 0x80, 0x38,
  0x1E, 0x03, 0x00, 0x60, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x00,
  0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0x1C, 0x1C, 0x03, 0xC0, 0x18, 0x30, 0x07,
  0x80, 0x38, 0xE0, 0x0F, 0x00, 0x71, 0x80, 0x1E, 0x00, 0x67, 0x00, 0x3C,
  0x00, 0xEE, 0x00, 0x78, 0x01, 0xD8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3E, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9C, 0x00, 0x07,
  0xC7, 0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0x38, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x00, 0x1F, 0x01, 0xC0, 0x0F, 0x80, 0xF0,
  0x07, 0xC0, 0x38, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01,
  0xC0, 0x7C, 0x00, 0x70, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0E, 0x0F, 0x80,
  0x03, 0x87, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x71, 0xF0, 0x00, 0x1C, 0xF8,
  0x00, 0x0F, 0x7C, 0x00, 0x03, 0xBE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8C, 0x00, 0x7C, 0xC0, 0x01, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xEC, 0x00, 0x1E, 0xC0, 0x03,
  0xCC, 0x01, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x01, 0xF0, 0xC0, 0x01, 0xE3, 0x00,
  0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C,
  0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x07, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x30, 0x00,
  0x1E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xDF, 0xE3, 0xC0, 0x06, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x80, 0x01,
  0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x3C, 0x00,
  0x06, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x38,
  0x00, 0x66, 0x00, 0x0E, 0x38, 0x00, 0x66, 0x00, 0x0C, 0x38, 0x00, 0xE7,
  0x00, 0x1C, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0x1C, 0x00, 0xC3, 0x00, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x0C, 0x01,
  0xC1, 0x80, 0x38, 0x0E, 0x01, 0x81, 0xC0, 0x30, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x07,
  0x03, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x60, 0xE0, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x01, 0xCC,
  0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1B,
  0x80, 0x00, 0xD8, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x18, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x0E,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x83,
  0x00, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x60, 0x00, 0x31, 0xC0, 0x00, 0x73, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x0C, 0x03, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x0F, 0x08, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x0F, 0x81, 0xFF, 0xF0, 0xFF, 0xC6, 0x7C, 0x00, 0xDE,
  0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1E, 0xE0, 0x06, 0xDE, 0x03, 0x99, 0xFF, 0xE3, 0x0F,
  0xF8, 0x60, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0xFE, 0x0E, 0x7F, 0xF8,
  0x77, 0x01, 0xF3, 0xF0, 0x03, 0x9F, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xDF,
  0x00, 0x0E, 0xF8, 0x00, 0xE6, 0x70, 0x1E, 0x31, 0xFF, 0xE1, 0x87, 0xFE,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xF1, 0xF0, 0x18, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x1C, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x07, 0xFC, 0x70, 0xFF, 0xF3, 0x8F, 0x01, 0xDC, 0xF0,
  0x03, 0x6F, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00,
  0xD8, 0xF0, 0x1C, 0xC3, 0xFF, 0xC6, 0x0F, 0xFC, 0x30, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x1E, 0x03, 0xC3, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x06,
  0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x01, 0x1F, 0x00, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0x03, 0xE3, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7F, 0xF8,
  0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x03, 0xFE, 0x18, 0x7F, 0xF8, 0xC7, 0x80, 0xE6, 0x78, 0x01, 0xB7, 0x80,
  0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x9C, 0x00, 0x7C, 0x78, 0x0E,
  0xE1, 0xFF, 0xE7, 0x07, 0xFE, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0xE3, 0xE0, 0x1E, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x1F, 0xF0, 0xE7, 0xFF, 0xCE, 0xE0, 0x3E, 0xFC, 0x00,
  0xEF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xA3, 0xDF, 0xCF, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xEE, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xCF,
  0x00, 0x39, 0xE0, 0x07, 0x7E, 0x00, 0xFD, 0xE0, 0x1F, 0x1C, 0x03, 0xC1,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00,
  0x38, 0xE0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC3, 0xFE, 0x03, 0xFE, 0x31, 0xFF, 0xC3, 0xFF, 0xCE, 0xE0, 0x79,
  0xC0, 0x7B, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0xC1, 0xFF, 0x0C, 0x7F, 0xFC, 0xEE, 0x03, 0xEF, 0xC0, 0x0E, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x3E, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00,
  0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xF0, 0x03, 0x81, 0xE0, 0x3E, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0xC1, 0xFF, 0x03, 0x1F, 0xFF, 0x0E, 0xE0, 0x3E, 0x3F, 0x00, 0x38, 0xF8,
  0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x1C, 0xF8, 0x00, 0x73, 0xF0, 0x03,
  0x8E, 0xE0, 0x3C, 0x39, 0xFF, 0xE0, 0xE1, 0xFF, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xFE, 0x18, 0x7F, 0xF8, 0xC7, 0x80, 0xE6, 0x78,
  0x01, 0xF7, 0x80, 0x07, 0xB8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x9C, 0x00,
  0xFC, 0x78, 0x0E, 0xE1, 0xFF, 0xE7, 0x07, 0xFC, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0xC1, 0xFF, 0x1F, 0xFE, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0xE3, 0x80, 0x39, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xEE,
  0x00, 0x7B, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xF7, 0x00, 0x3F, 0x7C, 0x07, 0x73,
  0xFF, 0xE3, 0x0F, 0xF8, 0x30, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x67, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x06, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x00, 0xCC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0xE7, 0x00, 0x36, 0x00, 0x73, 0x80,
  0x3B, 0x80, 0x31, 0xC0, 0x1D, 0xC0, 0x38, 0x70, 0x0C, 0x60, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x06, 0x06, 0x03, 0x06, 0x07, 0x03,
  0x83, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xC0, 0x60, 0xC0,
  0x30, 0xE0, 0x30, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0x30, 0x06, 0x30,
  0x03, 0x38, 0x03, 0x18, 0x01, 0x9C, 0x01, 0xDC, 0x00, 0xEC, 0x00, 0xEE,
  0x00, 0x76, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x38, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x83, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x77, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC1,
  0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x38,
  0x00, 0xE1, 0xC0, 0x01, 0x87, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00,
  0x33, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x01, 0xF0, 0x0F,
  0xC0, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xC0,
  0x1F, 0x07, 0xE1, 0xF0, 0x07, 0xFE, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 35, 12, 4, -34 },
  { 19, 11, 13, 17, 3, -34 },
  { 37, 28, 34, 30, 1, -34 },
  { 156, 20, 39, 27, 3, -36 },
  { 254, 33, 34, 38, 3, -34 },
  { 395, 30, 34, 34, 3, -34 },
  { 523, 3, 13, 9, 3, -34 },
  { 528, 10, 41, 13, 2, -34 },
  { 580, 9, 41, 13, 2, -34 },
  { 627, 21, 20, 26, 2, -36 },
  { 680, 22, 23, 27, 2, -28 },
  { 744, 5, 11, 11, 2, -5 },
  { 751, 11, 3, 15, 2, -14 },
  { 756, 4, 5, 11, 4, -4 },
  { 759, 15, 34, 16, 1, -34 },
  { 823, 21, 34, 27, 3, -34 },
  { 913, 11, 34, 27, 5, -34 },
  { 960, 21, 34, 27, 3, -34 },
  { 1050, 22, 34, 27, 2, -34 },
  { 1144, 25, 34, 27, 1, -34 },
  { 1251, 21, 34, 27, 3, -34 },
  { 1341, 21, 34, 27, 3, -34 },
  { 1431, 22, 34, 27, 2, -34 },
  { 1525, 21, 34, 27, 3, -34 },
  { 1615, 22, 35, 27, 2, -34 },
  { 1712, 4, 26, 11, 4, -25 },
  { 1725, 6, 31, 11, 2, -25 },
  { 1749, 22, 22, 27, 2, -28 },
  { 1810, 21, 11, 27, 3, -22 },
  { 1839, 22, 22, 27, 2, -28 },
  { 1900, 17, 35, 20, 1, -34 },
  { 1975, 36, 37, 42, 3, -33 },
  { 2142, 29, 34, 29, 0, -34 },
  { 2266, 22, 34, 30, 5, -34 },
  { 2360, 25, 34, 29, 3, -34 },
  { 2467, 26, 34, 33, 5, -34 },
  { 2578, 18, 34, 26, 5, -34 },
  { 2655, 18, 34, 24, 5, -34 },
  { 2732, 27, 34, 34, 3, -34 },
  { 2847, 24, 34, 34, 5, -34 },
  { 2949, 10, 34, 15, 2, -34 },
  { 2992, 11, 43, 12, -4, -34 },
  { 3052, 23, 34, 28, 5, -34 },
  { 3150, 18, 34, 24, 5, -34 },
  { 3227, 31, 34, 41, 5, -34 },
  { 3359, 25, 34, 34, 5, -34 },
  { 3466, 30, 34, 36, 3, -34 },
  { 3594, 20, 34, 28, 5, -34 },
  { 3679, 30, 42, 36, 3, -34 },
  { 3837, 22, 34, 28, 5, -34 },
  { 3931, 20, 34, 26, 3, -34 },
  { 4016, 25, 34, 25, 0, -34 },
  { 4123, 26, 34, 34, 4, -34 },
  { 4234, 27, 34, 27, 0, -34 },
  { 4349, 40, 34, 42, 1, -34 },
  { 4519, 26, 34, 26, 0, -34 },
  { 4630, 25, 34, 25, 0, -34 },
  { 4737, 23, 34, 27, 2, -34 },
  { 4835, 10, 41, 15, 4, -34 },
  { 4887, 15, 34, 16, 1, -34 },
  { 4951, 10, 41, 15, 1, -34 },
  { 5003, 23, 21, 27, 2, -34 },
  { 5064, 20, 2, 20, 0, 4 },
  { 5069, 9, 8, 12, 2, -36 },
  { 5078, 19, 25, 25, 2, -25 },
  { 5138, 21, 36, 28, 4, -36 },
  { 5233, 18, 25, 22, 3, -25 },
  { 5290, 21, 36, 28, 3, -36 },
  { 5385, 20, 25, 26, 3, -25 },
  { 5448, 16, 36, 15, 1, -36 },
  { 5520, 21, 36, 28, 3, -25 },
  { 5615, 20, 36, 28, 4, -36 },
  { 5705, 3, 34, 11, 4, -34 },
  { 5718, 9, 45, 11, -2, -34 },
  { 5769, 19, 36, 23, 4, -36 },
  { 5855, 3, 36, 11, 4, -36 },
  { 5869, 34, 25, 42, 4, -25 },
  { 5976, 20, 25, 28, 4, -25 },
  { 6039, 22, 25, 28, 3, -25 },
  { 6108, 22, 36, 28, 4, -25 },
  { 6207, 21, 36, 28, 3, -25 },
  { 6302, 14, 25, 19, 4, -25 },
  { 6346, 18, 25, 22, 2, -25 },
  { 6403, 14, 31, 16, 1, -31 },
  { 6458, 20, 25, 28, 4, -25 },
  { 6521, 22, 25, 22, 0, -25 },
  { 6590, 33, 25, 35, 1, -25 },
  { 6694, 22, 25, 24, 1, -25 },
  { 6763, 22, 36, 22, 0, -25 },
  { 6862, 18, 25, 22, 2, -25 },
  { 6919, 14, 41, 17, 1, -34 },
  { 6991, 2, 48, 26, 12, -36 },
  { 7003, 14, 41, 17, 2, -34 },
  { 7075, 22, 5, 27, 2, -19 },
};

const GFXfont NotoSans_Light47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light47pt7bBitmaps,
  (GFXglyph *)NotoSans_Light47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_LIGHT47PT7B_H_
