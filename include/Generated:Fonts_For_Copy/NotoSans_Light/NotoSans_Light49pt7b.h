#ifndef _NOTOSANS_LIGHT49PT7B_H_
#define _NOTOSANS_LIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x0F, 0xFF, 0xF6, 0xE0, 0xFC, 0x0F, 0x81, 0xB0,
  0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x06, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0xF1, 0xC3, 0x8E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x0F,
  0x0E, 0x00, 0x3E, 0x70, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3B, 0xF0, 0x01, 0xC7, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x1C, 0x01, 0xC1, 0xD0, 0x0E, 0x1E, 0xF8, 0x73, 0xE7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x0F, 0xF8, 0x00,
  0x38, 0x07, 0x07, 0x00, 0x0E, 0x01, 0x80, 0xC0, 0x07, 0x00, 0xE0, 0x38,
  0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30, 0x07, 0x03, 0x80, 0x0C,
  0x01, 0xC0, 0xC0, 0x03, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x1C, 0x38, 0x00,
  0x30, 0x06, 0x0C, 0x00, 0x0C, 0x01, 0x87, 0x0F, 0xE3, 0x80, 0x61, 0x87,
  0xFC, 0xE0, 0x38, 0xE3, 0x87, 0x18, 0x0C, 0x31, 0xC0, 0xE7, 0x07, 0x1C,
  0x70, 0x18, 0xFF, 0x86, 0x18, 0x07, 0x1F, 0xC3, 0x8E, 0x01, 0xC0, 0x01,
  0xC3, 0x80, 0x30, 0x00, 0x60, 0xE0, 0x0C, 0x00, 0x38, 0x38, 0x03, 0x00,
  0x0C, 0x0E, 0x00, 0xC0, 0x07, 0x03, 0x80, 0x30, 0x01, 0x80, 0xE0, 0x0C,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x70, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x03,
  0x87, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0xE3, 0xC0, 0xF0, 0x01, 0x8F, 0x00, 0xF0, 0x07, 0x1C,
  0x00, 0xF0, 0x0E, 0x78, 0x00, 0xF0, 0x38, 0xE0, 0x00, 0xF0, 0x71, 0xC0,
  0x00, 0xF1, 0xC3, 0x80, 0x00, 0xF3, 0x87, 0x00, 0x00, 0xFE, 0x0E, 0x00,
  0x00, 0xFC, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x0F, 0xF0, 0x7C, 0x00, 0x7C, 0xF0, 0x7E, 0x03, 0xE0, 0xF0, 0x7F, 0xFF,
  0x80, 0xF0, 0x3F, 0xFC, 0x00, 0xF0, 0xFF, 0xB6, 0xDB, 0x6D, 0xB6, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x0C, 0x07, 0xFC, 0x61, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0x03, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x77, 0x1E, 0x73, 0xC7, 0x78, 0x7E,
  0x07, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xE0, 0x7C, 0x3C, 0x00, 0x78, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xC1, 0xF8, 0x07, 0xC3, 0xC0, 0x03, 0x82, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x60, 0x00, 0x3C, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03,
  0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x7F, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3C, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x78, 0xF8, 0x07,
  0xE3, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xF8, 0x04, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x03, 0xE0,
  0x38, 0x7F, 0xF0, 0xE7, 0xFF, 0xE3, 0xBC, 0x03, 0xCF, 0xC0, 0x07, 0xBE,
  0x00, 0x0E, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x1E,
  0x00, 0x70, 0x3E, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x1E, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0xE0, 0x78, 0x07, 0x00, 0x78, 0x78, 0x00, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x78, 0x38, 0x00,
  0xF1, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x77, 0x00, 0x03, 0x9E, 0x00, 0x1C, 0x3E, 0x01, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3C,
  0x0E, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x70, 0x00, 0x7D, 0xE0, 0x03, 0xF3, 0xC0, 0x3D, 0xC7, 0xFF, 0xE7, 0x0F,
  0xFE, 0x1C, 0x03, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x40, 0x1F, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x4F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF6, 0x10, 0xF3, 0xCF,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x38, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0x87, 0x80, 0xF1, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x0F, 0xFC, 0x03, 0x8C, 0x00, 0xFF, 0xF8, 0x0E, 0x70, 0x07, 0x80,
  0xE0, 0x19, 0x80, 0x38, 0x03, 0x80, 0x6E, 0x01, 0xC0, 0x0E, 0x01, 0xF8,
  0x07, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x03,
  0x80, 0x7C, 0x03, 0x00, 0x0E, 0x01, 0xF0, 0x0C, 0x00, 0x38, 0x07, 0xC0,
  0x30, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x03, 0x00, 0x0C,
  0x01, 0xB0, 0x0E, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x01, 0xE0, 0x3B, 0x80,
  0xE0, 0x0D, 0x80, 0xCE, 0x01, 0xC0, 0x76, 0x07, 0x38, 0x03, 0xEF, 0x9F,
  0xF8, 0x60, 0x07, 0xFC, 0x3F, 0xC1, 0xC0, 0x07, 0x80, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0x00, 0x07, 0xCE, 0x00, 0x03,
  0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C,
  0x00, 0x0F, 0x38, 0x00, 0x3C, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC3, 0x80, 0x07, 0xC7, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0x70, 0x00, 0x7C, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80,
  0x7C, 0x0F, 0x00, 0x02, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x7C, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0x02, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xCF, 0xFC, 0xFF, 0x8F, 0xC0, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE1,
  0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xEF, 0xC0, 0x00, 0xFC,
  0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x03, 0xFD, 0xC0, 0x00,
  0x01, 0xBF, 0x60, 0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00, 0xEF, 0xDC, 0x00,
  0x00, 0x67, 0xE7, 0x00, 0x00, 0x73, 0xF3, 0x80, 0x00, 0x39, 0xF9, 0xC0,
  0x00, 0x38, 0xFC, 0x70, 0x00, 0x1C, 0x7E, 0x38, 0x00, 0x0C, 0x3F, 0x0E,
  0x00, 0x0E, 0x1F, 0x87, 0x00, 0x07, 0x0F, 0xC3, 0x80, 0x07, 0x07, 0xE0,
  0xE0, 0x03, 0x83, 0xF0, 0x70, 0x01, 0x81, 0xF8, 0x18, 0x01, 0xC0, 0xFC,
  0x0E, 0x00, 0xE0, 0x7E, 0x07, 0x00, 0xE0, 0x3F, 0x01, 0xC0, 0x70, 0x1F,
  0x80, 0xE0, 0x30, 0x0F, 0xC0, 0x30, 0x38, 0x07, 0xE0, 0x1C, 0x1C, 0x03,
  0xF0, 0x0E, 0x1C, 0x01, 0xF8, 0x03, 0x8E, 0x00, 0xFC, 0x01, 0xC6, 0x00,
  0x7E, 0x00, 0x67, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xE7, 0x80, 0x01, 0xF8,
  0xE0, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0x87, 0x80, 0x07, 0xE0, 0xE0, 0x01,
  0xF8, 0x1C, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x3C,
  0x01, 0xF8, 0x07, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x1C, 0x07, 0xE0,
  0x07, 0x81, 0xF8, 0x00, 0xE0, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x87,
  0xE0, 0x00, 0xE1, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0x9F, 0x80, 0x00,
  0xE7, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xC0, 0x07, 0xCE, 0x00,
  0x0F, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x01, 0xE7, 0x00, 0x3E, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0xE0, 0x03, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x38, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0x8F, 0xC0, 0x7C, 0x78, 0x00, 0x27, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xD0, 0x00, 0x3C, 0xF8, 0x07, 0xE7,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x1F, 0x80, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x77, 0x00,
  0x01, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x8E, 0x00, 0x0D, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x30, 0x00,
  0x70, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x38, 0x00, 0x73, 0x80, 0x07, 0x07,
  0x00, 0x18, 0xE0, 0x01, 0x81, 0xC0, 0x0E, 0x18, 0x00, 0xE0, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0x30, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x06, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x00, 0x70,
  0x38, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x0D, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x10, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xC1, 0xE0, 0x1E, 0x08, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0x80,
  0x73, 0xC0, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x70, 0x01, 0xF7, 0x00, 0x3B, 0x7C,
  0x07, 0x33, 0xFF, 0xE3, 0x0F, 0xF8, 0x30, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x60, 0x07, 0x0F, 0xFC, 0x0E, 0x7F, 0xFC, 0x1D, 0xE0, 0x3C, 0x3B,
  0x00, 0x1C, 0x7C, 0x00, 0x1C, 0xF8, 0x00, 0x39, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1C, 0xF8, 0x00, 0x79, 0xD8, 0x01, 0xE3, 0xBC, 0x07, 0x87,
  0x3F, 0xFE, 0x0C, 0x1F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF8, 0x1F,
  0xFF, 0x87, 0xC0, 0x61, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x03, 0x01, 0xC0, 0xFF, 0xC7, 0x0F, 0xFF, 0x9C, 0x7C,
  0x07, 0x73, 0xC0, 0x0F, 0xCE, 0x00, 0x1F, 0x70, 0x00, 0x3D, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x78, 0x00, 0x7C, 0xF0, 0x03, 0xB1, 0xF0, 0x1C, 0xC3,
  0xFF, 0xE3, 0x03, 0xFE, 0x0C, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x02, 0x1F, 0x80, 0x70, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x20, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0xC0, 0x73, 0x3C, 0x00,
  0xFC, 0xE0, 0x01, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF3,
  0x80, 0x07, 0xCF, 0x00, 0x3F, 0x1F, 0x03, 0xDC, 0x3F, 0xFE, 0x70, 0x3F,
  0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE4, 0x00, 0x07, 0x0E,
  0x00, 0x7C, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x06, 0x01, 0xC3, 0xFF, 0x0E, 0x7F, 0xFE, 0x77, 0x80, 0xF3,
  0xB0, 0x01, 0xDF, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0x80, 0x6F, 0xFE, 0x40, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x39, 0xFF, 0x3F, 0xC1,
  0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x38,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x0E, 0xFC,
  0x00, 0xED, 0xE0, 0x0F, 0x8E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0x80, 0xE0,
  0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0x30, 0x0E, 0x1F, 0xF0, 0x1F, 0xF0, 0xE7, 0xFF, 0x87,
  0xFF, 0x8E, 0xE0, 0x3C, 0xF0, 0x3C, 0xFC, 0x01, 0xDC, 0x01, 0xEF, 0x80,
  0x0F, 0x80, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0x6F, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07,
  0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07,
  0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x18, 0x07, 0x0F, 0xFC, 0x39, 0xFF, 0xF9, 0xDE, 0x03,
  0xCE, 0xC0, 0x07, 0x7C, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x0F,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0F, 0x01,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xC3, 0xFF,
  0x03, 0x8F, 0xFF, 0x07, 0x38, 0x0F, 0x8E, 0xC0, 0x07, 0x1F, 0x00, 0x07,
  0x3E, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0x3E, 0x00,
  0x1E, 0x76, 0x00, 0x78, 0xEF, 0x01, 0xE1, 0xCF, 0xFF, 0x83, 0x87, 0xFE,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0xC0, 0x73, 0x3C,
  0x00, 0xFC, 0xE0, 0x01, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x07, 0xCF, 0x00, 0x3F, 0x1E, 0x03, 0xDC, 0x3F, 0xFE, 0x70,
  0x3F, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x11, 0xC3, 0xFF, 0x9F, 0xF7, 0x38, 0x0E, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1E, 0x00,
  0xE7, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x74, 0x00, 0x0E,
  0xF0, 0x07, 0x9F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x10, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xB8,
  0x00, 0x7D, 0xE0, 0x06, 0xE7, 0x80, 0xF7, 0x1F, 0xFF, 0x38, 0x7F, 0xE0,
  0xC0, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x1D, 0xC0, 0x07, 0xC0, 0x06, 0x70, 0x03, 0xB0,
  0x03, 0x9C, 0x00, 0xEC, 0x00, 0xE3, 0x00, 0x33, 0x80, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0x38, 0x07, 0x18, 0x07, 0x0E, 0x01, 0x87, 0x01, 0xC1, 0x80,
  0xE1, 0xC0, 0x70, 0x70, 0x38, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x03,
  0x07, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x60, 0xC0, 0x38, 0x60, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x39,
  0x80, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xDC, 0x00,
  0x6E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x70, 0x00,
  0x70, 0xF0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x38,
  0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xF0, 0x0F, 0xC0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1F, 0x3F, 0xC1,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 36, 12, 4, -35 },
  { 19, 11, 13, 18, 3, -35 },
  { 37, 29, 35, 32, 1, -35 },
  { 164, 21, 40, 28, 3, -37 },
  { 269, 34, 35, 40, 3, -35 },
  { 418, 31, 36, 35, 3, -36 },
  { 558, 3, 13, 10, 3, -35 },
  { 563, 10, 43, 14, 2, -35 },
  { 617, 10, 43, 14, 2, -35 },
  { 671, 21, 21, 27, 3, -37 },
  { 727, 22, 23, 28, 3, -29 },
  { 791, 6, 12, 11, 2, -6 },
  { 800, 12, 3, 16, 2, -15 },
  { 805, 4, 5, 12, 4, -4 },
  { 808, 15, 35, 17, 1, -35 },
  { 874, 22, 36, 28, 3, -36 },
  { 973, 12, 35, 28, 5, -35 },
  { 1026, 22, 35, 28, 3, -35 },
  { 1123, 23, 35, 28, 2, -35 },
  { 1224, 26, 35, 28, 1, -35 },
  { 1338, 22, 35, 28, 3, -35 },
  { 1435, 22, 36, 28, 3, -36 },
  { 1534, 23, 35, 28, 2, -35 },
  { 1635, 22, 35, 28, 3, -35 },
  { 1732, 22, 36, 28, 3, -35 },
  { 1831, 4, 28, 12, 4, -27 },
  { 1845, 6, 33, 12, 2, -27 },
  { 1870, 22, 23, 28, 3, -29 },
  { 1934, 22, 12, 28, 3, -23 },
  { 1967, 22, 23, 28, 3, -29 },
  { 2031, 18, 36, 21, 1, -35 },
  { 2112, 38, 40, 44, 3, -35 },
  { 2302, 30, 35, 30, 0, -35 },
  { 2434, 23, 35, 31, 5, -35 },
  { 2535, 26, 35, 31, 3, -35 },
  { 2649, 27, 35, 35, 5, -35 },
  { 2768, 19, 35, 27, 5, -35 },
  { 2852, 19, 35, 25, 5, -35 },
  { 2936, 29, 36, 35, 3, -36 },
  { 3067, 26, 35, 35, 5, -35 },
  { 3181, 11, 35, 15, 2, -35 },
  { 3230, 12, 44, 12, -4, -35 },
  { 3296, 24, 35, 29, 5, -35 },
  { 3401, 19, 35, 25, 5, -35 },
  { 3485, 33, 35, 43, 5, -35 },
  { 3630, 26, 35, 36, 5, -35 },
  { 3744, 32, 36, 38, 3, -36 },
  { 3888, 21, 35, 29, 5, -35 },
  { 3980, 32, 44, 38, 3, -36 },
  { 4156, 23, 35, 29, 5, -35 },
  { 4257, 21, 35, 27, 3, -35 },
  { 4349, 26, 35, 26, 0, -35 },
  { 4463, 26, 35, 35, 5, -35 },
  { 4577, 29, 35, 29, 0, -35 },
  { 4704, 42, 35, 44, 1, -35 },
  { 4888, 27, 35, 27, 0, -35 },
  { 5007, 26, 35, 26, 0, -35 },
  { 5121, 24, 35, 28, 2, -35 },
  { 5226, 11, 43, 16, 4, -35 },
  { 5286, 15, 35, 17, 1, -35 },
  { 5352, 11, 43, 16, 1, -35 },
  { 5412, 24, 22, 28, 2, -35 },
  { 5478, 21, 3, 20, 0, 4 },
  { 5486, 9, 8, 13, 2, -38 },
  { 5495, 20, 27, 26, 2, -27 },
  { 5563, 23, 37, 29, 4, -37 },
  { 5670, 19, 27, 23, 3, -27 },
  { 5735, 22, 37, 29, 3, -37 },
  { 5837, 21, 27, 27, 3, -27 },
  { 5908, 17, 37, 15, 1, -37 },
  { 5987, 22, 39, 29, 3, -27 },
  { 6095, 21, 37, 29, 4, -37 },
  { 6193, 4, 36, 11, 4, -36 },
  { 6211, 11, 48, 11, -3, -36 },
  { 6277, 20, 37, 24, 4, -37 },
  { 6370, 3, 37, 11, 4, -37 },
  { 6384, 36, 27, 44, 4, -27 },
  { 6506, 21, 27, 29, 4, -27 },
  { 6577, 23, 27, 29, 3, -27 },
  { 6655, 23, 39, 29, 4, -27 },
  { 6768, 22, 39, 29, 3, -27 },
  { 6876, 15, 27, 19, 4, -27 },
  { 6927, 19, 27, 23, 2, -27 },
  { 6992, 14, 32, 17, 1, -32 },
  { 7048, 21, 26, 29, 4, -26 },
  { 7117, 23, 26, 23, 0, -26 },
  { 7192, 34, 26, 36, 1, -26 },
  { 7303, 23, 26, 25, 1, -26 },
  { 7378, 23, 38, 23, 0, -26 },
  { 7488, 19, 26, 23, 2, -26 },
  { 7550, 15, 43, 18, 1, -35 },
  { 7631, 2, 49, 27, 12, -37 },
  { 7644, 14, 43, 18, 2, -35 },
  { 7720, 22, 5, 28, 3, -20 },
};

const GFXfont NotoSans_Light49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Light49pt7bBitmaps,
  (GFXglyph *)NotoSans_Light49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_LIGHT49PT7B_H_
