#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_Light6pt7b, 6, "NotoSans_Light6pt7b" },
  { &NotoSans_Light7pt7b, 7, "NotoSans_Light7pt7b" },
  { &NotoSans_Light8pt7b, 8, "NotoSans_Light8pt7b" },
  { &NotoSans_Light9pt7b, 9, "NotoSans_Light9pt7b" },
  { &NotoSans_Light10pt7b, 10, "NotoSans_Light10pt7b" },
  { &NotoSans_Light11pt7b, 11, "NotoSans_Light11pt7b" },
  { &NotoSans_Light12pt7b, 12, "NotoSans_Light12pt7b" },
  { &NotoSans_Light13pt7b, 13, "NotoSans_Light13pt7b" },
  { &NotoSans_Light14pt7b, 14, "NotoSans_Light14pt7b" },
  { &NotoSans_Light15pt7b, 15, "NotoSans_Light15pt7b" },
  { &NotoSans_Light16pt7b, 16, "NotoSans_Light16pt7b" },
  { &NotoSans_Light17pt7b, 17, "NotoSans_Light17pt7b" },
  { &NotoSans_Light18pt7b, 18, "NotoSans_Light18pt7b" },
  { &NotoSans_Light19pt7b, 19, "NotoSans_Light19pt7b" },
  { &NotoSans_Light20pt7b, 20, "NotoSans_Light20pt7b" },
  { &NotoSans_Light21pt7b, 21, "NotoSans_Light21pt7b" },
  { &NotoSans_Light22pt7b, 22, "NotoSans_Light22pt7b" },
  { &NotoSans_Light23pt7b, 23, "NotoSans_Light23pt7b" },
  { &NotoSans_Light24pt7b, 24, "NotoSans_Light24pt7b" },
  { &NotoSans_Light25pt7b, 25, "NotoSans_Light25pt7b" },
  { &NotoSans_Light26pt7b, 26, "NotoSans_Light26pt7b" },
  { &NotoSans_Light27pt7b, 27, "NotoSans_Light27pt7b" },
  { &NotoSans_Light28pt7b, 28, "NotoSans_Light28pt7b" },
  { &NotoSans_Light29pt7b, 29, "NotoSans_Light29pt7b" },
  { &NotoSans_Light30pt7b, 30, "NotoSans_Light30pt7b" },
  { &NotoSans_Light31pt7b, 31, "NotoSans_Light31pt7b" },
  { &NotoSans_Light32pt7b, 32, "NotoSans_Light32pt7b" },
  { &NotoSans_Light33pt7b, 33, "NotoSans_Light33pt7b" },
  { &NotoSans_Light34pt7b, 34, "NotoSans_Light34pt7b" },
  { &NotoSans_Light35pt7b, 35, "NotoSans_Light35pt7b" },
  { &NotoSans_Light36pt7b, 36, "NotoSans_Light36pt7b" },
  { &NotoSans_Light37pt7b, 37, "NotoSans_Light37pt7b" },
  { &NotoSans_Light38pt7b, 38, "NotoSans_Light38pt7b" },
  { &NotoSans_Light39pt7b, 39, "NotoSans_Light39pt7b" },
  { &NotoSans_Light40pt7b, 40, "NotoSans_Light40pt7b" },
  { &NotoSans_Light41pt7b, 41, "NotoSans_Light41pt7b" },
  { &NotoSans_Light42pt7b, 42, "NotoSans_Light42pt7b" },
  { &NotoSans_Light43pt7b, 43, "NotoSans_Light43pt7b" },
  { &NotoSans_Light44pt7b, 44, "NotoSans_Light44pt7b" },
  { &NotoSans_Light45pt7b, 45, "NotoSans_Light45pt7b" },
  { &NotoSans_Light46pt7b, 46, "NotoSans_Light46pt7b" },
  { &NotoSans_Light47pt7b, 47, "NotoSans_Light47pt7b" },
  { &NotoSans_Light48pt7b, 48, "NotoSans_Light48pt7b" },
  { &NotoSans_Light49pt7b, 49, "NotoSans_Light49pt7b" },
  { &NotoSans_Light50pt7b, 50, "NotoSans_Light50pt7b" },
  { &NotoSans_Light51pt7b, 51, "NotoSans_Light51pt7b" },
  { &NotoSans_Light52pt7b, 52, "NotoSans_Light52pt7b" },
  { &NotoSans_Light53pt7b, 53, "NotoSans_Light53pt7b" },
  { &NotoSans_Light54pt7b, 54, "NotoSans_Light54pt7b" },
  { &NotoSans_Light55pt7b, 55, "NotoSans_Light55pt7b" },
  { &NotoSans_Light56pt7b, 56, "NotoSans_Light56pt7b" },
  { &NotoSans_Light57pt7b, 57, "NotoSans_Light57pt7b" },
  { &NotoSans_Light58pt7b, 58, "NotoSans_Light58pt7b" },
  { &NotoSans_Light59pt7b, 59, "NotoSans_Light59pt7b" },
  { &NotoSans_Light60pt7b, 60, "NotoSans_Light60pt7b" },
  { &NotoSans_Light61pt7b, 61, "NotoSans_Light61pt7b" },
  { &NotoSans_Light62pt7b, 62, "NotoSans_Light62pt7b" },
  { &NotoSans_Light63pt7b, 63, "NotoSans_Light63pt7b" },
  { &NotoSans_Light64pt7b, 64, "NotoSans_Light64pt7b" },
  { &NotoSans_Light65pt7b, 65, "NotoSans_Light65pt7b" },
  { &NotoSans_Light66pt7b, 66, "NotoSans_Light66pt7b" },
  { &NotoSans_Light67pt7b, 67, "NotoSans_Light67pt7b" },
  { &NotoSans_Light68pt7b, 68, "NotoSans_Light68pt7b" },
  { &NotoSans_Light69pt7b, 69, "NotoSans_Light69pt7b" },
  { &NotoSans_Light70pt7b, 70, "NotoSans_Light70pt7b" },
  { &NotoSans_Light71pt7b, 71, "NotoSans_Light71pt7b" },
  { &NotoSans_Light72pt7b, 72, "NotoSans_Light72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
