#ifndef _IBMPLEXMONO_EXTRALIGHT40PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x44, 0x00,
  0x00, 0x06, 0xF6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x00, 0x60, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20,
  0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20, 0x60, 0x00,
  0x81, 0x00, 0x02, 0x04, 0x07, 0xF8, 0x1F, 0xC0, 0x60, 0xC0, 0x01, 0x03,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x03,
  0xFC, 0x1F, 0xE0, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x18,
  0x10, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20,
  0x00, 0x40, 0x80, 0x03, 0x06, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1C, 0x47, 0x06, 0x08, 0x31, 0x81,
  0x03, 0x20, 0x20, 0x4C, 0x04, 0x01, 0x80, 0x80, 0x30, 0x10, 0x06, 0x02,
  0x00, 0x40, 0x40, 0x0C, 0x08, 0x00, 0xC1, 0x00, 0x0E, 0x20, 0x00, 0x7F,
  0x00, 0x00, 0xBC, 0x00, 0x10, 0xC0, 0x02, 0x0C, 0x00, 0x40, 0xC0, 0x08,
  0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x80, 0xA0, 0x10,
  0x3E, 0x02, 0x04, 0x60, 0x41, 0x87, 0x88, 0xC0, 0x1F, 0xE0, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x0C, 0xC3,
  0x00, 0x26, 0x06, 0x01, 0x90, 0x08, 0x04, 0xC0, 0x20, 0x23, 0x00, 0x81,
  0x8C, 0x03, 0x04, 0x30, 0x08, 0x30, 0xC0, 0x20, 0x81, 0x00, 0x84, 0x06,
  0x06, 0x10, 0x0C, 0x30, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0x0C, 0x30, 0x08, 0x60, 0x60, 0x21, 0x00,
  0x81, 0x04, 0x03, 0x0C, 0x10, 0x0C, 0x20, 0xC0, 0x31, 0x81, 0x00, 0xC4,
  0x04, 0x03, 0x20, 0x10, 0x09, 0x80, 0x60, 0x64, 0x00, 0xC3, 0x30, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xA0, 0x00,
  0x31, 0x01, 0xF6, 0x08, 0x18, 0x40, 0xC1, 0x8C, 0x06, 0x10, 0x80, 0x31,
  0x08, 0x01, 0x90, 0x80, 0x0D, 0x08, 0x00, 0x50, 0x80, 0x06, 0x08, 0x00,
  0x50, 0xC0, 0x05, 0x86, 0x00, 0x8C, 0x38, 0x30, 0x60, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x06, 0x03, 0x7C, 0x63, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x20, 0x40,
  0x04, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x39, 0x8C,
  0xE6, 0x31, 0x88, 0xC6, 0x20, 0xFF, 0xC0, 0x6F, 0x60, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0x03, 0x01, 0x80, 0x60, 0x80, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00,
  0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00,
  0x09, 0x80, 0x06, 0x20, 0x03, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0x03, 0x03,
  0x00, 0x61, 0x80, 0x0C, 0x40, 0x01, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xF0,
  0x0C, 0x0E, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x02, 0xC0, 0x03, 0x30, 0x03, 0x0E, 0x07, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x01, 0xB0, 0x00, 0x13, 0x00, 0x02,
  0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x03, 0x00, 0x20, 0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x08, 0x03, 0x01,
  0x80, 0x30, 0x10, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30,
  0x80, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x7F, 0x02, 0xC0, 0xC3,
  0x80, 0x19, 0x80, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x80, 0x03, 0xC0,
  0x01, 0x18, 0x01, 0x07, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x8F, 0xC0, 0x4C,
  0x0C, 0x14, 0x00, 0xC6, 0x00, 0x13, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00,
  0xC8, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x07, 0xF8, 0x07, 0x03, 0x83, 0x00, 0x31, 0x80, 0x06, 0x60,
  0x01, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00,
  0x62, 0x00, 0x10, 0xC0, 0x0C, 0x0C, 0x0C, 0x00, 0xFC, 0x01, 0xC0, 0xE0,
  0xC0, 0x0C, 0x40, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x40, 0x01, 0x8C, 0x00,
  0xC1, 0xC0, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x30,
  0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0xC8, 0x00,
  0x73, 0x00, 0x28, 0x30, 0x32, 0x03, 0xF1, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x6F, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x67, 0x31, 0x8C, 0x46, 0x31,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x60, 0x02, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x06,
  0x06, 0x06, 0x01, 0x82, 0x00, 0x62, 0x00, 0x11, 0x00, 0x09, 0x80, 0x06,
  0x80, 0x01, 0x40, 0x7C, 0xA0, 0x61, 0x50, 0x40, 0x68, 0x60, 0x34, 0x20,
  0x0E, 0x10, 0x07, 0x08, 0x03, 0x84, 0x01, 0xC2, 0x00, 0xE1, 0x00, 0x70,
  0x80, 0x28, 0x40, 0x14, 0x30, 0x0A, 0x08, 0x0D, 0x06, 0x0A, 0x81, 0xF9,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x03, 0x0C, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0x60, 0x04,
  0x02, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x01, 0x01,
  0x80, 0x18, 0x1F, 0xFF, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x20, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x40, 0x0E, 0x20, 0x01, 0x10, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01,
  0x20, 0x01, 0x90, 0x00, 0x88, 0x01, 0x87, 0xFF, 0x82, 0x00, 0x31, 0x00,
  0x04, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x03,
  0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0x81, 0x81, 0x80, 0x30, 0x40, 0x06,
  0x20, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x03, 0x30, 0x01, 0x86,
  0x00, 0xC0, 0x60, 0x60, 0x07, 0xE0, 0xFF, 0xE0, 0x60, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60,
  0x06, 0x30, 0x06, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFB,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFB,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x83, 0x01, 0x80,
  0x30, 0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x24, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0C, 0x80, 0x07,
  0x30, 0x01, 0xC6, 0x00, 0xB0, 0xC0, 0xCC, 0x0F, 0xC3, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0xC0, 0x0C,
  0xC0, 0x30, 0xC0, 0xC0, 0x7E, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00,
  0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x33,
  0x60, 0x0D, 0x88, 0x03, 0x43, 0x00, 0xE0, 0x60, 0x38, 0x08, 0x0C, 0x03,
  0x03, 0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x08,
  0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07,
  0xFF, 0xF0, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xD0,
  0x02, 0xF6, 0x01, 0xBC, 0x80, 0x4F, 0x30, 0x33, 0xC4, 0x08, 0xF1, 0x02,
  0x3C, 0x61, 0x0F, 0x08, 0x43, 0xC3, 0x30, 0xF0, 0x48, 0x3C, 0x1E, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x20, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0xB0,
  0x01, 0x90, 0x01, 0x98, 0x01, 0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x86,
  0x01, 0x86, 0x01, 0x83, 0x01, 0x83, 0x01, 0x81, 0x81, 0x81, 0x81, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x61, 0x80, 0x21, 0x80, 0x31, 0x80,
  0x11, 0x80, 0x19, 0x80, 0x09, 0x80, 0x0D, 0x80, 0x05, 0x80, 0x07, 0x80,
  0x03, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x60, 0x80, 0x0C, 0x60, 0x01,
  0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xD0, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x03, 0x04, 0x00, 0x80,
  0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xF8, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00,
  0x2C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x33, 0xFF, 0xE1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x60, 0x80,
  0x0C, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x03,
  0x04, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x60, 0x03, 0x30,
  0x00, 0xD8, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x36, 0x00,
  0x33, 0xFF, 0xE1, 0x81, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x08, 0x18,
  0x06, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x06,
  0x60, 0x01, 0xB0, 0x00, 0x58, 0x00, 0x30, 0x03, 0xFC, 0x01, 0xC0, 0x70,
  0x60, 0x03, 0x18, 0x00, 0x36, 0x00, 0x04, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x0A, 0x00, 0x03, 0xE0, 0x00, 0x46, 0x00, 0x10, 0x78, 0x0C, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x38,
  0x1C, 0x0F, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x10,
  0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x02, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x98,
  0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x60, 0x24,
  0x06, 0x02, 0x40, 0xF0, 0x24, 0x09, 0x02, 0x60, 0x90, 0x66, 0x09, 0x06,
  0x61, 0x98, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x23, 0x0C,
  0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x60, 0x64, 0x36, 0x02, 0x43, 0x40,
  0x2C, 0x34, 0x02, 0xC3, 0xC0, 0x3C, 0x18, 0x01, 0x81, 0x80, 0x18, 0xC0,
  0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80,
  0x80, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x30, 0xC0,
  0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00, 0x60,
  0x60, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x00, 0x08, 0x30,
  0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60,
  0x01, 0x80, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x12,
  0x00, 0x0C, 0xC0, 0x02, 0x10, 0x01, 0x06, 0x00, 0xC0, 0xC0, 0x20, 0x10,
  0x18, 0x06, 0x04, 0x00, 0x83, 0x00, 0x31, 0x80, 0x06, 0x40, 0x00, 0xB0,
  0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0x86, 0x18, 0x41, 0x0C, 0x20,
  0x07, 0xE0, 0x06, 0x06, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0xFF,
  0xE0, 0xC0, 0x08, 0x60, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x08,
  0xC0, 0x06, 0x30, 0x02, 0x84, 0x00, 0xA0, 0xC0, 0xC8, 0x0F, 0xC3, 0xC0,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x98, 0x38, 0xA0, 0x0C,
  0xC0, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x06, 0xC0, 0x04, 0xA0, 0x0C, 0x98, 0x38, 0x87, 0xE0,
  0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x06, 0x20, 0x03, 0x60, 0x01, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x01, 0x20, 0x03,
  0x10, 0x06, 0x0C, 0x0C, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x07, 0xE1, 0x1C, 0x19, 0x30, 0x05, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20, 0x03,
  0x30, 0x05, 0x1C, 0x19, 0x07, 0xE1, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80,
  0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x8C, 0x00, 0x61, 0x80,
  0x30, 0x30, 0x38, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x80, 0x30, 0x30, 0x0C, 0x03, 0x01,
  0x00, 0x20, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x06,
  0x00, 0x20, 0xC0, 0x04, 0x08, 0x01, 0x80, 0x80, 0x60, 0x08, 0x18, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xF0, 0x60, 0x03, 0x98, 0x00, 0x12, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x63, 0x80, 0x38, 0x0F,
  0xF8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xC2, 0x60, 0xC5, 0x00,
  0x4C, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0B, 0xFF, 0xE0, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x30, 0xC0, 0x18, 0x30, 0x08, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00,
  0x31, 0xC0, 0x0C, 0xD0, 0x03, 0x66, 0x00, 0xF0, 0xC0, 0x30, 0x18, 0x0C,
  0x03, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x01, 0x30, 0x00, 0x70, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x9E, 0x0F, 0x28, 0x44, 0x6C, 0x0A,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x87, 0xE1, 0x30, 0x62, 0x80, 0x26,
  0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x03, 0xF0,
  0x03, 0x03, 0x01, 0x80, 0x20, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01,
  0x8C, 0x00, 0xC1, 0x00, 0x20, 0x30, 0x30, 0x03, 0xF0, 0x00, 0x87, 0xE0,
  0x98, 0x38, 0xA0, 0x0C, 0xC0, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x04, 0xA0, 0x0C,
  0x98, 0x38, 0x87, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE1, 0x1C, 0x19,
  0x30, 0x05, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20, 0x03, 0x30, 0x05, 0x1C, 0x19,
  0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x22, 0x00, 0x04,
  0x80, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0x03,
  0x83, 0x00, 0x30, 0x80, 0x02, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x40, 0x00, 0xF8, 0x00,
  0x23, 0x00, 0x18, 0x70, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0xC0, 0x0C, 0x80, 0x28, 0xC1, 0x90, 0xFE, 0x20, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x18, 0x80, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC1,
  0x00, 0x20, 0x60, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x03, 0x30,
  0x00, 0x48, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x0D, 0x00, 0xC0, 0x24, 0x03, 0x80, 0x90, 0x12, 0x02, 0x60, 0x48, 0x09,
  0x81, 0x20, 0x62, 0x04, 0x81, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x43, 0x08, 0x41, 0x0C, 0x60, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x22, 0x04, 0xC0, 0x48, 0x1A, 0x01, 0x60, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0xE0, 0x00, 0xC8, 0x00,
  0x43, 0x00, 0x30, 0x60, 0x18, 0x08, 0x04, 0x03, 0x03, 0x00, 0x61, 0x80,
  0x0C, 0xC0, 0x01, 0x20, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01,
  0x20, 0x00, 0xCC, 0x00, 0x61, 0x80, 0x30, 0x30, 0x08, 0x04, 0x06, 0x01,
  0x83, 0x00, 0x31, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xD0, 0x00,
  0x26, 0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x20,
  0x60, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x20, 0x06,
  0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x78,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x03, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xF0, 0x38, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x3F, 0xC0, 0x0E,
  0x00, 0x33, 0x18, 0x02, 0x20, 0xC0, 0x24, 0x06, 0x02, 0x40, 0x30, 0x44,
  0x01, 0x8C, 0xC0, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 4, 28, 24, 10, -28 },
  { 15, 8, 10, 24, 8, -30 },
  { 25, 22, 28, 24, 1, -28 },
  { 102, 19, 36, 24, 2, -32 },
  { 188, 22, 28, 24, 1, -28 },
  { 265, 20, 28, 24, 2, -28 },
  { 335, 2, 10, 24, 11, -30 },
  { 338, 10, 36, 24, 9, -30 },
  { 383, 10, 36, 24, 5, -30 },
  { 428, 20, 20, 24, 2, -22 },
  { 478, 20, 19, 24, 2, -22 },
  { 526, 5, 11, 24, 9, -4 },
  { 533, 10, 1, 24, 7, -13 },
  { 535, 4, 3, 24, 10, -3 },
  { 537, 16, 36, 24, 4, -30 },
  { 609, 18, 28, 24, 3, -28 },
  { 672, 19, 28, 24, 3, -28 },
  { 739, 18, 28, 24, 3, -28 },
  { 802, 17, 28, 24, 3, -28 },
  { 862, 20, 28, 24, 2, -28 },
  { 932, 17, 28, 24, 3, -28 },
  { 992, 18, 28, 24, 3, -28 },
  { 1055, 18, 28, 24, 3, -28 },
  { 1118, 18, 28, 24, 3, -28 },
  { 1181, 18, 28, 24, 3, -28 },
  { 1244, 4, 21, 24, 10, -21 },
  { 1255, 5, 28, 24, 9, -21 },
  { 1273, 18, 22, 24, 3, -23 },
  { 1323, 20, 8, 24, 2, -16 },
  { 1343, 18, 22, 24, 3, -23 },
  { 1393, 16, 28, 24, 4, -28 },
  { 1449, 17, 32, 24, 3, -28 },
  { 1517, 20, 28, 24, 2, -28 },
  { 1587, 17, 28, 24, 4, -28 },
  { 1647, 18, 28, 24, 3, -28 },
  { 1710, 17, 28, 24, 4, -28 },
  { 1770, 17, 28, 24, 4, -28 },
  { 1830, 17, 28, 24, 4, -28 },
  { 1890, 18, 28, 24, 3, -28 },
  { 1953, 16, 28, 24, 4, -28 },
  { 2009, 16, 28, 24, 4, -28 },
  { 2065, 15, 28, 24, 4, -28 },
  { 2118, 18, 28, 24, 4, -28 },
  { 2181, 15, 28, 24, 6, -28 },
  { 2234, 18, 28, 24, 3, -28 },
  { 2297, 16, 28, 24, 4, -28 },
  { 2353, 18, 28, 24, 3, -28 },
  { 2416, 17, 28, 24, 4, -28 },
  { 2476, 18, 33, 24, 3, -28 },
  { 2551, 17, 28, 24, 4, -28 },
  { 2611, 19, 28, 24, 2, -28 },
  { 2678, 22, 28, 24, 1, -28 },
  { 2755, 16, 28, 24, 4, -28 },
  { 2811, 20, 28, 24, 2, -28 },
  { 2881, 20, 28, 24, 2, -28 },
  { 2951, 20, 28, 24, 2, -28 },
  { 3021, 22, 28, 24, 1, -28 },
  { 3098, 20, 28, 24, 2, -28 },
  { 3168, 10, 36, 24, 10, -30 },
  { 3213, 16, 36, 24, 4, -30 },
  { 3285, 10, 36, 24, 4, -30 },
  { 3330, 18, 15, 24, 3, -28 },
  { 3364, 20, 1, 24, 2, 5 },
  { 3367, 5, 7, 24, 8, -31 },
  { 3372, 18, 21, 24, 3, -21 },
  { 3420, 16, 30, 24, 5, -30 },
  { 3480, 16, 21, 24, 4, -21 },
  { 3522, 16, 30, 24, 3, -30 },
  { 3582, 18, 21, 24, 3, -21 },
  { 3630, 18, 30, 24, 3, -30 },
  { 3698, 19, 30, 24, 3, -22 },
  { 3770, 15, 30, 24, 5, -30 },
  { 3827, 17, 30, 24, 5, -30 },
  { 3891, 14, 38, 24, 4, -30 },
  { 3958, 18, 30, 24, 5, -30 },
  { 4026, 16, 30, 24, 4, -30 },
  { 4086, 18, 21, 24, 3, -21 },
  { 4134, 15, 21, 24, 5, -21 },
  { 4174, 18, 21, 24, 3, -21 },
  { 4222, 16, 29, 24, 5, -21 },
  { 4280, 16, 29, 24, 3, -21 },
  { 4338, 19, 21, 24, 3, -21 },
  { 4388, 18, 21, 24, 3, -21 },
  { 4436, 20, 28, 24, 1, -28 },
  { 4506, 15, 21, 24, 4, -21 },
  { 4546, 18, 21, 24, 3, -21 },
  { 4594, 22, 21, 24, 1, -21 },
  { 4652, 18, 21, 24, 3, -21 },
  { 4700, 18, 29, 24, 3, -21 },
  { 4766, 16, 21, 24, 4, -21 },
  { 4808, 14, 36, 24, 5, -30 },
  { 4871, 2, 36, 24, 11, -30 },
  { 4880, 14, 36, 24, 5, -30 },
  { 4943, 20, 7, 24, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_EXTRALIGHT40PT7B_H_
