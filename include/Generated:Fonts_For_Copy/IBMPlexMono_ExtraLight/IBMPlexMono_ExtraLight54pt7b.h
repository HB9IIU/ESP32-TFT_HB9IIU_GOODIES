#ifndef _IBMPLEXMONO_EXTRALIGHT54PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x30, 0x84, 0x21, 0x08, 0x40, 0x00, 0x00, 0x00, 0x3D, 0xEF,
  0xF8, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x06, 0x03, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC0, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x10, 0xF0, 0x1E, 0x04, 0x0E, 0x06,
  0x01, 0x00, 0xC3, 0x00, 0x40, 0x18, 0xC0, 0x10, 0x04, 0x70, 0x04, 0x00,
  0x18, 0x01, 0x00, 0x06, 0x00, 0x40, 0x01, 0x80, 0x10, 0x00, 0x60, 0x04,
  0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0xE0, 0x10, 0x00, 0x1C,
  0x04, 0x00, 0x03, 0x81, 0x00, 0x00, 0x7E, 0x40, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x3F, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x10,
  0x1C, 0x00, 0x04, 0x03, 0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00,
  0x10, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x40, 0x0C,
  0x00, 0x10, 0x03, 0x40, 0x04, 0x01, 0xB8, 0x01, 0x00, 0x67, 0x00, 0x40,
  0x38, 0xE0, 0x10, 0x0C, 0x1E, 0x04, 0x0E, 0x03, 0xE1, 0x0F, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0x3F, 0xE0, 0x00, 0x61, 0xC1, 0xC0, 0x01, 0x8C, 0x03, 0x80,
  0x0C, 0x60, 0x06, 0x00, 0x21, 0x80, 0x08, 0x01, 0x86, 0x00, 0x30, 0x0C,
  0x10, 0x00, 0xC0, 0x30, 0x40, 0x03, 0x01, 0x81, 0x00, 0x0C, 0x04, 0x04,
  0x00, 0x30, 0x30, 0x18, 0x00, 0xC0, 0x80, 0x60, 0x02, 0x06, 0x01, 0x80,
  0x18, 0x30, 0x03, 0x00, 0xE0, 0xC0, 0x07, 0x07, 0x06, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x07, 0x0F,
  0x00, 0x18, 0x30, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x02, 0x06, 0x00, 0x60,
  0x18, 0x18, 0x00, 0x80, 0xC0, 0x40, 0x03, 0x03, 0x01, 0x00, 0x0C, 0x18,
  0x0C, 0x00, 0x30, 0x60, 0x10, 0x00, 0xC3, 0x00, 0x40, 0x03, 0x08, 0x01,
  0x00, 0x08, 0x60, 0x06, 0x00, 0x63, 0x00, 0x18, 0x01, 0x8C, 0x00, 0x30,
  0x0C, 0x60, 0x00, 0xF0, 0x71, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0xE7, 0x00, 0x7F, 0x1C,
  0x30, 0x06, 0x03, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x60, 0x07, 0x06, 0x0C, 0x00, 0x38, 0x60, 0xC0, 0x01, 0xC6, 0x0C,
  0x00, 0x0C, 0x40, 0xC0, 0x00, 0x64, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1E, 0x06, 0x00, 0x03, 0x70,
  0x70, 0x00, 0x63, 0x83, 0x80, 0x0C, 0x1C, 0x1E, 0x03, 0x80, 0xC0, 0xFF,
  0xF0, 0x06, 0x01, 0xFC, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x0B, 0xC0, 0x30, 0x0F, 0x9F,
  0x06, 0x0F, 0xC0, 0x7C, 0xCF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06, 0x70, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3,
  0x1C, 0x71, 0x86, 0x18, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xBF,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x07,
  0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x98, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE1, 0x80, 0x00, 0xF0,
  0x60, 0x00, 0x70, 0x18, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03,
  0x83, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x39, 0x80, 0x00, 0xE1, 0xC0, 0x03, 0x81, 0xE0, 0x1E, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x33, 0xFF, 0xE0, 0x37, 0x00,
  0xF0, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x10, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x40, 0x00, 0x0E, 0xE0, 0x00,
  0x0C, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x7F, 0x00, 0x31, 0xFF, 0xE0, 0x67, 0x80, 0xF0, 0x6C, 0x00,
  0x38, 0x68, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01, 0xC1, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x87, 0x80, 0x03, 0x81,
  0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x81, 0xE0, 0x03, 0x83, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x3D, 0xC0, 0x00, 0xD9, 0xE0, 0x03, 0x61, 0xF0, 0x1C, 0xC0, 0xFF, 0xF1,
  0x80, 0x7F, 0x87, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF7,
  0xBF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0xBF, 0xE0, 0x3C, 0x78, 0xF9, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0xC1, 0x86,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00,
  0x1C, 0x30, 0x00, 0x39, 0xC0, 0x00, 0x66, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x03, 0xE3, 0xC0, 0x3F, 0xCF, 0x01,
  0xC1, 0xBC, 0x0E, 0x01, 0xF0, 0x30, 0x03, 0xC0, 0x80, 0x0F, 0x06, 0x00,
  0x3C, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x3C, 0x18,
  0x00, 0xF0, 0x60, 0x03, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x7C, 0x06, 0x03,
  0xF0, 0x1F, 0xFB, 0xC0, 0x1F, 0xCD, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x03,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0C, 0x00, 0x0F, 0x18, 0x00, 0x07,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0xE6, 0x00, 0x03, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x1C, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x38, 0x00, 0x07, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x02, 0x30, 0x00, 0x03, 0x38,
  0x00, 0x07, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x03,
  0xC0, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x07,
  0x86, 0x00, 0x3E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x38, 0x00, 0x0B, 0x1C, 0x00,
  0x1B, 0x0E, 0x00, 0x33, 0x07, 0x80, 0xE3, 0x03, 0xFF, 0xC3, 0x00, 0x7F,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x76, 0x00,
  0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0xE0, 0x00, 0xC6, 0x60, 0x00, 0xCE,
  0x30, 0x00, 0xDC, 0x38, 0x00, 0xF8, 0x18, 0x00, 0xF0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x0F,
  0xD8, 0x00, 0x1B, 0xCC, 0x00, 0x1B, 0xCC, 0x00, 0x13, 0xCC, 0x00, 0x33,
  0xC6, 0x00, 0x33, 0xC6, 0x00, 0x63, 0xC3, 0x00, 0x63, 0xC3, 0x00, 0xC3,
  0xC1, 0x80, 0xC3, 0xC1, 0x81, 0x83, 0xC0, 0x81, 0x83, 0xC0, 0xC1, 0x03,
  0xC0, 0xC3, 0x03, 0xC0, 0x63, 0x03, 0xC0, 0x66, 0x03, 0xC0, 0x36, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x08, 0x03,
  0xC0, 0x10, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF6, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0xC0,
  0x00, 0xF1, 0x80, 0x03, 0xC6, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x30, 0x00,
  0xF0, 0xE0, 0x03, 0xC1, 0x80, 0x0F, 0x07, 0x00, 0x3C, 0x0C, 0x00, 0xF0,
  0x38, 0x03, 0xC0, 0x60, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x18, 0x0F, 0x00, 0x60, 0x3C, 0x00, 0xC0, 0xF0, 0x03, 0x03,
  0xC0, 0x06, 0x0F, 0x00, 0x18, 0x3C, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0xC0,
  0x01, 0x8F, 0x00, 0x06, 0x3C, 0x00, 0x0C, 0xF0, 0x00, 0x33, 0xC0, 0x00,
  0x6F, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x3C,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x1C, 0x00,
  0x06, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0x00,
  0x03, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x03, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x81, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x0E, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC3, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00,
  0x03, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x18, 0x06, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x00, 0x38, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0F, 0x80, 0x3C, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x1E, 0x01, 0xE0, 0x3F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x07, 0x00, 0x66, 0x00, 0xE0, 0x08, 0xC0, 0x3C,
  0x01, 0x18, 0x06, 0x80, 0x63, 0x00, 0xD8, 0x0C, 0x60, 0x13, 0x01, 0x8C,
  0x06, 0x60, 0x30, 0x80, 0xC4, 0x06, 0x10, 0x10, 0xC0, 0xC3, 0x06, 0x18,
  0x18, 0x60, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x61, 0x82, 0x06, 0x08, 0x30,
  0xC0, 0xC1, 0x06, 0x18, 0x08, 0x60, 0xC3, 0x01, 0x8C, 0x18, 0x40, 0x31,
  0x83, 0x18, 0x06, 0x30, 0x23, 0x00, 0x46, 0x04, 0x60, 0x0C, 0xC0, 0xD8,
  0x01, 0x98, 0x1B, 0x00, 0x33, 0x03, 0x60, 0x03, 0x60, 0x68, 0x00, 0x68,
  0x0F, 0x00, 0x0D, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xC1, 0x81, 0x83, 0x83, 0x03,
  0x03, 0x06, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x03,
  0x00, 0x1C, 0x03, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x58, 0x30, 0x00, 0x2C, 0x1C,
  0x00, 0x26, 0x07, 0x80, 0xE3, 0xF1, 0xFF, 0xE1, 0xF8, 0x3F, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x3F, 0x80, 0xC3, 0xFF, 0x83,
  0x3C, 0x0F, 0x0C, 0x80, 0x0E, 0x34, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6E, 0x00, 0x01,
  0xB8, 0x00, 0x0C, 0xD0, 0x00, 0x73, 0x20, 0x03, 0x8C, 0xE0, 0x3C, 0x30,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0,
  0xF0, 0x38, 0x00, 0xC3, 0x80, 0x03, 0x18, 0x00, 0x1D, 0x80, 0x00, 0x6C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x19, 0xC0,
  0x01, 0x87, 0x00, 0x18, 0x1E, 0x03, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x3F, 0x83, 0x03, 0xFF, 0x8C,
  0x3C, 0x07, 0x31, 0xC0, 0x06, 0xCE, 0x00, 0x0F, 0x30, 0x00, 0x1D, 0xC0,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00, 0x00,
  0xCC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x70, 0x01, 0xB0, 0xF0, 0x1C, 0xC0,
  0xFF, 0xE3, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3C,
  0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x18, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x98, 0x00, 0x7F,
  0xFC, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0xF1, 0xC0,
  0x00, 0x1C, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x0F, 0xC0, 0xC3, 0xFF, 0x8C, 0x60, 0x3C,
  0xC8, 0x00, 0xED, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x19, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x03, 0x81, 0x80, 0x0E, 0x03, 0x00,
  0x38, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xC7, 0x60, 0x01, 0x9C, 0xE0, 0x03, 0x70, 0xE0,
  0x07, 0x80, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xFC,
  0x67, 0xF0, 0xFF, 0x36, 0x1C, 0xC1, 0xDC, 0x06, 0xC0, 0x6C, 0x01, 0xC0,
  0x36, 0x00, 0xE0, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x30, 0x03, 0xC0, 0x18,
  0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x01,
  0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x30, 0x03, 0xC0,
  0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x03, 0x00, 0x3C,
  0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x30, 0x03,
  0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x03, 0x00,
  0x3C, 0x01, 0x80, 0x18, 0x00, 0xFC, 0x0C, 0x3F, 0xF8, 0xC6, 0x03, 0xCC,
  0x80, 0x0E, 0xD0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3C,
  0x07, 0x00, 0xE0, 0x03, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x78,
  0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0x0F,
  0xFE, 0x0C, 0xF0, 0x3C, 0x32, 0x00, 0x38, 0xD0, 0x00, 0x73, 0x80, 0x00,
  0xCE, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x33, 0x40, 0x01, 0xCC, 0x80, 0x0E, 0x33, 0x80,
  0xF0, 0xC3, 0xFF, 0x83, 0x03, 0xF8, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x30, 0xF0, 0x1C, 0xC7, 0x00, 0x1B, 0x38, 0x00, 0x3C,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0xF1, 0xC0, 0x06,
  0xC3, 0xC0, 0x73, 0x03, 0xFF, 0x8C, 0x03, 0xF8, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0x02, 0x38, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x78, 0x07, 0xC1, 0xC0, 0x01, 0xC3, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0xE0, 0xF8, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x1B, 0x1E, 0x07, 0x30, 0xFF, 0xE3,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x46, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0D, 0x00, 0x34, 0x00,
  0xD0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x00, 0x98, 0x02, 0x60, 0x19, 0x80,
  0x26, 0x01, 0x88, 0x06, 0x60, 0x18, 0xC0, 0x62, 0x01, 0x0C, 0x06, 0x30,
  0x30, 0xC0, 0x63, 0x03, 0x04, 0x04, 0x30, 0x30, 0x60, 0x43, 0x02, 0x06,
  0x0C, 0x10, 0x60, 0x60, 0xC1, 0x06, 0x02, 0x0C, 0x18, 0x60, 0x30, 0xC1,
  0x84, 0x03, 0x08, 0x18, 0xC0, 0x31, 0x81, 0x8C, 0x01, 0x18, 0x08, 0xC0,
  0x19, 0x80, 0xC8, 0x01, 0x98, 0x0D, 0x80, 0x19, 0x00, 0xD8, 0x00, 0x90,
  0x0D, 0x80, 0x0F, 0x00, 0x50, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03,
  0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x63, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC1, 0x80, 0x01,
  0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x43, 0xF8, 0x00, 0x31, 0x87,
  0x00, 0x0C, 0xC0, 0xE0, 0x03, 0x60, 0x1C, 0x01, 0x98, 0x03, 0x80, 0x64,
  0x00, 0x70, 0x33, 0x00, 0x0E, 0x1C, 0xC0, 0x01, 0xFE, 0x30, 0x00, 0x1F,
  0x00,
};

const GFXglyph IBMPlexMono_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 5, 38, 32, 14, -38 },
  { 25, 10, 14, 32, 11, -40 },
  { 43, 30, 38, 32, 1, -38 },
  { 186, 26, 49, 32, 3, -43 },
  { 346, 30, 39, 32, 1, -38 },
  { 493, 28, 39, 32, 2, -38 },
  { 630, 2, 14, 32, 15, -40 },
  { 634, 13, 48, 32, 12, -41 },
  { 712, 13, 48, 32, 7, -41 },
  { 790, 27, 27, 32, 3, -30 },
  { 882, 26, 26, 32, 3, -29 },
  { 967, 6, 14, 32, 12, -5 },
  { 978, 14, 2, 32, 9, -17 },
  { 982, 5, 4, 32, 14, -4 },
  { 985, 22, 48, 32, 5, -41 },
  { 1117, 25, 39, 32, 4, -38 },
  { 1239, 26, 38, 32, 4, -38 },
  { 1363, 24, 38, 32, 4, -38 },
  { 1477, 23, 39, 32, 4, -38 },
  { 1590, 28, 38, 32, 2, -38 },
  { 1723, 24, 39, 32, 4, -38 },
  { 1840, 24, 39, 32, 4, -38 },
  { 1957, 24, 38, 32, 4, -38 },
  { 2071, 25, 39, 32, 4, -38 },
  { 2193, 23, 38, 32, 5, -38 },
  { 2303, 5, 28, 32, 14, -28 },
  { 2321, 7, 37, 32, 12, -28 },
  { 2354, 23, 29, 32, 5, -31 },
  { 2438, 26, 11, 32, 3, -22 },
  { 2474, 23, 29, 32, 5, -31 },
  { 2558, 22, 38, 32, 5, -38 },
  { 2663, 22, 44, 32, 5, -38 },
  { 2784, 27, 38, 32, 3, -38 },
  { 2913, 23, 38, 32, 5, -38 },
  { 3023, 24, 39, 32, 4, -38 },
  { 3140, 23, 38, 32, 6, -38 },
  { 3250, 22, 38, 32, 6, -38 },
  { 3355, 22, 38, 32, 6, -38 },
  { 3460, 24, 39, 32, 4, -38 },
  { 3577, 22, 38, 32, 5, -38 },
  { 3682, 23, 38, 32, 5, -38 },
  { 3792, 20, 39, 32, 5, -38 },
  { 3890, 24, 38, 32, 6, -38 },
  { 4004, 21, 38, 32, 8, -38 },
  { 4104, 24, 38, 32, 4, -38 },
  { 4218, 22, 38, 32, 5, -38 },
  { 4323, 25, 39, 32, 4, -38 },
  { 4445, 23, 38, 32, 6, -38 },
  { 4555, 25, 46, 32, 4, -38 },
  { 4699, 23, 38, 32, 6, -38 },
  { 4809, 26, 39, 32, 3, -38 },
  { 4936, 28, 38, 32, 2, -38 },
  { 5069, 22, 39, 32, 5, -38 },
  { 5177, 27, 38, 32, 3, -38 },
  { 5306, 27, 38, 32, 3, -38 },
  { 5435, 28, 38, 32, 2, -38 },
  { 5568, 30, 38, 32, 1, -38 },
  { 5711, 27, 38, 32, 3, -38 },
  { 5840, 13, 48, 32, 14, -41 },
  { 5918, 22, 48, 32, 5, -41 },
  { 6050, 14, 48, 32, 5, -41 },
  { 6134, 26, 21, 32, 3, -38 },
  { 6203, 26, 2, 32, 3, 6 },
  { 6210, 7, 9, 32, 11, -41 },
  { 6218, 25, 30, 32, 4, -29 },
  { 6312, 22, 41, 32, 6, -40 },
  { 6425, 21, 30, 32, 6, -29 },
  { 6504, 22, 41, 32, 4, -40 },
  { 6617, 23, 30, 32, 5, -29 },
  { 6704, 25, 40, 32, 4, -40 },
  { 6829, 25, 42, 32, 5, -31 },
  { 6961, 20, 40, 32, 6, -40 },
  { 7061, 23, 41, 32, 6, -41 },
  { 7179, 19, 52, 32, 5, -41 },
  { 7303, 23, 40, 32, 7, -40 },
  { 7418, 23, 40, 32, 5, -40 },
  { 7533, 25, 29, 32, 4, -29 },
  { 7624, 20, 29, 32, 6, -29 },
  { 7697, 23, 30, 32, 5, -29 },
  { 7784, 22, 40, 32, 6, -29 },
  { 7894, 22, 40, 32, 4, -29 },
  { 8004, 26, 28, 32, 4, -28 },
  { 8095, 23, 30, 32, 5, -29 },
  { 8182, 26, 38, 32, 2, -38 },
  { 8306, 20, 29, 32, 6, -28 },
  { 8379, 23, 28, 32, 5, -28 },
  { 8460, 28, 28, 32, 2, -28 },
  { 8558, 24, 28, 32, 4, -28 },
  { 8642, 24, 39, 32, 4, -28 },
  { 8759, 22, 28, 32, 5, -28 },
  { 8836, 20, 48, 32, 6, -41 },
  { 8956, 2, 48, 32, 15, -41 },
  { 8968, 20, 48, 32, 6, -41 },
  { 9088, 26, 10, 32, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_EXTRALIGHT54PT7B_H_
