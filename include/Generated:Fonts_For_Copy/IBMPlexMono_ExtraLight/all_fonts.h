#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_ExtraLight
// Headers: 67

#include "IBMPlexMono_ExtraLight6pt7b.h"
#include "IBMPlexMono_ExtraLight7pt7b.h"
#include "IBMPlexMono_ExtraLight8pt7b.h"
#include "IBMPlexMono_ExtraLight9pt7b.h"
#include "IBMPlexMono_ExtraLight10pt7b.h"
#include "IBMPlexMono_ExtraLight11pt7b.h"
#include "IBMPlexMono_ExtraLight12pt7b.h"
#include "IBMPlexMono_ExtraLight13pt7b.h"
#include "IBMPlexMono_ExtraLight14pt7b.h"
#include "IBMPlexMono_ExtraLight15pt7b.h"
#include "IBMPlexMono_ExtraLight16pt7b.h"
#include "IBMPlexMono_ExtraLight17pt7b.h"
#include "IBMPlexMono_ExtraLight18pt7b.h"
#include "IBMPlexMono_ExtraLight19pt7b.h"
#include "IBMPlexMono_ExtraLight20pt7b.h"
#include "IBMPlexMono_ExtraLight21pt7b.h"
#include "IBMPlexMono_ExtraLight22pt7b.h"
#include "IBMPlexMono_ExtraLight23pt7b.h"
#include "IBMPlexMono_ExtraLight24pt7b.h"
#include "IBMPlexMono_ExtraLight25pt7b.h"
#include "IBMPlexMono_ExtraLight26pt7b.h"
#include "IBMPlexMono_ExtraLight27pt7b.h"
#include "IBMPlexMono_ExtraLight28pt7b.h"
#include "IBMPlexMono_ExtraLight29pt7b.h"
#include "IBMPlexMono_ExtraLight30pt7b.h"
#include "IBMPlexMono_ExtraLight31pt7b.h"
#include "IBMPlexMono_ExtraLight32pt7b.h"
#include "IBMPlexMono_ExtraLight33pt7b.h"
#include "IBMPlexMono_ExtraLight34pt7b.h"
#include "IBMPlexMono_ExtraLight35pt7b.h"
#include "IBMPlexMono_ExtraLight36pt7b.h"
#include "IBMPlexMono_ExtraLight37pt7b.h"
#include "IBMPlexMono_ExtraLight38pt7b.h"
#include "IBMPlexMono_ExtraLight39pt7b.h"
#include "IBMPlexMono_ExtraLight40pt7b.h"
#include "IBMPlexMono_ExtraLight41pt7b.h"
#include "IBMPlexMono_ExtraLight42pt7b.h"
#include "IBMPlexMono_ExtraLight43pt7b.h"
#include "IBMPlexMono_ExtraLight44pt7b.h"
#include "IBMPlexMono_ExtraLight45pt7b.h"
#include "IBMPlexMono_ExtraLight46pt7b.h"
#include "IBMPlexMono_ExtraLight47pt7b.h"
#include "IBMPlexMono_ExtraLight48pt7b.h"
#include "IBMPlexMono_ExtraLight49pt7b.h"
#include "IBMPlexMono_ExtraLight50pt7b.h"
#include "IBMPlexMono_ExtraLight51pt7b.h"
#include "IBMPlexMono_ExtraLight52pt7b.h"
#include "IBMPlexMono_ExtraLight53pt7b.h"
#include "IBMPlexMono_ExtraLight54pt7b.h"
#include "IBMPlexMono_ExtraLight55pt7b.h"
#include "IBMPlexMono_ExtraLight56pt7b.h"
#include "IBMPlexMono_ExtraLight57pt7b.h"
#include "IBMPlexMono_ExtraLight58pt7b.h"
#include "IBMPlexMono_ExtraLight59pt7b.h"
#include "IBMPlexMono_ExtraLight60pt7b.h"
#include "IBMPlexMono_ExtraLight61pt7b.h"
#include "IBMPlexMono_ExtraLight62pt7b.h"
#include "IBMPlexMono_ExtraLight63pt7b.h"
#include "IBMPlexMono_ExtraLight64pt7b.h"
#include "IBMPlexMono_ExtraLight65pt7b.h"
#include "IBMPlexMono_ExtraLight66pt7b.h"
#include "IBMPlexMono_ExtraLight67pt7b.h"
#include "IBMPlexMono_ExtraLight68pt7b.h"
#include "IBMPlexMono_ExtraLight69pt7b.h"
#include "IBMPlexMono_ExtraLight70pt7b.h"
#include "IBMPlexMono_ExtraLight71pt7b.h"
#include "IBMPlexMono_ExtraLight72pt7b.h"
