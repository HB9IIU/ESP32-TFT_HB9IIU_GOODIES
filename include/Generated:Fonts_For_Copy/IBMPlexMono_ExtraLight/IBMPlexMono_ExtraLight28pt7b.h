#ifndef _IBMPLEXMONO_EXTRALIGHT28PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x03, 0xF0, 0x8C, 0x63, 0x18,
  0xC6, 0x20, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x42, 0x00,
  0x84, 0x01, 0x08, 0x3E, 0x1F, 0x04, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x0F, 0x87, 0xC1, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00,
  0x42, 0x00, 0x84, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0x83, 0x26,
  0x21, 0x0A, 0x08, 0x30, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x44, 0x01,
  0xF0, 0x01, 0x70, 0x08, 0xC0, 0x43, 0x02, 0x08, 0x10, 0x40, 0x83, 0x04,
  0x1C, 0x21, 0x39, 0x30, 0x7F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3C,
  0x02, 0x8C, 0x0A, 0x08, 0x14, 0x08, 0x48, 0x11, 0x10, 0x22, 0x20, 0x48,
  0x41, 0x10, 0x46, 0x40, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x20, 0xD0, 0x22,
  0x20, 0x44, 0x40, 0x90, 0x81, 0x21, 0x02, 0x82, 0x05, 0x02, 0x14, 0x03,
  0xC0, 0x0F, 0x80, 0x43, 0x02, 0x06, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x70, 0x72, 0x41, 0x10, 0x84, 0xC1, 0x12,
  0x02, 0x48, 0x05, 0x20, 0x18, 0x80, 0x31, 0x01, 0x46, 0x08, 0x87, 0xC1,
  0xFE, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x81, 0x01, 0x02, 0x02, 0x02, 0x06, 0x06, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x1C, 0x21, 0x87, 0x5C, 0x81, 0xC0, 0x02, 0x80, 0x09,
  0x80, 0x11, 0x00, 0x41, 0x01, 0x01, 0x06, 0x02, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x36, 0x64, 0x44, 0x48, 0xFE,
  0xFC, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x00,
  0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x30, 0x61, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x68, 0x02, 0x40, 0x13, 0x01, 0x0C, 0x18, 0x1F, 0x00, 0x07, 0x00, 0x68,
  0x06, 0x40, 0x62, 0x06, 0x10, 0x60, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0xFF, 0xF0, 0x0F, 0x81, 0x82, 0x10, 0x08, 0x80,
  0x48, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0xFF, 0xF0, 0x1F, 0x83, 0x0C, 0x40, 0x28, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x20, 0x02, 0x00, 0xC1, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x3C, 0x02, 0x60, 0xC1, 0xF8, 0x00, 0x20, 0x01,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x08,
  0x20, 0x20, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x3F,
  0xFF, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xF2, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x4F, 0x85, 0x06, 0x60,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x14, 0x02, 0x30,
  0x61, 0xF8, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x4F, 0x85, 0x06, 0xE0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x16, 0x02, 0x30, 0x60, 0xF8, 0xFF, 0xF8, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x0F, 0x81, 0x83, 0x10, 0x0C, 0x80, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x06, 0x30, 0x60, 0x7C, 0x0C, 0x18, 0x80, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1A, 0x00, 0x8C, 0x18, 0x3F, 0x00, 0x0F,
  0x81, 0x83, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0E, 0x00, 0x78, 0x03,
  0x40, 0x1B, 0x01, 0x8C, 0x14, 0x1F, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x64, 0x44, 0x48,
  0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x10, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x20, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x00, 0x1F, 0x0C, 0x19, 0x01,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0xE0, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x0F, 0x81, 0x04, 0x20, 0x24, 0x03, 0x40, 0x14, 0x01, 0x43, 0xD4, 0x63,
  0x84, 0x18, 0x81, 0x88, 0x18, 0x81, 0x88, 0x18, 0x81, 0x84, 0x18, 0x43,
  0x43, 0xD4, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x80, 0x0F, 0xE0, 0x01,
  0x00, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0xC0, 0x11, 0x00, 0x44, 0x02,
  0x10, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x04, 0x10, 0x10, 0xFF, 0xC2,
  0x00, 0x88, 0x02, 0x60, 0x09, 0x00, 0x14, 0x00, 0x70, 0x01, 0xFF, 0x08,
  0x0C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x8F,
  0xF0, 0x80, 0xC8, 0x02, 0x80, 0x28, 0x03, 0x80, 0x18, 0x03, 0x80, 0x28,
  0x02, 0x80, 0x4F, 0xF8, 0x0F, 0xC0, 0xC3, 0x08, 0x04, 0x80, 0x24, 0x00,
  0xA0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x19, 0x00, 0x86, 0x18, 0x1F,
  0x80, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x8F, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFE, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x83, 0x06, 0x20, 0x24, 0x01, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x03, 0x30, 0x50, 0xF9, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F,
  0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x7F, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x24, 0x18, 0xF8, 0x80, 0x14, 0x01, 0x20,
  0x11, 0x01, 0x08, 0x18, 0x41, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0xA0,
  0x29, 0x01, 0x84, 0x0C, 0x30, 0x40, 0x82, 0x02, 0x10, 0x18, 0x80, 0x44,
  0x01, 0x20, 0x0D, 0x00, 0x30, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x1E, 0x00,
  0xE8, 0x0B, 0x40, 0x59, 0x04, 0xC8, 0x26, 0x42, 0x31, 0x11, 0x88, 0x8C,
  0x28, 0x61, 0x43, 0x04, 0x18, 0x20, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x1A,
  0x03, 0x20, 0x64, 0x0C, 0x41, 0x88, 0x30, 0x86, 0x10, 0xC1, 0x18, 0x23,
  0x02, 0x60, 0x4C, 0x05, 0x80, 0xB0, 0x0E, 0x01, 0xC0, 0x30, 0x0F, 0x81,
  0x82, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x68, 0x02,
  0x40, 0x13, 0x01, 0x0C, 0x18, 0x1F, 0x00, 0xFF, 0x88, 0x06, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x06, 0xFF, 0x88,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x68, 0x02, 0x40, 0x13, 0x01, 0x0C, 0x10, 0x1F, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x7C, 0xFF, 0x88, 0x06, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x06, 0xFF, 0x88, 0x60, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x28, 0x03, 0x1F, 0xC1,
  0x83, 0x10, 0x05, 0x00, 0x38, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x1E, 0x00, 0x8C, 0x18, 0x3F, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x09, 0x83, 0x1F,
  0x80, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x23,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x80, 0x82, 0x02, 0x08, 0x08, 0x40,
  0x11, 0x00, 0x44, 0x01, 0x30, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x40,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x10,
  0x50, 0xC1, 0x42, 0x85, 0x0A, 0x24, 0x48, 0x91, 0x12, 0x24, 0x48, 0x91,
  0x22, 0x84, 0x8A, 0x0A, 0x28, 0x28, 0xA0, 0xA3, 0x02, 0x8C, 0x06, 0xC0,
  0x04, 0xC0, 0x10, 0x80, 0x20, 0x80, 0x81, 0x82, 0x01, 0x04, 0x01, 0x10,
  0x02, 0x60, 0x02, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x44, 0x01,
  0x88, 0x02, 0x08, 0x08, 0x08, 0x30, 0x10, 0x40, 0x11, 0x00, 0x36, 0x00,
  0x30, 0x80, 0x02, 0x80, 0x09, 0x00, 0x31, 0x00, 0x43, 0x01, 0x02, 0x02,
  0x02, 0x08, 0x04, 0x10, 0x04, 0x40, 0x09, 0x00, 0x0A, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0xFE,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x02, 0x00, 0x28,
  0x02, 0x40, 0x11, 0x01, 0x04, 0x08, 0x20, 0x80, 0x88, 0x04, 0x40, 0x14,
  0x00, 0xE0, 0x02, 0xFF, 0xF8, 0x91, 0x12, 0x1F, 0x03, 0x06, 0x20, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0xFF, 0x8C, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x01, 0xC6, 0x0A, 0x1F, 0x9C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x09, 0xF0, 0xA0, 0xCC, 0x06, 0x80, 0x28, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0xC0, 0x6A, 0x0C,
  0x9F, 0x00, 0x1F, 0x06, 0x19, 0x01, 0xE0, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x00, 0xA0, 0x13, 0x0C, 0x3E, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xF1, 0x30, 0xD4,
  0x07, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x03, 0x40, 0x73, 0x05, 0x1F, 0x90, 0x0F, 0x83, 0x06, 0x60, 0x24, 0x01,
  0x40, 0x18, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x16, 0x03,
  0x30, 0x60, 0xF8, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07,
  0xFF, 0x00, 0x00, 0x3C, 0x3F, 0x01, 0x04, 0x08, 0x08, 0x20, 0x21, 0x80,
  0x82, 0x03, 0x08, 0x08, 0x20, 0x20, 0x41, 0x01, 0xF8, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x01, 0xFF, 0x18, 0x06, 0xC0, 0x0A, 0x00, 0x24, 0x00, 0x98,
  0x04, 0x1F, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x78, 0xB0, 0xD8, 0x0A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x0F, 0xFF, 0x00, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xBF, 0xE0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0x80,
  0x88, 0x10, 0x82, 0x08, 0xC0, 0x98, 0x0A, 0xC0, 0xC4, 0x08, 0x20, 0x81,
  0x08, 0x08, 0x80, 0xC8, 0x06, 0x80, 0x30, 0xFE, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xFF, 0xF0, 0xB8, 0xF6, 0x28, 0xE0, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20,
  0xC1, 0x04, 0x8F, 0x16, 0x1B, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x0F, 0x83,
  0x06, 0x60, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x01, 0x40, 0x16, 0x02, 0x30, 0x60, 0xF8, 0x9F, 0x0A, 0x0C, 0xC0, 0x68,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x2C,
  0x06, 0xA0, 0xC9, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x1F, 0x13, 0x0D, 0x40, 0x74, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x34, 0x07, 0x30, 0x51, 0xF9, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFC, 0xFC, 0x14, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x03, 0xFF, 0xC0, 0x1F, 0x81, 0x83, 0x10,
  0x04, 0x80, 0x04, 0x00, 0x10, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x10, 0x00,
  0x80, 0x07, 0x80, 0x23, 0x03, 0x07, 0xE0, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xFF, 0xC1, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x60, 0xC7, 0xD0,
  0xC0, 0x14, 0x01, 0x40, 0x22, 0x02, 0x20, 0x21, 0x04, 0x10, 0x41, 0x04,
  0x08, 0x80, 0x88, 0x09, 0x00, 0x50, 0x05, 0x00, 0x20, 0x81, 0x03, 0x06,
  0x06, 0x0A, 0x12, 0x14, 0x24, 0x48, 0x48, 0x90, 0x91, 0x11, 0x22, 0x24,
  0x48, 0x48, 0x50, 0x90, 0xA0, 0xA1, 0x41, 0x43, 0x03, 0x02, 0x02, 0x00,
  0xC0, 0x11, 0x01, 0x0C, 0x10, 0x20, 0x80, 0x88, 0x02, 0x80, 0x08, 0x00,
  0xE0, 0x05, 0x00, 0x44, 0x04, 0x10, 0x40, 0xC6, 0x02, 0x60, 0x0C, 0x80,
  0x1A, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x41, 0x02, 0x08,
  0x08, 0x80, 0x44, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x01, 0xFF, 0xC0, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x08, 0x03, 0x0F, 0x80, 0x1C, 0x00,
  0x80, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x06, 0x00,
  0x3E, 0x1C, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0xFC, 0x00, 0x38, 0x0A, 0x20, 0x60, 0x83, 0x02,
  0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 5, 7, 17, 6, -21 },
  { 14, 15, 20, 17, 1, -20 },
  { 52, 13, 26, 17, 2, -23 },
  { 95, 15, 20, 17, 1, -20 },
  { 133, 14, 20, 17, 1, -20 },
  { 168, 1, 7, 17, 8, -21 },
  { 169, 7, 25, 17, 6, -21 },
  { 191, 6, 25, 17, 4, -21 },
  { 210, 15, 14, 17, 1, -15 },
  { 237, 13, 13, 17, 2, -15 },
  { 259, 4, 8, 17, 6, -3 },
  { 263, 7, 1, 17, 5, -9 },
  { 264, 3, 2, 17, 7, -2 },
  { 265, 11, 25, 17, 3, -21 },
  { 300, 13, 20, 17, 2, -20 },
  { 333, 13, 20, 17, 2, -20 },
  { 366, 13, 20, 17, 2, -20 },
  { 399, 12, 20, 17, 2, -20 },
  { 429, 14, 20, 17, 1, -20 },
  { 464, 12, 20, 17, 2, -20 },
  { 494, 12, 20, 17, 2, -20 },
  { 524, 12, 20, 17, 2, -20 },
  { 554, 13, 20, 17, 2, -20 },
  { 587, 13, 20, 17, 2, -20 },
  { 620, 3, 15, 17, 7, -15 },
  { 626, 4, 20, 17, 6, -15 },
  { 636, 12, 15, 17, 2, -16 },
  { 659, 13, 6, 17, 2, -12 },
  { 669, 12, 15, 17, 2, -16 },
  { 692, 11, 20, 17, 3, -20 },
  { 720, 12, 23, 17, 2, -20 },
  { 755, 14, 20, 17, 1, -20 },
  { 790, 12, 20, 17, 3, -20 },
  { 820, 13, 20, 17, 2, -20 },
  { 853, 12, 20, 17, 3, -20 },
  { 883, 11, 20, 17, 3, -20 },
  { 911, 12, 20, 17, 3, -20 },
  { 941, 12, 20, 17, 2, -20 },
  { 971, 11, 20, 17, 3, -20 },
  { 999, 11, 20, 17, 3, -20 },
  { 1027, 10, 20, 17, 3, -20 },
  { 1052, 13, 20, 17, 3, -20 },
  { 1085, 11, 20, 17, 4, -20 },
  { 1113, 13, 20, 17, 2, -20 },
  { 1146, 11, 20, 17, 3, -20 },
  { 1174, 13, 20, 17, 2, -20 },
  { 1207, 12, 20, 17, 3, -20 },
  { 1237, 13, 24, 17, 2, -20 },
  { 1276, 12, 20, 17, 3, -20 },
  { 1306, 13, 20, 17, 2, -20 },
  { 1339, 15, 20, 17, 1, -20 },
  { 1377, 11, 20, 17, 3, -20 },
  { 1405, 14, 20, 17, 1, -20 },
  { 1440, 14, 20, 17, 1, -20 },
  { 1475, 15, 20, 17, 1, -20 },
  { 1513, 15, 20, 17, 1, -20 },
  { 1551, 14, 20, 17, 1, -20 },
  { 1586, 7, 25, 17, 7, -21 },
  { 1608, 11, 25, 17, 3, -21 },
  { 1643, 7, 25, 17, 3, -21 },
  { 1665, 13, 11, 17, 2, -20 },
  { 1683, 13, 1, 17, 2, 3 },
  { 1685, 3, 5, 17, 6, -22 },
  { 1687, 13, 14, 17, 2, -14 },
  { 1710, 12, 21, 17, 3, -21 },
  { 1742, 11, 14, 17, 3, -14 },
  { 1762, 12, 21, 17, 2, -21 },
  { 1794, 12, 14, 17, 2, -14 },
  { 1815, 13, 21, 17, 2, -21 },
  { 1850, 14, 21, 17, 2, -15 },
  { 1887, 11, 21, 17, 3, -21 },
  { 1916, 12, 20, 17, 3, -20 },
  { 1946, 10, 26, 17, 3, -20 },
  { 1979, 12, 21, 17, 4, -21 },
  { 2011, 12, 21, 17, 2, -21 },
  { 2043, 13, 14, 17, 2, -14 },
  { 2066, 11, 14, 17, 3, -14 },
  { 2086, 12, 14, 17, 2, -14 },
  { 2107, 12, 20, 17, 3, -14 },
  { 2137, 12, 20, 17, 2, -14 },
  { 2167, 14, 14, 17, 2, -14 },
  { 2192, 13, 14, 17, 2, -14 },
  { 2215, 14, 20, 17, 1, -20 },
  { 2250, 10, 14, 17, 3, -14 },
  { 2268, 12, 14, 17, 2, -14 },
  { 2289, 15, 14, 17, 1, -14 },
  { 2316, 13, 14, 17, 2, -14 },
  { 2339, 13, 20, 17, 2, -14 },
  { 2372, 11, 14, 17, 3, -14 },
  { 2392, 11, 25, 17, 3, -21 },
  { 2427, 1, 25, 17, 8, -21 },
  { 2431, 11, 25, 17, 3, -21 },
  { 2466, 13, 5, 17, 2, -11 },
};

const GFXfont IBMPlexMono_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_EXTRALIGHT28PT7B_H_
