#ifndef _IBMPLEXMONO_EXTRALIGHT41PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x03, 0xFE,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x80, 0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80,
  0x01, 0x03, 0x01, 0xFE, 0x07, 0xF8, 0x04, 0x08, 0x00, 0x18, 0x10, 0x00,
  0x30, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x06,
  0x04, 0x03, 0xFC, 0x0F, 0xE0, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40,
  0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00, 0x08, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x38, 0x8E,
  0x0C, 0x10, 0x63, 0x02, 0x06, 0x40, 0x40, 0x58, 0x08, 0x03, 0x01, 0x00,
  0x60, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x80, 0x18, 0x10, 0x01, 0x02, 0x00,
  0x18, 0x40, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x23, 0x80, 0x04, 0x18,
  0x00, 0x81, 0x80, 0x10, 0x10, 0x02, 0x03, 0x00, 0x40, 0x60, 0x08, 0x0C,
  0x01, 0x01, 0x80, 0x20, 0x38, 0x04, 0x05, 0x80, 0x81, 0x9C, 0x10, 0x60,
  0xE2, 0x38, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x0F, 0x00, 0x06, 0x61, 0x80, 0x19, 0x81, 0x80, 0x22, 0x01,
  0x00, 0xC4, 0x03, 0x01, 0x18, 0x06, 0x04, 0x30, 0x0C, 0x18, 0x60, 0x18,
  0x20, 0xC0, 0x30, 0xC0, 0x80, 0x61, 0x01, 0x00, 0x84, 0x03, 0x03, 0x08,
  0x03, 0x0C, 0x20, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x06, 0x10, 0x03, 0x10, 0x10, 0x0C, 0x60, 0x30, 0x10, 0x80, 0x20,
  0x41, 0x00, 0x41, 0x82, 0x00, 0x82, 0x04, 0x01, 0x0C, 0x08, 0x02, 0x10,
  0x10, 0x04, 0x40, 0x30, 0x18, 0x80, 0x20, 0x22, 0x00, 0x30, 0x8C, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x60, 0xE0, 0x02, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x07, 0x00, 0x00, 0x64, 0x03, 0xC4, 0x30, 0x10, 0x60, 0xC0, 0x86, 0x03,
  0x04, 0x30, 0x0C, 0x21, 0x00, 0x23, 0x08, 0x01, 0x98, 0x40, 0x06, 0x82,
  0x00, 0x1C, 0x10, 0x00, 0x60, 0xC0, 0x03, 0x82, 0x00, 0x26, 0x18, 0x02,
  0x10, 0x70, 0x60, 0x40, 0xFC, 0x03, 0x80, 0xFF, 0xE0, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x18, 0x04, 0x02, 0x78, 0x20, 0xF8, 0x79, 0x7C, 0x00, 0x7F, 0x00,
  0x00, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x4C, 0x00, 0x04, 0x30, 0x00, 0x60,
  0xC0, 0x06, 0x02, 0x00, 0x20, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x39, 0x8C,
  0x67, 0x31, 0x8C, 0x46, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03,
  0xF8, 0x01, 0x81, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x08, 0xC0,
  0x01, 0x10, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x05, 0x80, 0x00, 0x90, 0x00, 0x33, 0x00, 0x04, 0x20, 0x00, 0x86, 0x00,
  0x20, 0x60, 0x0C, 0x06, 0x07, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1A,
  0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x03, 0x02, 0x00, 0x60,
  0x20, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF0, 0x03,
  0x81, 0x80, 0xC0, 0x08, 0x30, 0x01, 0x86, 0x00, 0x18, 0x80, 0x03, 0x20,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x0E, 0x06, 0x0C, 0x01,
  0x8C, 0x00, 0x64, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x3F, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x01, 0x98, 0x01, 0x87, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x18, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x60,
  0x40, 0x06, 0x02, 0x00, 0x20, 0x10, 0x03, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x20, 0x18, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02,
  0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x23, 0xF8, 0x0B, 0x03, 0x83, 0x00, 0x30, 0x80,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x40, 0x00, 0xB8, 0x00, 0x63,
  0x00, 0x30, 0x70, 0x38, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x8F, 0xE0, 0x6C, 0x0E,
  0x16, 0x00, 0xC7, 0x00, 0x19, 0x80, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x00,
  0x03, 0x60, 0x00, 0x8C, 0x00, 0x61, 0x80, 0x30, 0x30, 0x38, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x01,
  0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x81, 0xC0,
  0xC0, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01, 0x90, 0x00, 0x32,
  0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x80,
  0xC0, 0xE0, 0x07, 0xF0, 0x07, 0x01, 0x81, 0x80, 0x0C, 0x60, 0x00, 0x98,
  0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x02, 0x40, 0x00, 0xCC, 0x00, 0x10, 0xC0, 0x06, 0x0E,
  0x03, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0,
  0x06, 0x60, 0x00, 0x98, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x60, 0x00, 0xD8, 0x00, 0x33,
  0x00, 0x14, 0x60, 0x0F, 0x0E, 0x0C, 0x80, 0xFC, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x63, 0x39, 0x8C, 0x62, 0x31, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xF0, 0x0C, 0x0E, 0x0C, 0x01, 0x8C, 0x00, 0x6C, 0x00,
  0x16, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x06, 0x0C, 0x0C, 0x01, 0x04, 0x00,
  0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0x80, 0xF9, 0x40,
  0xC2, 0xA0, 0xC0, 0xF0, 0x40, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x10, 0x07,
  0x08, 0x03, 0x84, 0x01, 0xC2, 0x00, 0xE1, 0x00, 0x70, 0xC0, 0x38, 0x60,
  0x1C, 0x10, 0x0E, 0x08, 0x07, 0x02, 0x07, 0x80, 0xFD, 0xE0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x01,
  0xA0, 0x00, 0x09, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80,
  0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0x81, 0x80, 0x04, 0x04, 0x00, 0x60,
  0x20, 0x02, 0x01, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x80,
  0x40, 0x04, 0x07, 0xFF, 0xE0, 0x20, 0x01, 0x81, 0x00, 0x04, 0x18, 0x00,
  0x20, 0x80, 0x01, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x23, 0x00, 0x01, 0x90,
  0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x40, 0x06,
  0x20, 0x01, 0x90, 0x00, 0x48, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x64,
  0x00, 0x63, 0xFF, 0xC1, 0x00, 0x1C, 0x80, 0x03, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0xCF, 0xFF, 0x80, 0x01, 0xFC,
  0x01, 0x81, 0xC0, 0x80, 0x18, 0x40, 0x02, 0x30, 0x00, 0xC8, 0x00, 0x16,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x01, 0x30, 0x00, 0xC4, 0x00, 0x20, 0x80, 0x18, 0x18,
  0x1C, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00,
  0x08, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x60, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20,
  0x00, 0x98, 0x00, 0x34, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0xCC, 0x00,
  0x51, 0x80, 0x24, 0x38, 0x19, 0x03, 0xF8, 0x40, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x19, 0x80, 0x21, 0x81, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x33,
  0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0, 0x0C,
  0x30, 0x01, 0x8F, 0x00, 0x33, 0x20, 0x06, 0xC6, 0x00, 0xF0, 0x60, 0x1C,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x23, 0x00, 0x06, 0x60,
  0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xD0,
  0x03, 0x76, 0x00, 0xDC, 0x80, 0x27, 0x30, 0x19, 0xC4, 0x04, 0x71, 0x03,
  0x1C, 0x60, 0x87, 0x08, 0x61, 0xC3, 0x18, 0x70, 0x44, 0x1C, 0x13, 0x07,
  0x02, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x1C, 0x04, 0x07, 0x02, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0xC0, 0x01, 0xF0, 0x00,
  0xE8, 0x00, 0x76, 0x00, 0x39, 0x00, 0x1C, 0xC0, 0x0E, 0x20, 0x07, 0x18,
  0x03, 0x84, 0x01, 0xC3, 0x00, 0xE0, 0x80, 0x70, 0x60, 0x38, 0x10, 0x1C,
  0x0C, 0x0E, 0x02, 0x07, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0x30, 0xE0, 0x18,
  0x70, 0x06, 0x38, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x13, 0x80,
  0x0D, 0xC0, 0x02, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x03, 0xF8,
  0x01, 0x81, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x08, 0xC0, 0x01,
  0x10, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05,
  0x80, 0x00, 0x90, 0x00, 0x33, 0x00, 0x04, 0x20, 0x00, 0x86, 0x00, 0x20,
  0x60, 0x0C, 0x06, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x30, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01,
  0xB0, 0x00, 0xCC, 0x00, 0x63, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0x81, 0x80, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00,
  0x08, 0xC0, 0x01, 0x10, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00, 0x33, 0x00, 0x04, 0x20, 0x00,
  0x86, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0xFF, 0xF8,
  0x30, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0xFF, 0xE0, 0xC0, 0xC0,
  0x30, 0x10, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x30, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0x8C, 0x00, 0x33, 0x00,
  0x06, 0xC0, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0xE0, 0x38, 0x18, 0x00, 0xC3,
  0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x40, 0x00, 0x2E, 0x00, 0x06, 0x38, 0x00, 0xC0,
  0xE0, 0x38, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x05, 0x80,
  0x02, 0x40, 0x03, 0x30, 0x01, 0x08, 0x01, 0x83, 0x01, 0x80, 0x7F, 0x00,
  0xC0, 0x00, 0x1A, 0x00, 0x01, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00,
  0x02, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x10, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x20, 0x10, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x80, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x02, 0x00, 0x10, 0x30, 0x00,
  0x81, 0x80, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x06, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x98, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x06, 0x03, 0x40, 0x70, 0x26, 0x05, 0x02, 0x60,
  0xD0, 0x26, 0x0D, 0x02, 0x60, 0x98, 0x22, 0x08, 0x82, 0x21, 0x88, 0x22,
  0x10, 0xC2, 0x21, 0x0C, 0x62, 0x30, 0x46, 0x23, 0x04, 0x62, 0x20, 0x64,
  0x32, 0x02, 0x43, 0x60, 0x24, 0x34, 0x03, 0x43, 0x40, 0x34, 0x14, 0x01,
  0x41, 0xC0, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C,
  0x00, 0x18, 0x60, 0x00, 0x81, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x04,
  0x00, 0xC0, 0x60, 0x02, 0x06, 0x00, 0x18, 0x20, 0x00, 0x63, 0x00, 0x01,
  0x30, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60,
  0x20, 0x02, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0xC1,
  0x80, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x61, 0x80, 0x00, 0x81, 0x80,
  0x03, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x03, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x60,
  0x00, 0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFE, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x06, 0xC0, 0x01, 0x88, 0x00, 0x21, 0x80, 0x0C, 0x10, 0x01, 0x03,
  0x00, 0x60, 0x30, 0x18, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00,
  0xC6, 0x00, 0x08, 0x80, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xFF,
  0xF0, 0xC1, 0x06, 0x0C, 0x10, 0x20, 0xC0, 0x07, 0xF0, 0x03, 0x03, 0x00,
  0xC0, 0x10, 0x30, 0x03, 0x04, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFC, 0x1C, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0xE1, 0x80, 0x2C, 0x18, 0x19, 0x80, 0xFC, 0x1E, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x43, 0xF0, 0x26, 0x06, 0x14, 0x01, 0x8C, 0x00,
  0x66, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x03, 0x60, 0x01, 0x30, 0x01, 0x94, 0x01, 0x89, 0x81, 0x84, 0x3F,
  0x00, 0x03, 0xF0, 0x06, 0x06, 0x06, 0x00, 0x84, 0x00, 0x26, 0x00, 0x12,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x01, 0x98, 0x00, 0x84, 0x00, 0xC1, 0x81, 0x80, 0x3F, 0x80, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0xF8, 0xC3, 0x03, 0x66, 0x00, 0xF2,
  0x00, 0x3B, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x40, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0xE6, 0x00, 0xF0, 0xC0, 0xD8,
  0x3F, 0x8C, 0x07, 0xF0, 0x0E, 0x0C, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00,
  0x36, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x01, 0xB0, 0x00, 0x8C, 0x00, 0x83, 0x81, 0x80, 0x7F, 0x00, 0x00,
  0x7F, 0xE0, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x20, 0x0E, 0x0E, 0x01, 0x80, 0x20, 0x10, 0x01, 0x03,
  0x00, 0x10, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18,
  0x10, 0x01, 0x01, 0x00, 0x10, 0x08, 0x02, 0x00, 0x60, 0xC0, 0x07, 0xF0,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFF, 0x03, 0x80, 0x0C, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x04, 0x38, 0x03, 0x80,
  0x7F, 0xC0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xC2, 0x60, 0xE5, 0x00,
  0x6C, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x6C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x03,
  0x03, 0x00, 0xC1, 0x80, 0x31, 0xC0, 0x0C, 0xD8, 0x03, 0x63, 0x00, 0xF0,
  0x40, 0x38, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x30, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07,
  0xFF, 0xFC, 0x9F, 0x0F, 0x94, 0x32, 0x1B, 0x02, 0x81, 0x60, 0x60, 0x38,
  0x04, 0x07, 0x00, 0x80, 0xE0, 0x10, 0x1C, 0x02, 0x03, 0x80, 0x40, 0x70,
  0x08, 0x0E, 0x01, 0x01, 0xC0, 0x20, 0x38, 0x04, 0x07, 0x00, 0x80, 0xE0,
  0x10, 0x1C, 0x02, 0x03, 0x80, 0x40, 0x70, 0x08, 0x0E, 0x01, 0x01, 0xC0,
  0x20, 0x38, 0x04, 0x06, 0x87, 0xE1, 0x30, 0x72, 0x80, 0x36, 0x00, 0x2C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x03, 0xF8, 0x03, 0x03,
  0x81, 0x80, 0x30, 0xC0, 0x04, 0x20, 0x00, 0x98, 0x00, 0x24, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x02, 0x20, 0x00, 0x8C, 0x00,
  0x41, 0x80, 0x30, 0x30, 0x38, 0x03, 0xF8, 0x00, 0x87, 0xE0, 0x4C, 0x0C,
  0x28, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x28, 0x03,
  0x13, 0x03, 0x08, 0x7E, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF1,
  0x86, 0x06, 0xCC, 0x01, 0xE4, 0x00, 0x76, 0x00, 0x1A, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0x90, 0x01,
  0xCC, 0x01, 0xE1, 0x81, 0xB0, 0x7F, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0xFF, 0x87, 0xF0, 0x19, 0x80, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0x01, 0x83, 0x00, 0x18,
  0x80, 0x03, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x40, 0x00, 0x78, 0x00, 0x33, 0x00, 0x18,
  0x70, 0x1C, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0xFE, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1D,
  0x80, 0x39, 0x81, 0xB0, 0xFC, 0x60, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x48, 0x00, 0x66, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x60, 0x08, 0x10,
  0x0C, 0x0C, 0x06, 0x06, 0x02, 0x01, 0x03, 0x00, 0xC1, 0x00, 0x20, 0x80,
  0x10, 0xC0, 0x0C, 0x40, 0x02, 0x20, 0x01, 0x30, 0x00, 0xD0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0xC0, 0x30, 0x05, 0x00, 0xE0, 0x14, 0x02, 0x80, 0xD0,
  0x0A, 0x03, 0x60, 0x68, 0x09, 0x81, 0x30, 0x22, 0x04, 0x40, 0x88, 0x11,
  0x02, 0x20, 0xC4, 0x18, 0x82, 0x18, 0x43, 0x08, 0x21, 0x04, 0x20, 0x84,
  0x11, 0x02, 0x10, 0x44, 0x0C, 0xC1, 0x10, 0x13, 0x06, 0x40, 0x48, 0x1A,
  0x01, 0x20, 0x28, 0x06, 0x80, 0xA0, 0x0A, 0x02, 0x80, 0x38, 0x0C, 0x00,
  0xC0, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x10, 0x60, 0x08, 0x0C, 0x06,
  0x01, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x40, 0x01, 0xB0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x01, 0x30, 0x00, 0xC6, 0x00, 0x60, 0x80, 0x10,
  0x30, 0x08, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x50, 0x00, 0x36, 0x00, 0x08, 0x80, 0x02, 0x30, 0x01,
  0x8C, 0x00, 0x41, 0x00, 0x30, 0x60, 0x08, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x10, 0x30, 0x06, 0x08, 0x00, 0x86, 0x00, 0x31, 0x00, 0x04,
  0x40, 0x01, 0x30, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x13, 0x18, 0x01, 0x20, 0xC0,
  0x36, 0x02, 0x02, 0x40, 0x30, 0x64, 0x01, 0x8C, 0xC0, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 29, 25, 11, -29 },
  { 12, 7, 11, 25, 9, -30 },
  { 22, 23, 29, 25, 1, -29 },
  { 106, 19, 37, 25, 3, -33 },
  { 194, 23, 29, 25, 1, -29 },
  { 278, 21, 29, 25, 2, -29 },
  { 355, 1, 11, 25, 12, -30 },
  { 357, 10, 37, 25, 9, -31 },
  { 404, 10, 37, 25, 5, -31 },
  { 451, 21, 20, 25, 2, -23 },
  { 504, 19, 19, 25, 3, -22 },
  { 550, 5, 11, 25, 9, -4 },
  { 557, 11, 1, 25, 7, -13 },
  { 559, 3, 3, 25, 11, -3 },
  { 561, 16, 37, 25, 4, -31 },
  { 635, 19, 29, 25, 3, -29 },
  { 704, 20, 29, 25, 3, -29 },
  { 777, 19, 29, 25, 3, -29 },
  { 846, 17, 29, 25, 3, -29 },
  { 908, 21, 29, 25, 2, -29 },
  { 985, 18, 29, 25, 3, -29 },
  { 1051, 18, 29, 25, 3, -29 },
  { 1117, 18, 29, 25, 3, -29 },
  { 1183, 19, 29, 25, 3, -29 },
  { 1252, 18, 29, 25, 3, -29 },
  { 1318, 3, 21, 25, 11, -21 },
  { 1326, 5, 28, 25, 9, -21 },
  { 1344, 18, 22, 25, 3, -24 },
  { 1394, 19, 9, 25, 3, -17 },
  { 1416, 18, 22, 25, 3, -24 },
  { 1466, 17, 29, 25, 4, -29 },
  { 1528, 17, 33, 25, 4, -29 },
  { 1599, 21, 29, 25, 2, -29 },
  { 1676, 17, 29, 25, 4, -29 },
  { 1738, 18, 29, 25, 3, -29 },
  { 1804, 18, 29, 25, 4, -29 },
  { 1870, 17, 29, 25, 4, -29 },
  { 1932, 17, 29, 25, 4, -29 },
  { 1994, 18, 29, 25, 3, -29 },
  { 2060, 17, 29, 25, 4, -29 },
  { 2122, 17, 29, 25, 4, -29 },
  { 2184, 15, 29, 25, 4, -29 },
  { 2239, 19, 29, 25, 4, -29 },
  { 2308, 16, 29, 25, 6, -29 },
  { 2366, 18, 29, 25, 3, -29 },
  { 2432, 17, 29, 25, 4, -29 },
  { 2494, 19, 29, 25, 3, -29 },
  { 2563, 18, 29, 25, 4, -29 },
  { 2629, 19, 34, 25, 3, -29 },
  { 2710, 18, 29, 25, 4, -29 },
  { 2776, 20, 29, 25, 2, -29 },
  { 2849, 21, 29, 25, 2, -29 },
  { 2926, 17, 29, 25, 4, -29 },
  { 2988, 21, 29, 25, 2, -29 },
  { 3065, 20, 29, 25, 2, -29 },
  { 3138, 21, 29, 25, 2, -29 },
  { 3215, 23, 29, 25, 1, -29 },
  { 3299, 21, 29, 25, 2, -29 },
  { 3376, 11, 37, 25, 10, -31 },
  { 3427, 16, 37, 25, 4, -31 },
  { 3501, 10, 37, 25, 4, -31 },
  { 3548, 19, 16, 25, 3, -29 },
  { 3586, 20, 1, 25, 2, 5 },
  { 3589, 6, 7, 25, 8, -31 },
  { 3595, 19, 21, 25, 3, -21 },
  { 3645, 17, 30, 25, 5, -30 },
  { 3709, 17, 21, 25, 4, -21 },
  { 3754, 17, 30, 25, 3, -30 },
  { 3818, 17, 21, 25, 4, -21 },
  { 3863, 19, 30, 25, 3, -30 },
  { 3935, 20, 30, 25, 3, -22 },
  { 4010, 15, 30, 25, 5, -30 },
  { 4067, 17, 31, 25, 5, -31 },
  { 4133, 14, 39, 25, 4, -31 },
  { 4202, 18, 30, 25, 5, -30 },
  { 4270, 17, 30, 25, 4, -30 },
  { 4334, 19, 21, 25, 3, -21 },
  { 4384, 15, 21, 25, 5, -21 },
  { 4424, 18, 21, 25, 3, -21 },
  { 4472, 17, 29, 25, 5, -21 },
  { 4534, 17, 29, 25, 3, -21 },
  { 4596, 20, 21, 25, 3, -21 },
  { 4649, 18, 21, 25, 3, -21 },
  { 4697, 19, 29, 25, 2, -29 },
  { 4766, 15, 21, 25, 5, -21 },
  { 4806, 17, 21, 25, 4, -21 },
  { 4851, 22, 21, 25, 1, -21 },
  { 4909, 18, 21, 25, 3, -21 },
  { 4957, 18, 29, 25, 3, -21 },
  { 5023, 17, 21, 25, 4, -21 },
  { 5068, 15, 37, 25, 5, -31 },
  { 5138, 1, 37, 25, 12, -31 },
  { 5143, 15, 37, 25, 5, -31 },
  { 5213, 20, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_EXTRALIGHT41PT7B_H_
