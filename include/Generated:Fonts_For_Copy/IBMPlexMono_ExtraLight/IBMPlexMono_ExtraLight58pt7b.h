#ifndef _IBMPLEXMONO_EXTRALIGHT58PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCC, 0x63,
  0x18, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0xFF, 0xEE, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x38, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x30, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0x86, 0x3E, 0x03, 0x80, 0xC0, 0xE0, 0xE0, 0x18, 0x0E, 0x18, 0x03, 0x00,
  0xE7, 0x00, 0x60, 0x0C, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0xF0, 0x30, 0x00, 0x0F, 0x86, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0xC0,
  0x06, 0x00, 0xDC, 0x00, 0xC0, 0x19, 0xC0, 0x18, 0x07, 0x1C, 0x03, 0x01,
  0xC1, 0xC0, 0x60, 0x70, 0x1F, 0x0C, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0xE0, 0xF0, 0x00, 0x33, 0x80,
  0x70, 0x00, 0x66, 0x00, 0x60, 0x01, 0x98, 0x00, 0x60, 0x03, 0x30, 0x00,
  0xC0, 0x0C, 0x60, 0x01, 0x80, 0x18, 0xC0, 0x03, 0x00, 0x61, 0x80, 0x06,
  0x01, 0x83, 0x00, 0x0C, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x0C, 0x00, 0x30,
  0x18, 0x18, 0x00, 0x60, 0x60, 0x30, 0x00, 0xC0, 0x80, 0x30, 0x03, 0x03,
  0x00, 0x70, 0x0E, 0x0C, 0x00, 0x70, 0x78, 0x18, 0x00, 0x7F, 0xE0, 0x40,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x70, 0x78,
  0x01, 0x81, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0x60,
  0x18, 0x18, 0x00, 0x60, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x60, 0x01, 0x83,
  0x00, 0xC0, 0x03, 0x0C, 0x01, 0x80, 0x06, 0x18, 0x03, 0x00, 0x0C, 0x60,
  0x06, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x33, 0x00, 0x18, 0x00, 0xC4, 0x00,
  0x18, 0x01, 0x98, 0x00, 0x38, 0x06, 0x60, 0x00, 0x38, 0x3C, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x38, 0xE0, 0x07, 0xF1, 0xC1, 0xC0, 0x18, 0x0E, 0x03, 0x80, 0x60,
  0x30, 0x07, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x06, 0x00, 0x18, 0x18, 0x18,
  0x00, 0x30, 0x60, 0xE0, 0x00, 0xE1, 0x03, 0x00, 0x01, 0xCC, 0x0C, 0x00,
  0x03, 0xB0, 0x30, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x19,
  0xC0, 0xE0, 0x00, 0xC3, 0x81, 0xC0, 0x07, 0x07, 0x03, 0xC0, 0x78, 0x0E,
  0x07, 0xFF, 0x80, 0x18, 0x07, 0xF8, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x07, 0xF0, 0x0C, 0x01, 0xF3, 0xF0, 0x60,
  0xFE, 0x03, 0xFB, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x38, 0x71, 0xE3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x18, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0xC1, 0x80,
  0x00, 0xF0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x07, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x70,
  0xF0, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x7F, 0x80, 0x11, 0xFF, 0xF0, 0x09, 0xE0,
  0x3E, 0x05, 0x80, 0x07, 0x87, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1, 0xE0, 0x01,
  0xC0, 0x7C, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x7F, 0x80, 0x31, 0xFF, 0xF0, 0x19, 0xE0, 0x3E, 0x0D, 0x80,
  0x07, 0x8D, 0x80, 0x00, 0xE6, 0x80, 0x00, 0x33, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0xE0, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x07, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xB3, 0x80, 0x00, 0xD8, 0xF0, 0x00,
  0xD8, 0x3E, 0x03, 0xCC, 0x07, 0xFF, 0x86, 0x00, 0xFF, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xC0, 0x1C, 0x7C, 0xF9,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xE1, 0xC7, 0x8E,
  0x1C, 0x38, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0xC0, 0xE0, 0x01,
  0xC3, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x07, 0xE3, 0x40, 0x1F, 0xF3, 0xC0, 0x3C, 0x1B, 0xC0, 0x30, 0x0F, 0xC0,
  0x60, 0x07, 0xC0, 0x60, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x70, 0x07, 0x40, 0x38, 0x0B, 0x60, 0x1F, 0xFB, 0x60, 0x0F, 0xE3, 0x60,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xC0, 0x78, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x78, 0x18,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x1C, 0x60, 0x00, 0x0B, 0x1C, 0x00, 0x02, 0xC3, 0x80, 0x01, 0x30, 0x70,
  0x00, 0xCC, 0x0F, 0x01, 0xE3, 0x01, 0xFF, 0xF0, 0xC0, 0x0F, 0xE0, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x0F,
  0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0,
  0x03, 0x81, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1F, 0x00, 0x03,
  0x0C, 0xE0, 0x00, 0xC6, 0x18, 0x00, 0x33, 0x87, 0x00, 0x0D, 0xC0, 0xE0,
  0x03, 0xE0, 0x18, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFD, 0x80, 0x00, 0xDE, 0xC0, 0x00, 0x6F, 0x60, 0x00,
  0x67, 0x98, 0x00, 0x33, 0xCC, 0x00, 0x31, 0xE3, 0x00, 0x18, 0xF1, 0x80,
  0x0C, 0x78, 0x60, 0x0C, 0x3C, 0x30, 0x06, 0x1E, 0x0C, 0x06, 0x0F, 0x06,
  0x03, 0x07, 0x83, 0x83, 0x03, 0xC0, 0xC1, 0x81, 0xE0, 0x60, 0x80, 0xF0,
  0x18, 0xC0, 0x78, 0x0C, 0x60, 0x3C, 0x03, 0x60, 0x1E, 0x01, 0xB0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x04, 0x00,
  0xF0, 0x04, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0xCE, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0,
  0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x03, 0xC0,
  0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x03, 0x03, 0xC0,
  0x03, 0x03, 0xC0, 0x01, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x30, 0x00, 0x1F, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x30, 0x00, 0x1F, 0x18, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x70, 0x03, 0x30, 0x03, 0x80, 0x11, 0x80, 0x3C, 0x01,
  0x84, 0x01, 0xB0, 0x0C, 0x30, 0x0D, 0x80, 0x61, 0x80, 0x6C, 0x03, 0x0C,
  0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x8C, 0x06, 0x18, 0x18,
  0x60, 0x30, 0xC0, 0xC1, 0x81, 0x86, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0x60,
  0x41, 0x83, 0x01, 0x86, 0x04, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x61, 0x81,
  0x8C, 0x03, 0x0C, 0x0C, 0x60, 0x0C, 0x60, 0x63, 0x00, 0x63, 0x03, 0x18,
  0x03, 0x18, 0x19, 0x80, 0x0C, 0xC0, 0xCC, 0x00, 0x66, 0x06, 0x60, 0x03,
  0x30, 0x36, 0x00, 0x19, 0x01, 0xB0, 0x00, 0x78, 0x05, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0xE0, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x3E, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x16, 0x03, 0x80, 0x06, 0xC0, 0x3C, 0x07, 0x8F, 0xC3, 0xFF,
  0xC1, 0xF8, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x0F, 0xE0, 0x18, 0x7F, 0xF0, 0x33, 0xC0, 0xF8,
  0x6C, 0x00, 0x38, 0xD0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x76,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x68, 0x00, 0x1C,
  0xD8, 0x00, 0x71, 0x9E, 0x07, 0xC3, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB8, 0x00, 0x04, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80,
  0xF0, 0x1E, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x03, 0x03,
  0xFF, 0xC3, 0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x0B, 0x18,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x0B, 0x0E, 0x00, 0x33, 0x07,
  0x80, 0xE3, 0x03, 0xFF, 0xC3, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80,
  0xE0, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x40, 0x00, 0xFF, 0xE8, 0x00, 0x78, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x0F, 0xE0, 0x61, 0xFF, 0xC3, 0x38, 0x0F, 0x1B, 0x00, 0x1C, 0xD0, 0x00,
  0x77, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x6F, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x73, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xF0, 0x00, 0x31, 0xD8, 0x00,
  0x19, 0xC6, 0x00, 0x0D, 0xC3, 0x80, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x19, 0xFE, 0x0F,
  0xF3, 0x60, 0xE3, 0x0F, 0x68, 0x0C, 0x80, 0x6E, 0x00, 0xE0, 0x0D, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00,
  0x78, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x3C, 0x00,
  0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x03,
  0xC0, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x01, 0xE0, 0x06,
  0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x1E,
  0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0x30,
  0x01, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0,
  0x03, 0x00, 0x18, 0x00, 0xFE, 0x06, 0x1F, 0xFC, 0x33, 0x80, 0xF1, 0xB0,
  0x01, 0xCD, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0,
  0x07, 0x01, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0x87, 0xFF, 0x03, 0x3C,
  0x0F, 0x86, 0xC0, 0x03, 0x8D, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00,
  0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x66, 0x80,
  0x01, 0xCD, 0x80, 0x07, 0x19, 0xE0, 0x7C, 0x30, 0xFF, 0xE0, 0x60, 0x7F,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xC3, 0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x0B,
  0x18, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x0B, 0x0E, 0x00, 0x33,
  0x07, 0x80, 0xE3, 0x03, 0xFF, 0xC3, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFC, 0x00, 0xCF, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x03,
  0xC3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xE0, 0x7C, 0x01, 0xE0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x73,
  0x80, 0x02, 0xC7, 0x00, 0x1B, 0x1F, 0x03, 0xCC, 0x1F, 0xFE, 0x30, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x04, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x09, 0x00, 0x1A, 0x00, 0x33,
  0x00, 0x36, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0x98,
  0x03, 0x10, 0x03, 0x30, 0x06, 0x30, 0x04, 0x20, 0x0C, 0x60, 0x18, 0x60,
  0x18, 0xC0, 0x30, 0xC0, 0x60, 0x80, 0x61, 0x80, 0xC1, 0x80, 0xC3, 0x01,
  0x83, 0x01, 0x02, 0x03, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x18,
  0x0C, 0x18, 0x18, 0x30, 0x18, 0x30, 0x30, 0x60, 0x30, 0x60, 0x60, 0x80,
  0x20, 0x80, 0x43, 0x00, 0x63, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01,
  0x8C, 0x03, 0x10, 0x01, 0x18, 0x06, 0x60, 0x03, 0x20, 0x0C, 0xC0, 0x06,
  0x40, 0x09, 0x80, 0x0D, 0x80, 0x1A, 0x00, 0x0B, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0xC0, 0x01,
  0x80, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x7F, 0x80, 0x00, 0x87, 0x0E, 0x00,
  0x0C, 0x30, 0x38, 0x00, 0x63, 0x00, 0xE0, 0x03, 0x18, 0x03, 0x80, 0x31,
  0x80, 0x0E, 0x01, 0x8C, 0x00, 0x38, 0x18, 0x40, 0x00, 0xE1, 0xC6, 0x00,
  0x03, 0xFC, 0x30, 0x00, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 5, 40, 35, 15, -40 },
  { 26, 11, 15, 35, 12, -43 },
  { 47, 33, 40, 35, 1, -40 },
  { 212, 27, 54, 35, 4, -47 },
  { 395, 31, 42, 35, 2, -41 },
  { 558, 30, 42, 35, 2, -41 },
  { 716, 2, 15, 35, 16, -43 },
  { 720, 14, 52, 35, 13, -44 },
  { 811, 14, 52, 35, 7, -44 },
  { 902, 29, 29, 35, 3, -32 },
  { 1008, 27, 28, 35, 4, -32 },
  { 1103, 7, 15, 35, 13, -5 },
  { 1117, 15, 2, 35, 10, -19 },
  { 1121, 5, 5, 35, 15, -5 },
  { 1125, 23, 52, 35, 6, -44 },
  { 1275, 27, 42, 35, 4, -41 },
  { 1417, 27, 40, 35, 5, -40 },
  { 1552, 25, 41, 35, 5, -41 },
  { 1681, 25, 42, 35, 4, -41 },
  { 1813, 29, 40, 35, 3, -40 },
  { 1958, 25, 41, 35, 5, -40 },
  { 2087, 25, 41, 35, 5, -40 },
  { 2216, 26, 40, 35, 4, -40 },
  { 2346, 27, 42, 35, 4, -41 },
  { 2488, 25, 41, 35, 5, -41 },
  { 2617, 5, 31, 35, 15, -31 },
  { 2637, 7, 41, 35, 13, -31 },
  { 2673, 25, 32, 35, 5, -34 },
  { 2773, 27, 13, 35, 4, -24 },
  { 2817, 25, 32, 35, 5, -34 },
  { 2917, 23, 41, 35, 6, -41 },
  { 3035, 24, 47, 35, 5, -41 },
  { 3176, 29, 40, 35, 3, -40 },
  { 3321, 24, 40, 35, 6, -40 },
  { 3441, 26, 42, 35, 4, -41 },
  { 3578, 25, 40, 35, 6, -40 },
  { 3703, 24, 40, 35, 6, -40 },
  { 3823, 24, 40, 35, 6, -40 },
  { 3943, 26, 42, 35, 4, -41 },
  { 4080, 24, 40, 35, 5, -40 },
  { 4200, 25, 40, 35, 5, -40 },
  { 4325, 22, 41, 35, 5, -40 },
  { 4438, 26, 40, 35, 6, -40 },
  { 4568, 23, 40, 35, 8, -40 },
  { 4683, 25, 40, 35, 5, -40 },
  { 4808, 24, 40, 35, 5, -40 },
  { 4928, 27, 42, 35, 4, -41 },
  { 5070, 25, 40, 35, 6, -40 },
  { 5195, 27, 50, 35, 4, -41 },
  { 5364, 25, 40, 35, 6, -40 },
  { 5489, 27, 42, 35, 4, -41 },
  { 5631, 31, 40, 35, 2, -40 },
  { 5786, 24, 41, 35, 5, -40 },
  { 5909, 29, 40, 35, 3, -40 },
  { 6054, 29, 40, 35, 3, -40 },
  { 6199, 29, 40, 35, 3, -40 },
  { 6344, 32, 40, 35, 1, -40 },
  { 6504, 29, 40, 35, 3, -40 },
  { 6649, 14, 52, 35, 15, -44 },
  { 6740, 23, 52, 35, 6, -44 },
  { 6890, 14, 52, 35, 6, -44 },
  { 6981, 27, 22, 35, 4, -40 },
  { 7056, 28, 2, 35, 3, 7 },
  { 7063, 8, 10, 35, 11, -44 },
  { 7073, 27, 32, 35, 4, -31 },
  { 7181, 23, 44, 35, 7, -43 },
  { 7308, 23, 32, 35, 6, -31 },
  { 7400, 24, 44, 35, 4, -43 },
  { 7532, 25, 32, 35, 5, -31 },
  { 7632, 26, 43, 35, 5, -43 },
  { 7772, 27, 45, 35, 5, -33 },
  { 7924, 21, 43, 35, 7, -43 },
  { 8037, 24, 43, 35, 7, -43 },
  { 8166, 20, 55, 35, 6, -43 },
  { 8304, 25, 43, 35, 8, -43 },
  { 8439, 25, 43, 35, 5, -43 },
  { 8574, 27, 31, 35, 4, -31 },
  { 8679, 21, 31, 35, 7, -31 },
  { 8761, 25, 32, 35, 5, -31 },
  { 8861, 23, 43, 35, 7, -31 },
  { 8985, 24, 43, 35, 4, -31 },
  { 9114, 27, 30, 35, 5, -30 },
  { 9216, 25, 32, 35, 5, -31 },
  { 9316, 28, 40, 35, 2, -40 },
  { 9456, 22, 31, 35, 6, -30 },
  { 9542, 25, 30, 35, 5, -30 },
  { 9636, 31, 30, 35, 2, -30 },
  { 9753, 25, 30, 35, 5, -30 },
  { 9847, 26, 42, 35, 4, -30 },
  { 9984, 23, 30, 35, 6, -30 },
  { 10071, 21, 52, 35, 7, -44 },
  { 10208, 2, 52, 35, 16, -44 },
  { 10221, 21, 52, 35, 7, -44 },
  { 10358, 29, 11, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_EXTRALIGHT58PT7B_H_
