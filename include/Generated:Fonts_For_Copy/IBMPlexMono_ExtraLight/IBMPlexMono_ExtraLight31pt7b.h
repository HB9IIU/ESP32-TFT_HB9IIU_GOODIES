#ifndef _IBMPLEXMONO_EXTRALIGHT31PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x0F, 0xC0, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x01, 0x0C, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x10, 0xC0, 0x08, 0x40, 0xFC, 0x3F, 0x06, 0x10, 0x02, 0x08,
  0x01, 0x04, 0x00, 0x86, 0x00, 0x42, 0x00, 0x21, 0x03, 0xE0, 0xFC, 0x10,
  0x40, 0x08, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x03, 0x13, 0x8C,
  0x21, 0x90, 0x41, 0x20, 0x80, 0xC1, 0x00, 0x82, 0x01, 0x04, 0x03, 0x08,
  0x03, 0x10, 0x01, 0xF0, 0x00, 0x5C, 0x00, 0x84, 0x01, 0x04, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x30, 0x10, 0x50, 0x20, 0x90, 0x43, 0x18, 0x8C, 0x0F,
  0xE0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3E, 0x01, 0xA1, 0x80, 0xA0,
  0x40, 0x90, 0x10, 0x48, 0x08, 0x44, 0x04, 0x22, 0x02, 0x21, 0x02, 0x20,
  0x43, 0x10, 0x1F, 0x10, 0x00, 0x00, 0x00, 0x07, 0x80, 0x06, 0x30, 0x26,
  0x08, 0x22, 0x04, 0x11, 0x01, 0x10, 0x80, 0x90, 0x40, 0x48, 0x20, 0x48,
  0x18, 0x24, 0x06, 0x34, 0x01, 0xE0, 0x07, 0xC0, 0x08, 0x60, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x1C, 0x00, 0x32, 0x0F, 0x41, 0x08, 0x41, 0x88, 0xC0, 0xC8,
  0x80, 0x68, 0x80, 0x38, 0x80, 0x18, 0x40, 0x18, 0x40, 0x24, 0x30, 0x42,
  0x1F, 0x83, 0xFF, 0x03, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x03, 0xC0, 0x40, 0x40, 0x80, 0x81,
  0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x83, 0x04, 0x10, 0x20, 0x86, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x81, 0x78, 0x8E, 0x0F, 0xF0,
  0x01, 0x80, 0x01, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x10, 0x08, 0x08,
  0x10, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x76, 0x64, 0x4C, 0x88, 0xFF,
  0xFC, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80,
  0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x0C, 0x1C, 0x18, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x60,
  0x02, 0x40, 0x04, 0x80, 0x19, 0x80, 0x21, 0x00, 0xC1, 0x83, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x0D, 0x00, 0x32, 0x00, 0xC4, 0x03, 0x08, 0x0C, 0x10,
  0x20, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x0F, 0xFF, 0xC0, 0x1F, 0x81, 0x03, 0x10, 0x09,
  0x00, 0x28, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x7F, 0xFC, 0x0F, 0xC1, 0x83, 0x18, 0x04,
  0x80, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x03, 0x03,
  0xE0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x02, 0x80, 0x23, 0x06, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x68, 0x00, 0x48, 0x00, 0x88, 0x01, 0x88, 0x01, 0x08, 0x02, 0x08, 0x04,
  0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x40,
  0x08, 0x40, 0x08, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x7F, 0xF2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x7C, 0x2C, 0x19, 0x80, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xE0, 0x05, 0x80, 0x66,
  0x06, 0x0F, 0xC0, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x7C, 0x2C, 0x19, 0x80, 0x68, 0x01,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x63,
  0x06, 0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x1A,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0xE0, 0xC2, 0x00, 0x90,
  0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0xD0, 0x02, 0x20, 0x08, 0x60, 0xC0,
  0x7C, 0x0E, 0x0C, 0x60, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x14, 0x00, 0x58, 0x02, 0x30, 0x30, 0x3F, 0x80, 0x0F, 0x81, 0x83,
  0x10, 0x0D, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xD0, 0x0A, 0x60, 0xD1, 0xF9, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0E, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x66, 0x44,
  0xC8, 0x80, 0x00, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x00,
  0x0F, 0x81, 0x83, 0x10, 0x0D, 0x80, 0x28, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x0F, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x0F, 0x50,
  0xC6, 0x8C, 0x1C, 0x40, 0xE2, 0x03, 0x10, 0x18, 0x80, 0xC4, 0x06, 0x20,
  0x31, 0x03, 0x88, 0x1C, 0x21, 0x60, 0xF3, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x03,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x10, 0x0C,
  0x10, 0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x1F, 0xFC, 0x10,
  0x04, 0x20, 0x04, 0x20, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0xFF, 0xC4, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x34, 0x03, 0x3F, 0xF1, 0x00, 0x48, 0x01, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x03, 0x7F,
  0xE0, 0x07, 0xE0, 0x60, 0xC3, 0x00, 0x88, 0x01, 0x60, 0x05, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x12, 0x00, 0x4C, 0x02,
  0x18, 0x30, 0x1F, 0x80, 0xFF, 0x84, 0x03, 0x20, 0x09, 0x00, 0x28, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00,
  0x68, 0x06, 0x7F, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x60, 0xC3, 0x01, 0x88, 0x02, 0x40,
  0x05, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0xFE, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x16,
  0x00, 0xCC, 0x05, 0x18, 0x34, 0x1F, 0x10, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F,
  0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFC, 0x3F, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x36, 0x0C,
  0x3E, 0x00, 0x80, 0x0E, 0x00, 0x68, 0x01, 0x20, 0x08, 0x80, 0x42, 0x02,
  0x08, 0x10, 0x20, 0xC0, 0x86, 0x02, 0x30, 0x08, 0xE0, 0x24, 0x80, 0xA1,
  0x03, 0x06, 0x08, 0x08, 0x20, 0x10, 0x80, 0x62, 0x00, 0x88, 0x01, 0x20,
  0x06, 0x80, 0x0A, 0x00, 0x10, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x5A, 0x02, 0xD0, 0x26,
  0x41, 0x32, 0x11, 0x88, 0x8C, 0x4C, 0x61, 0x43, 0x0A, 0x18, 0x60, 0xC1,
  0x06, 0x10, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0xC0, 0x0E, 0x00, 0x68, 0x03, 0x40, 0x19, 0x00, 0xC8, 0x06,
  0x20, 0x31, 0x01, 0x8C, 0x0C, 0x20, 0x61, 0x83, 0x04, 0x18, 0x30, 0xC0,
  0x86, 0x06, 0x30, 0x11, 0x80, 0xCC, 0x02, 0x60, 0x1B, 0x00, 0x58, 0x03,
  0xC0, 0x0C, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x63, 0x00, 0x44, 0x00, 0xC8,
  0x00, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x60, 0x02, 0x40, 0x04, 0x80, 0x19,
  0x80, 0x21, 0x00, 0xC1, 0x83, 0x01, 0xF8, 0x00, 0xFF, 0xC4, 0x01, 0xA0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x0D, 0xFF, 0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x30, 0x60,
  0x80, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x60, 0x02, 0x40, 0x04, 0x80, 0x19, 0x80, 0x21, 0x00, 0xC1, 0x83, 0x01,
  0xF8, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xF0, 0xFF, 0xC4, 0x01,
  0xA0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x0D, 0xFF, 0x88, 0x30, 0x40, 0x82, 0x06, 0x10, 0x10, 0x80,
  0x44, 0x03, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x04, 0x0F, 0xE0, 0xC0,
  0xE6, 0x00, 0xD0, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x58, 0x03, 0x30, 0x38, 0x3F, 0x80,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xB0, 0x04, 0x80, 0x62, 0x06, 0x0F, 0xC0, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x12, 0x00, 0x24, 0x00, 0xCC, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x81, 0x00, 0x82, 0x01, 0x04, 0x02, 0x10,
  0x06, 0x20, 0x04, 0x40, 0x09, 0x80, 0x1A, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xA0, 0x41, 0x41, 0x82, 0x82, 0x85, 0x85, 0x09, 0x12, 0x12, 0x24,
  0x24, 0x44, 0x48, 0x88, 0x92, 0x11, 0x24, 0x32, 0x48, 0x28, 0x90, 0x51,
  0x40, 0xA2, 0x80, 0xC7, 0x01, 0x86, 0x03, 0x00, 0x40, 0x03, 0x20, 0x02,
  0x30, 0x04, 0x10, 0x0C, 0x08, 0x08, 0x0C, 0x10, 0x04, 0x10, 0x06, 0x20,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x60,
  0x04, 0x20, 0x04, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x04, 0x20, 0x06,
  0x60, 0x02, 0xC0, 0x01, 0x80, 0x01, 0xA0, 0x00, 0x98, 0x00, 0x84, 0x00,
  0xC3, 0x00, 0x40, 0x80, 0x60, 0x20, 0x20, 0x18, 0x20, 0x04, 0x30, 0x01,
  0x10, 0x00, 0x90, 0x00, 0x28, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x7F, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xFF, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFF, 0x03, 0x00, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x86, 0x03, 0x04,
  0x04, 0x04, 0x10, 0x08, 0x20, 0x08, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x10,
  0xFF, 0xFE, 0xC4, 0x21, 0x10, 0x1F, 0x80, 0x60, 0xC1, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0xF8, 0x60, 0x10, 0x80, 0x23,
  0x00, 0x46, 0x00, 0x8C, 0x01, 0x08, 0x06, 0x18, 0x34, 0x0F, 0x8F, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0,
  0xCC, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x2A, 0x0C, 0x9F, 0x80, 0x0F, 0xC0,
  0x83, 0x08, 0x04, 0x80, 0x24, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x90, 0x08, 0x41, 0x81, 0xF0,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x21,
  0xF1, 0x18, 0x69, 0x00, 0xD0, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x12, 0x01, 0x88, 0x34,
  0x3E, 0x20, 0x0F, 0x81, 0x83, 0x10, 0x0C, 0x80, 0x28, 0x01, 0xC0, 0x06,
  0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0xA0,
  0x08, 0xC1, 0x81, 0xF0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0x80, 0x00, 0x3C, 0x3E,
  0x83, 0x06, 0x18, 0x08, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x60,
  0x20, 0xC1, 0x81, 0xF8, 0x08, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x07,
  0xFC, 0x60, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0D, 0x80, 0x63,
  0xFE, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0xF8, 0xA0, 0xD8, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x2F, 0xFC, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x03, 0x80, 0x24, 0x06, 0x20, 0x61, 0x06, 0x08,
  0x40, 0x46, 0x02, 0x58, 0x14, 0x40, 0xC1, 0x04, 0x04, 0x20, 0x31, 0x00,
  0xC8, 0x02, 0x40, 0x0A, 0x00, 0x20, 0xFE, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x9C, 0x7A, 0x8A, 0x1C,
  0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06,
  0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41,
  0x9F, 0x14, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x0F, 0x81,
  0x83, 0x10, 0x0D, 0x80, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x20, 0x18, 0xC1, 0x83, 0xF0,
  0x9F, 0x8A, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x2C, 0x02, 0xA0, 0xC9, 0xF8,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x88, 0xC3,
  0x48, 0x06, 0x80, 0x14, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0x90, 0x0C, 0x41, 0xA1, 0xF1, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0xFE, 0x3E, 0x05,
  0x80, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x7F, 0xFE, 0x1F, 0x83, 0x03, 0x10, 0x07, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xE0, 0x0D, 0xC0, 0xC3, 0xF8, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x14, 0x05, 0x30, 0x51, 0xF9, 0x80,
  0x0C, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x81, 0x86, 0x08,
  0x10, 0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x90, 0x02, 0x80, 0x14, 0x00,
  0xC0, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x41, 0x41, 0x42, 0x41, 0x42,
  0x41, 0x42, 0x22, 0x42, 0x22, 0x24, 0x22, 0x24, 0x22, 0x24, 0x12, 0x24,
  0x14, 0x28, 0x14, 0x18, 0x14, 0x18, 0x0C, 0x18, 0x0C, 0x80, 0x1A, 0x00,
  0x88, 0x08, 0x60, 0x81, 0x0C, 0x04, 0x40, 0x14, 0x00, 0xC0, 0x06, 0x00,
  0x68, 0x02, 0x20, 0x21, 0x82, 0x04, 0x30, 0x11, 0x00, 0x50, 0x03, 0xC0,
  0x05, 0x00, 0x36, 0x00, 0x88, 0x02, 0x20, 0x10, 0x40, 0x41, 0x03, 0x06,
  0x08, 0x08, 0x20, 0x21, 0x00, 0x44, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00,
  0x30, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x01,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x1F, 0xFF, 0x07, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x10, 0x03, 0x0F,
  0xC0, 0x07, 0x00, 0x10, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x06, 0x00, 0x1F, 0x07,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0xE0, 0x38, 0x02, 0xCC, 0x05,
  0x0C, 0x14, 0x08, 0x28, 0x08, 0x90, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 22, 19, 8, -22 },
  { 10, 5, 8, 19, 7, -23 },
  { 15, 17, 22, 19, 1, -22 },
  { 62, 15, 28, 19, 2, -25 },
  { 115, 17, 22, 19, 1, -22 },
  { 162, 16, 22, 19, 1, -22 },
  { 206, 1, 8, 19, 9, -23 },
  { 207, 8, 28, 19, 7, -24 },
  { 235, 7, 28, 19, 4, -24 },
  { 260, 16, 15, 19, 1, -17 },
  { 290, 15, 15, 19, 2, -17 },
  { 319, 4, 8, 19, 7, -3 },
  { 323, 8, 1, 19, 5, -10 },
  { 324, 3, 2, 19, 8, -2 },
  { 325, 12, 28, 19, 3, -24 },
  { 367, 15, 22, 19, 2, -22 },
  { 409, 15, 22, 19, 2, -22 },
  { 451, 13, 22, 19, 3, -22 },
  { 487, 13, 22, 19, 2, -22 },
  { 523, 16, 22, 19, 1, -22 },
  { 567, 13, 22, 19, 3, -22 },
  { 603, 13, 22, 19, 3, -22 },
  { 639, 14, 22, 19, 2, -22 },
  { 678, 14, 22, 19, 2, -22 },
  { 717, 13, 22, 19, 3, -22 },
  { 753, 3, 16, 19, 8, -16 },
  { 759, 4, 21, 19, 7, -16 },
  { 770, 13, 17, 19, 3, -18 },
  { 798, 15, 7, 19, 2, -13 },
  { 812, 13, 17, 19, 3, -18 },
  { 840, 13, 22, 19, 3, -22 },
  { 876, 13, 25, 19, 3, -22 },
  { 917, 16, 22, 19, 1, -22 },
  { 961, 13, 22, 19, 3, -22 },
  { 997, 14, 22, 19, 2, -22 },
  { 1036, 13, 22, 19, 3, -22 },
  { 1072, 13, 22, 19, 3, -22 },
  { 1108, 13, 22, 19, 3, -22 },
  { 1144, 14, 22, 19, 2, -22 },
  { 1183, 13, 22, 19, 3, -22 },
  { 1219, 13, 22, 19, 3, -22 },
  { 1255, 11, 22, 19, 3, -22 },
  { 1286, 14, 22, 19, 3, -22 },
  { 1325, 12, 22, 19, 4, -22 },
  { 1358, 13, 22, 19, 3, -22 },
  { 1394, 13, 22, 19, 3, -22 },
  { 1430, 15, 22, 19, 2, -22 },
  { 1472, 13, 22, 19, 3, -22 },
  { 1508, 15, 26, 19, 2, -22 },
  { 1557, 13, 22, 19, 3, -22 },
  { 1593, 14, 22, 19, 2, -22 },
  { 1632, 16, 22, 19, 1, -22 },
  { 1676, 13, 22, 19, 3, -22 },
  { 1712, 15, 22, 19, 2, -22 },
  { 1754, 15, 22, 19, 2, -22 },
  { 1796, 16, 22, 19, 1, -22 },
  { 1840, 17, 22, 19, 1, -22 },
  { 1887, 16, 22, 19, 1, -22 },
  { 1931, 8, 28, 19, 8, -24 },
  { 1959, 12, 28, 19, 3, -24 },
  { 2001, 8, 28, 19, 3, -24 },
  { 2029, 15, 12, 19, 2, -22 },
  { 2052, 15, 1, 19, 2, 4 },
  { 2054, 4, 5, 19, 6, -23 },
  { 2057, 15, 16, 19, 2, -16 },
  { 2087, 12, 23, 19, 4, -23 },
  { 2122, 13, 16, 19, 3, -16 },
  { 2148, 13, 23, 19, 2, -23 },
  { 2186, 13, 16, 19, 3, -16 },
  { 2212, 14, 23, 19, 3, -23 },
  { 2253, 14, 23, 19, 3, -17 },
  { 2294, 11, 23, 19, 4, -23 },
  { 2326, 13, 23, 19, 4, -23 },
  { 2364, 11, 29, 19, 3, -23 },
  { 2404, 13, 23, 19, 4, -23 },
  { 2442, 13, 23, 19, 3, -23 },
  { 2480, 14, 16, 19, 2, -16 },
  { 2508, 11, 16, 19, 4, -16 },
  { 2530, 13, 16, 19, 3, -16 },
  { 2556, 12, 22, 19, 4, -16 },
  { 2589, 13, 22, 19, 2, -16 },
  { 2625, 15, 16, 19, 2, -16 },
  { 2655, 13, 16, 19, 3, -16 },
  { 2681, 15, 22, 19, 1, -22 },
  { 2723, 12, 16, 19, 3, -16 },
  { 2747, 13, 16, 19, 3, -16 },
  { 2773, 16, 16, 19, 1, -16 },
  { 2805, 13, 16, 19, 3, -16 },
  { 2831, 14, 22, 19, 2, -16 },
  { 2870, 13, 16, 19, 3, -16 },
  { 2896, 12, 28, 19, 3, -24 },
  { 2938, 1, 28, 19, 9, -24 },
  { 2942, 12, 28, 19, 3, -24 },
  { 2984, 15, 6, 19, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_EXTRALIGHT31PT7B_H_
