#ifndef _IBMPLEXMONO_EXTRALIGHT9PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x36, 0x54, 0xAD, 0xB0, 0x4E, 0xDC, 0x3D, 0x64, 0x6D,
  0x9C, 0xBA, 0xCC, 0x64, 0x93, 0x69, 0x34, 0xC0, 0x6A, 0xA9, 0x95, 0x56,
  0x21, 0x3E, 0xA0, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x25, 0x25, 0x24,
  0xE9, 0x9D, 0x9E, 0x4C, 0xC4, 0x4F, 0x6A, 0x22, 0xCF, 0x75, 0x1B, 0xC0,
  0x31, 0x95, 0x27, 0xC8, 0xE8, 0xE9, 0x96, 0x68, 0xE9, 0x9E, 0xFA, 0x24,
  0x48, 0xE9, 0x69, 0x9E, 0xE9, 0x9E, 0x24, 0x88, 0x8C, 0x34, 0x84, 0x30,
  0xF0, 0xF0, 0x84, 0x36, 0x80, 0x6B, 0x24, 0x04, 0xEA, 0xF9, 0xF8, 0x60,
  0x23, 0x14, 0xA7, 0x44, 0xEA, 0xE9, 0x9E, 0xEA, 0x98, 0xBE, 0xE9, 0x99,
  0x9E, 0xF8, 0xF8, 0x8F, 0xF8, 0xE8, 0x88, 0xEA, 0x9B, 0x9F, 0x99, 0xF9,
  0x99, 0xF4, 0x44, 0x4F, 0xE4, 0x9A, 0xC0, 0xBA, 0xCC, 0xA9, 0x88, 0x88,
  0x8F, 0x9B, 0xDD, 0x99, 0x99, 0xDD, 0xB9, 0xE9, 0x99, 0x9E, 0xE9, 0x9E,
  0x88, 0xE9, 0x99, 0x9E, 0x42, 0xE9, 0x9E, 0xCB, 0xE9, 0xC3, 0x96, 0xF9,
  0x08, 0x42, 0x10, 0x99, 0x99, 0xAE, 0x8C, 0x94, 0xA6, 0x10, 0x8C, 0x6B,
  0xDD, 0x28, 0x8A, 0x88, 0xC5, 0x44, 0x8A, 0x98, 0x42, 0x10, 0x78, 0x88,
  0x88, 0x7C, 0xF2, 0x49, 0x27, 0x92, 0x24, 0x89, 0xD5, 0x57, 0x4A, 0xB0,
  0xF0, 0xC0, 0xE2, 0xEA, 0xD0, 0x88, 0xE9, 0x99, 0xE0, 0x6A, 0x8B, 0x60,
  0x27, 0xDB, 0x78, 0xEA, 0xF8, 0xF0, 0x34, 0xF4, 0x44, 0xF0, 0x1E, 0xAE,
  0x8F, 0x9E, 0x93, 0xDB, 0x68, 0x40, 0xC4, 0x44, 0xF0, 0x23, 0x92, 0x49,
  0xE0, 0x88, 0xBC, 0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xBD, 0xDD, 0xD0,
  0xF6, 0xDA, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xF6, 0xDE, 0x48,
  0xF4, 0x44, 0xF0, 0xE9, 0xE1, 0xE0, 0x47, 0xD0, 0x84, 0x1C, 0xB6, 0xDE,
  0xBA, 0xAC, 0x40, 0xAF, 0x7B, 0xAD, 0x00, 0xBA, 0x4A, 0xB0, 0x9A, 0xAC,
  0x44, 0x80, 0xE2, 0x48, 0xF0, 0x69, 0x44, 0x93, 0xFF, 0xCA, 0x3C, 0x96,
  0xDA,
};

const GFXglyph IBMPlexMono_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -7 },
  { 20, 2, 8, 5, 2, -7 },
  { 22, 2, 8, 5, 1, -7 },
  { 24, 5, 4, 5, 0, -5 },
  { 27, 4, 5, 5, 1, -5 },
  { 30, 1, 2, 5, 2, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 3, 8, 5, 1, -7 },
  { 36, 4, 6, 5, 1, -6 },
  { 39, 4, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 1, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 1, 5, 5, 2, -5 },
  { 68, 1, 6, 5, 2, -5 },
  { 69, 4, 5, 5, 1, -5 },
  { 72, 4, 3, 5, 1, -4 },
  { 74, 4, 5, 5, 1, -5 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 4, 7, 5, 1, -6 },
  { 84, 5, 6, 5, 0, -6 },
  { 88, 4, 6, 5, 1, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 4, 8, 5, 1, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 3, 8, 5, 2, -7 },
  { 173, 3, 8, 5, 1, -7 },
  { 176, 2, 8, 5, 1, -7 },
  { 178, 4, 3, 5, 1, -6 },
  { 180, 4, 1, 5, 1, 1 },
  { 181, 1, 2, 5, 2, -8 },
  { 182, 4, 5, 5, 1, -5 },
  { 185, 4, 7, 5, 1, -7 },
  { 189, 4, 5, 5, 1, -5 },
  { 192, 3, 7, 5, 1, -7 },
  { 195, 4, 5, 5, 1, -5 },
  { 198, 4, 7, 5, 1, -7 },
  { 202, 4, 8, 5, 1, -6 },
  { 206, 3, 7, 5, 1, -7 },
  { 209, 4, 7, 5, 1, -7 },
  { 213, 3, 9, 5, 1, -7 },
  { 217, 4, 7, 5, 1, -7 },
  { 221, 4, 7, 5, 1, -7 },
  { 225, 4, 5, 5, 1, -5 },
  { 228, 3, 5, 5, 1, -5 },
  { 230, 4, 5, 5, 1, -5 },
  { 233, 4, 7, 5, 1, -5 },
  { 237, 3, 7, 5, 1, -5 },
  { 240, 4, 5, 5, 1, -5 },
  { 243, 4, 5, 5, 1, -5 },
  { 246, 5, 6, 5, 0, -6 },
  { 250, 3, 5, 5, 1, -5 },
  { 252, 4, 5, 5, 1, -5 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 4, 5, 5, 1, -5 },
  { 262, 4, 7, 5, 1, -5 },
  { 266, 4, 5, 5, 1, -5 },
  { 269, 3, 8, 5, 1, -7 },
  { 272, 1, 8, 5, 2, -7 },
  { 273, 3, 8, 5, 1, -7 },
  { 276, 4, 2, 5, 1, -4 },
};

const GFXfont IBMPlexMono_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_EXTRALIGHT9PT7B_H_
