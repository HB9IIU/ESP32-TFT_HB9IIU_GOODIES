#ifndef _IBMPLEXMONO_EXTRALIGHT55PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xB8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x03, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x01, 0xFF, 0xC0,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0x86, 0x3E, 0x03, 0x81, 0x81, 0xC1, 0x80, 0x60, 0x38, 0xE0, 0x18, 0x07,
  0x30, 0x06, 0x00, 0x8C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x60, 0x00,
  0x1E, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x18, 0xF8, 0x00, 0x06, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x34, 0x00, 0x60, 0x0F, 0x80, 0x18, 0x07, 0x70, 0x06, 0x01, 0x8E, 0x01,
  0x80, 0xE1, 0xE0, 0x60, 0x70, 0x1E, 0x18, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x70, 0x70, 0x00, 0x31, 0x80, 0x70,
  0x00, 0xC3, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x60, 0x06, 0x18, 0x00, 0xC0,
  0x08, 0x30, 0x01, 0x80, 0x30, 0x60, 0x03, 0x00, 0xC0, 0xC0, 0x06, 0x01,
  0x81, 0x80, 0x0C, 0x06, 0x03, 0x00, 0x18, 0x08, 0x06, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x07, 0x06, 0x00,
  0x1C, 0x1C, 0x0C, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0C, 0x0F, 0xF8, 0x00, 0x30, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x18, 0x01,
  0x81, 0x80, 0x30, 0x03, 0x06, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0x60, 0x10,
  0x18, 0x00, 0xC0, 0x60, 0x30, 0x01, 0x81, 0x80, 0x60, 0x03, 0x03, 0x00,
  0xC0, 0x06, 0x0C, 0x01, 0x80, 0x0C, 0x10, 0x03, 0x00, 0x18, 0x60, 0x06,
  0x00, 0x31, 0x80, 0x06, 0x00, 0xC3, 0x00, 0x0E, 0x01, 0x8C, 0x00, 0x0E,
  0x0E, 0x18, 0x00, 0x0F, 0xF8, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x3F, 0x0E, 0x30, 0x03, 0xF1, 0x83,
  0x80, 0x30, 0x30, 0x1C, 0x03, 0x03, 0x00, 0xE0, 0x30, 0x60, 0x07, 0x02,
  0x06, 0x00, 0x38, 0x20, 0xC0, 0x01, 0x86, 0x0C, 0x00, 0x0C, 0x60, 0xC0,
  0x00, 0x66, 0x0C, 0x00, 0x07, 0x60, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x33, 0x03,
  0x00, 0x06, 0x18, 0x38, 0x00, 0xE0, 0xC1, 0xF0, 0x3C, 0x06, 0x07, 0xFF,
  0x00, 0x70, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x07, 0xC0, 0x10, 0x07, 0xBF, 0x02, 0x07, 0xE0, 0xFC, 0x47, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x38,
  0x71, 0xE3, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x04, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x03, 0x98, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x78, 0x18,
  0x00, 0x3C, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x01, 0xE0,
  0x38, 0x00, 0x70, 0x30, 0x00, 0x30, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x8E, 0x00, 0x03, 0x98, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x33, 0x80, 0x00, 0xC3, 0x80, 0x07, 0x83, 0xC0,
  0x3E, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x7F, 0x80, 0x31, 0xFF, 0xE0, 0x37,
  0x80, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x7F, 0x80, 0x63, 0xFF, 0xC0, 0xCE, 0x03, 0xC3, 0x30, 0x01, 0xE6,
  0x80, 0x00, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x60, 0xE0, 0x03,
  0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xE0,
  0x3E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x03, 0xC0, 0x78,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0xE0, 0x00,
  0xE0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x98, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x16, 0x1C, 0x00, 0x76,
  0x0F, 0x01, 0xE6, 0x07, 0xFF, 0x8C, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBF, 0xF7,
  0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x38,
  0x71, 0xE3, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x04, 0x18, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x80,
  0x60, 0x03, 0x81, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00,
  0x00, 0x2C, 0x00, 0xF8, 0x58, 0x07, 0xFC, 0xB0, 0x1E, 0x0D, 0xE0, 0x30,
  0x0B, 0xC0, 0xC0, 0x0F, 0x81, 0x80, 0x1F, 0x02, 0x00, 0x1E, 0x0C, 0x00,
  0x3C, 0x18, 0x00, 0x78, 0x30, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x03,
  0xC1, 0x80, 0x07, 0x83, 0x00, 0x0F, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x3C,
  0x0C, 0x00, 0x78, 0x18, 0x01, 0xF0, 0x38, 0x05, 0xE0, 0x38, 0x0B, 0xC0,
  0x3F, 0xE7, 0x80, 0x3F, 0x8D, 0x80, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0x87, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x1E, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x00,
  0x03, 0x86, 0x00, 0x1E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x03, 0x70, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x38, 0x00, 0x07, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x0B, 0x0E, 0x00,
  0x3B, 0x07, 0xC0, 0xF3, 0x01, 0xFF, 0xE3, 0x00, 0x7F, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x9C, 0x00, 0x18, 0x70, 0x03,
  0x81, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0x61, 0xF0, 0x00, 0x31, 0xDC, 0x00, 0x19, 0xC6, 0x00, 0x0C,
  0xC1, 0x80, 0x06, 0xC0, 0xE0, 0x03, 0xC0, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x07, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFB, 0x00, 0x01,
  0xBD, 0x80, 0x00, 0xDE, 0x60, 0x00, 0xCF, 0x30, 0x00, 0x67, 0x8C, 0x00,
  0x23, 0xC6, 0x00, 0x31, 0xE3, 0x00, 0x18, 0xF0, 0xC0, 0x18, 0x78, 0x60,
  0x0C, 0x3C, 0x18, 0x0C, 0x1E, 0x0C, 0x06, 0x0F, 0x03, 0x06, 0x07, 0x81,
  0x83, 0x03, 0xC0, 0x41, 0x01, 0xE0, 0x31, 0x80, 0xF0, 0x18, 0xC0, 0x78,
  0x06, 0xC0, 0x3C, 0x03, 0x60, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x3D, 0x80,
  0x00, 0x79, 0x80, 0x00, 0xF3, 0x00, 0x01, 0xE3, 0x00, 0x03, 0xC6, 0x00,
  0x07, 0x86, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x18, 0x00,
  0x78, 0x18, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x30, 0x03, 0xC0, 0x60, 0x07,
  0x80, 0x60, 0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78,
  0x01, 0x80, 0xF0, 0x03, 0x01, 0xE0, 0x03, 0x03, 0xC0, 0x06, 0x07, 0x80,
  0x06, 0x0F, 0x00, 0x0C, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x78, 0x00,
  0x18, 0xF0, 0x00, 0x31, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0x67, 0x80, 0x00,
  0x6F, 0x00, 0x00, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0x00, 0x03, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x03,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0x00, 0x03, 0xC6, 0x00,
  0x01, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x78,
  0x03, 0xC0, 0x38, 0x00, 0x3C, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x0C, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0xC0, 0x01, 0x81, 0xE0, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x07, 0x00, 0x66, 0x00, 0xE0, 0x0C, 0xC0, 0x1C, 0x01, 0x98, 0x06, 0xC0,
  0x33, 0x00, 0xD8, 0x06, 0x60, 0x1B, 0x00, 0xC4, 0x02, 0x30, 0x10, 0x80,
  0xC6, 0x02, 0x18, 0x18, 0xC0, 0xC3, 0x02, 0x08, 0x18, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x30, 0x40, 0x41, 0x86, 0x18,
  0x0C, 0x30, 0xC3, 0x01, 0x86, 0x18, 0x60, 0x30, 0xC1, 0x18, 0x03, 0x10,
  0x23, 0x00, 0x62, 0x06, 0x60, 0x0C, 0xC0, 0xC8, 0x00, 0x98, 0x1B, 0x00,
  0x1B, 0x03, 0x60, 0x03, 0x60, 0x6C, 0x00, 0x6C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x02,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x1C,
  0x03, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3E, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x2C, 0x1C, 0x00, 0x26,
  0x07, 0x80, 0x73, 0xF1, 0xFF, 0xE0, 0xF8, 0x1F, 0xC0, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0F, 0xE0, 0x18,
  0x7F, 0xF0, 0x31, 0xC0, 0xF8, 0x66, 0x00, 0x78, 0xD0, 0x00, 0x31, 0xE0,
  0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x80, 0x00, 0x37, 0x00, 0x00, 0xCF, 0x00, 0x01, 0x9A, 0x00, 0x06, 0x33,
  0x00, 0x1C, 0x63, 0x81, 0xF0, 0xC3, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xE1, 0xC0,
  0x07, 0x03, 0xC0, 0x78, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x60,
  0x7F, 0xF0, 0xC3, 0xE0, 0x71, 0x8E, 0x00, 0x33, 0x18, 0x00, 0x16, 0x60,
  0x00, 0x3C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x01, 0xE3, 0x00, 0x02, 0xC7,
  0x00, 0x19, 0x87, 0xC0, 0xE3, 0x03, 0xFF, 0x86, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x30, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x30, 0x70, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE2, 0x00, 0x0F, 0xFE, 0x80,
  0x07, 0x01, 0xE0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x01, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC1, 0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x07, 0x8D, 0x00, 0x1C, 0xE0,
  0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x60, 0x00, 0xCE, 0x30, 0x00,
  0xDC, 0x38, 0x00, 0xF8, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x67, 0xF0, 0xFF, 0x36, 0x1C,
  0xE1, 0xDC, 0x03, 0x40, 0x7C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x30, 0x07, 0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x04, 0x00, 0xF0,
  0x02, 0x00, 0x78, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x1E, 0x00, 0x40, 0x0F,
  0x00, 0x20, 0x07, 0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x04, 0x00,
  0xF0, 0x02, 0x00, 0x78, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x1E, 0x00, 0x40,
  0x0F, 0x00, 0x20, 0x07, 0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x04,
  0x00, 0xF0, 0x02, 0x00, 0x78, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x18, 0x01,
  0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x07, 0x8D, 0x00, 0x1C, 0xE0, 0x00, 0xEC,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0x87, 0xFF, 0x03, 0x1C, 0x0F, 0x86,
  0x60, 0x07, 0x8D, 0x00, 0x03, 0x1E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x0C,
  0xF0, 0x00, 0x19, 0xA0, 0x00, 0x63, 0x30, 0x01, 0xC6, 0x38, 0x1F, 0x0C,
  0x3F, 0xF8, 0x18, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x0C, 0x3E, 0x07, 0x18, 0xE0, 0x03, 0x31, 0x80, 0x01,
  0x66, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x1E, 0x30, 0x00,
  0x2C, 0x70, 0x01, 0x98, 0x7C, 0x0E, 0x30, 0x3F, 0xF8, 0x60, 0x1F, 0xC0,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC,
  0x00, 0xCE, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1E, 0x01,
  0xF0, 0x38, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x73, 0x80, 0x0F,
  0x1E, 0x07, 0xB0, 0xFF, 0xE3, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x22, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0x40, 0x06, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xD8, 0x03, 0x30,
  0x06, 0x40, 0x19, 0x80, 0x22, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x20, 0x18,
  0xC0, 0x21, 0x00, 0xC2, 0x01, 0x0C, 0x04, 0x10, 0x18, 0x60, 0x60, 0xC0,
  0xC3, 0x03, 0x06, 0x06, 0x18, 0x18, 0x10, 0x30, 0x40, 0x80, 0x81, 0x03,
  0x0C, 0x06, 0x18, 0x18, 0x60, 0x30, 0xC0, 0xC3, 0x00, 0x86, 0x06, 0x10,
  0x04, 0x30, 0x11, 0x80, 0x31, 0x00, 0x8C, 0x01, 0x88, 0x06, 0x60, 0x04,
  0xC0, 0x32, 0x00, 0x26, 0x01, 0xB0, 0x01, 0xB0, 0x0D, 0x80, 0x0D, 0x80,
  0x28, 0x00, 0x28, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x80, 0xC0, 0x03, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x8E, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0xE0,
  0x00, 0x39, 0x80, 0x00, 0x36, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x61, 0xFC, 0x00, 0x0C, 0x61, 0xC0, 0x01,
  0x18, 0x1C, 0x00, 0x63, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0x03, 0x18, 0x00,
  0xC0, 0x62, 0x00, 0x0E, 0x18, 0xC0, 0x00, 0xFE, 0x18, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 5, 38, 33, 14, -38 },
  { 25, 9, 14, 33, 12, -41 },
  { 41, 31, 38, 33, 1, -38 },
  { 189, 26, 52, 33, 3, -45 },
  { 358, 31, 40, 33, 1, -39 },
  { 513, 28, 40, 33, 2, -39 },
  { 653, 1, 14, 33, 16, -41 },
  { 655, 13, 50, 33, 13, -42 },
  { 737, 13, 50, 33, 7, -42 },
  { 819, 27, 27, 33, 3, -30 },
  { 911, 27, 28, 33, 3, -31 },
  { 1006, 7, 14, 33, 12, -5 },
  { 1019, 15, 2, 33, 9, -18 },
  { 1023, 5, 4, 33, 14, -4 },
  { 1026, 21, 50, 33, 6, -42 },
  { 1158, 25, 40, 33, 4, -39 },
  { 1283, 26, 38, 33, 4, -38 },
  { 1407, 24, 39, 33, 5, -39 },
  { 1524, 23, 40, 33, 4, -39 },
  { 1639, 28, 38, 33, 2, -38 },
  { 1772, 24, 39, 33, 4, -38 },
  { 1889, 23, 39, 33, 5, -38 },
  { 2002, 24, 38, 33, 4, -38 },
  { 2116, 25, 40, 33, 4, -39 },
  { 2241, 24, 39, 33, 5, -39 },
  { 2358, 5, 29, 33, 14, -29 },
  { 2377, 7, 38, 33, 12, -29 },
  { 2411, 23, 30, 33, 5, -32 },
  { 2498, 27, 12, 33, 3, -23 },
  { 2539, 23, 30, 33, 5, -32 },
  { 2626, 23, 39, 33, 5, -39 },
  { 2739, 23, 45, 33, 5, -39 },
  { 2869, 27, 38, 33, 3, -38 },
  { 2998, 24, 38, 33, 5, -38 },
  { 3112, 25, 40, 33, 4, -39 },
  { 3237, 23, 38, 33, 6, -38 },
  { 3347, 22, 38, 33, 6, -38 },
  { 3452, 23, 38, 33, 6, -38 },
  { 3562, 24, 40, 33, 4, -39 },
  { 3682, 23, 38, 33, 5, -38 },
  { 3792, 23, 38, 33, 5, -38 },
  { 3902, 21, 39, 33, 5, -38 },
  { 4005, 25, 38, 33, 6, -38 },
  { 4124, 21, 38, 33, 8, -38 },
  { 4224, 25, 38, 33, 4, -38 },
  { 4343, 23, 38, 33, 5, -38 },
  { 4453, 25, 40, 33, 4, -39 },
  { 4578, 23, 38, 33, 6, -38 },
  { 4688, 25, 48, 33, 4, -39 },
  { 4838, 23, 38, 33, 6, -38 },
  { 4948, 26, 40, 33, 3, -39 },
  { 5078, 29, 38, 33, 2, -38 },
  { 5216, 23, 39, 33, 5, -38 },
  { 5329, 27, 38, 33, 3, -38 },
  { 5458, 27, 38, 33, 3, -38 },
  { 5587, 29, 38, 33, 2, -38 },
  { 5725, 31, 38, 33, 1, -38 },
  { 5873, 27, 38, 33, 3, -38 },
  { 6002, 14, 50, 33, 14, -42 },
  { 6090, 21, 50, 33, 6, -42 },
  { 6222, 14, 50, 33, 5, -42 },
  { 6310, 27, 21, 33, 3, -38 },
  { 6381, 27, 2, 33, 3, 6 },
  { 6388, 7, 9, 33, 11, -42 },
  { 6396, 25, 30, 33, 4, -29 },
  { 6490, 23, 42, 33, 6, -41 },
  { 6611, 22, 30, 33, 6, -29 },
  { 6694, 23, 42, 33, 4, -41 },
  { 6815, 23, 30, 33, 5, -29 },
  { 6902, 25, 41, 33, 4, -41 },
  { 7031, 26, 43, 33, 5, -31 },
  { 7171, 20, 41, 33, 7, -41 },
  { 7274, 24, 41, 33, 6, -41 },
  { 7397, 20, 52, 33, 5, -41 },
  { 7527, 24, 41, 33, 7, -41 },
  { 7650, 23, 41, 33, 5, -41 },
  { 7768, 25, 29, 33, 4, -29 },
  { 7859, 20, 29, 33, 7, -29 },
  { 7932, 23, 30, 33, 5, -29 },
  { 8019, 23, 40, 33, 6, -29 },
  { 8134, 23, 40, 33, 4, -29 },
  { 8249, 27, 28, 33, 4, -28 },
  { 8344, 24, 30, 33, 5, -29 },
  { 8434, 27, 38, 33, 2, -38 },
  { 8563, 20, 29, 33, 6, -28 },
  { 8636, 23, 28, 33, 5, -28 },
  { 8717, 29, 28, 33, 2, -28 },
  { 8819, 23, 28, 33, 5, -28 },
  { 8900, 25, 39, 33, 4, -28 },
  { 9022, 23, 28, 33, 5, -28 },
  { 9103, 21, 50, 33, 6, -42 },
  { 9235, 1, 50, 33, 16, -42 },
  { 9242, 21, 50, 33, 6, -42 },
  { 9374, 27, 10, 33, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_EXTRALIGHT55PT7B_H_
