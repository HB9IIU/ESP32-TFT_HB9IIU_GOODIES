#ifndef _IBMPLEXMONO_EXTRALIGHT50PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x64, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x10, 0x03, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF0, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0x00, 0x80, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x08, 0xF0, 0x1C,
  0x08, 0x1C, 0x30, 0x08, 0x0E, 0x30, 0x08, 0x06, 0x60, 0x08, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x08, 0x00, 0x60, 0x08, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x08, 0x00, 0x30, 0x08, 0x00, 0x38, 0x08, 0x00, 0x1C,
  0x08, 0x00, 0x0F, 0x88, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0B, 0xF0, 0x00, 0x08, 0x38, 0x00, 0x08, 0x1C, 0x00, 0x08, 0x0E, 0x00,
  0x08, 0x06, 0x00, 0x08, 0x06, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00,
  0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x02, 0x40, 0x08, 0x06, 0xE0,
  0x08, 0x06, 0x70, 0x08, 0x0C, 0x1C, 0x08, 0x1C, 0x0F, 0x08, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0x38, 0x38, 0x00, 0x63, 0x01, 0xC0, 0x04, 0x60, 0x0C,
  0x00, 0xC6, 0x00, 0x40, 0x18, 0x40, 0x06, 0x01, 0x84, 0x00, 0x60, 0x30,
  0x40, 0x06, 0x02, 0x04, 0x00, 0x60, 0x60, 0x40, 0x06, 0x04, 0x06, 0x00,
  0x40, 0xC0, 0x60, 0x0C, 0x18, 0x03, 0x01, 0xC1, 0x00, 0x38, 0x38, 0x30,
  0x01, 0xFF, 0x02, 0x00, 0x07, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x06, 0x0F,
  0xF8, 0x00, 0xC1, 0xC1, 0xC0, 0x08, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0x30, 0x20, 0x06, 0x02, 0x06, 0x00, 0x20, 0x60, 0x60, 0x02, 0x04, 0x06,
  0x00, 0x20, 0xC0, 0x60, 0x02, 0x18, 0x06, 0x00, 0x21, 0x80, 0x20, 0x06,
  0x30, 0x03, 0x00, 0x62, 0x00, 0x38, 0x0C, 0x60, 0x01, 0xC1, 0xC4, 0x00,
  0x0F, 0xF8, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xE0, 0x07, 0xC3, 0xB8, 0x03, 0xE3, 0x0C, 0x01, 0x03, 0x03, 0x00, 0x83,
  0x00, 0xC0, 0x41, 0x80, 0x30, 0x61, 0x80, 0x1C, 0x30, 0xC0, 0x07, 0x18,
  0x60, 0x01, 0xCC, 0x30, 0x00, 0x66, 0x18, 0x00, 0x1A, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0xB8, 0x60, 0x00,
  0xCE, 0x1C, 0x00, 0xC3, 0x07, 0x81, 0xC0, 0xC1, 0xFF, 0xC0, 0x30, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0xFB, 0xE0, 0xC1, 0xF0, 0x1F, 0x33,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x38, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x73, 0x8E, 0x38,
  0xC3, 0x1C, 0x61, 0x86, 0x10, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07,
  0x81, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x07, 0x98, 0x00, 0x0E,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xE0,
  0x3C, 0x06, 0x00, 0x38, 0x30, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xE2, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x74, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0x70, 0x00, 0x30, 0xE0, 0x01, 0xC1, 0xE0, 0x1E, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x08, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x04, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x0F,
  0xE0, 0x09, 0xFF, 0xE0, 0x2E, 0x03, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x03,
  0x10, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x19, 0x00, 0x00, 0x6E, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0xE0, 0x78, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x0F, 0xE0, 0x18, 0xFF, 0xE0, 0x67, 0x03, 0xE1, 0xA0, 0x03,
  0x8D, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03,
  0x8C, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xF0, 0x3C, 0x07, 0x00, 0x18, 0x30, 0x00, 0x31, 0xC0, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0xB1, 0xC0, 0x05, 0x83, 0xC0,
  0xE6, 0x07, 0xFF, 0x18, 0x07, 0xF0, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3C, 0xF3,
  0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x71, 0xCE, 0x38, 0xE3, 0x0C, 0x71, 0x86, 0x18, 0x43, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x03, 0x83, 0x80,
  0x0C, 0x70, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xC0, 0xF0, 0x18, 0x01, 0xC1, 0x80, 0x06, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x3E, 0x34, 0x03, 0xFD, 0xA0, 0x38, 0x3F, 0x03, 0x00,
  0xF8, 0x18, 0x03, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x60, 0x07, 0x83,
  0x00, 0x3C, 0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x30, 0x03,
  0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x20, 0x06, 0x81, 0x80, 0x34, 0x0E,
  0x03, 0xA0, 0x3F, 0xED, 0x80, 0xFE, 0x6C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0C, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0xF1, 0x80,
  0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x70, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x30, 0x00, 0x71, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0C, 0xC0, 0x01, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x1E, 0x03, 0x80, 0x1C, 0x18, 0x00,
  0x38, 0xE0, 0x00, 0x63, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x33, 0x00, 0x00,
  0xCE, 0x00, 0x06, 0x18, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x78, 0x1E, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0C, 0x00,
  0x78, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x07, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xB0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xB0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x01, 0x80, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x18, 0x00, 0x02, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xEC, 0x01,
  0xFF, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCE, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x16, 0x1C, 0x00, 0x6C,
  0x1E, 0x03, 0x98, 0x1F, 0xFE, 0x30, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1D,
  0x80, 0x06, 0x70, 0x03, 0x0F, 0x03, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x06,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0xE0, 0x01,
  0x8C, 0xC0, 0x03, 0x30, 0xC0, 0x06, 0xC1, 0xC0, 0x0F, 0x01, 0x80, 0x1E,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x07, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xD8, 0x00, 0x2F, 0x60, 0x01,
  0xBC, 0x80, 0x06, 0xF3, 0x00, 0x33, 0xCC, 0x00, 0xCF, 0x18, 0x06, 0x3C,
  0x60, 0x18, 0xF0, 0xC0, 0x43, 0xC3, 0x03, 0x0F, 0x04, 0x08, 0x3C, 0x18,
  0x60, 0xF0, 0x21, 0x83, 0xC0, 0xCC, 0x0F, 0x03, 0x30, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x02, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x81, 0x00, 0x18, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C,
  0x01, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18, 0x03, 0x01, 0x80,
  0x10, 0x18, 0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x19,
  0x80, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0C, 0x00, 0x1E,
  0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C,
  0xC0, 0x00, 0x73, 0x00, 0x07, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07,
  0x81, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0C, 0x00,
  0x1E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x73, 0x00, 0x07, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x3C,
  0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30,
  0x00, 0xC3, 0xC0, 0x3C, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x04, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x18, 0x02,
  0x40, 0x1C, 0x02, 0x40, 0x3C, 0x02, 0x60, 0x3C, 0x06, 0x60, 0x24, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x42, 0x06,
  0x60, 0xC3, 0x06, 0x20, 0xC3, 0x04, 0x20, 0x81, 0x04, 0x20, 0x81, 0x84,
  0x21, 0x81, 0x84, 0x31, 0x81, 0x8C, 0x31, 0x00, 0x8C, 0x33, 0x00, 0xCC,
  0x33, 0x00, 0xCC, 0x33, 0x00, 0xCC, 0x32, 0x00, 0x4C, 0x36, 0x00, 0x6C,
  0x16, 0x00, 0x68, 0x14, 0x00, 0x28, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x41, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06, 0x06, 0x03,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x0C, 0x06, 0x00,
  0x0C, 0x08, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x38, 0x30, 0x01, 0xB0, 0x78, 0x0E, 0x7E, 0x3F,
  0xF8, 0x7C, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0x80, 0xC7,
  0xFE, 0x0C, 0xC0, 0x78, 0xD0, 0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x06, 0xC0, 0x00, 0x6E, 0x00, 0x0C, 0xD0, 0x01, 0xCD, 0xC0, 0x78, 0xC7,
  0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1,
  0xC0, 0x0C, 0x38, 0x00, 0x63, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x13, 0x00, 0x03, 0x38,
  0x00, 0x61, 0xC0, 0x0E, 0x0F, 0x03, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x1F, 0x83, 0x07, 0xFE, 0x31, 0xE0, 0x33, 0x38,
  0x00, 0xB3, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00,
  0x07, 0x38, 0x00, 0xB1, 0xE0, 0x33, 0x07, 0xFE, 0x30, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x09,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x63,
  0x80, 0x03, 0x07, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0xFC,
  0x40, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x07, 0xE0, 0xC7, 0xFE, 0x37, 0x03, 0xCD, 0x00, 0x3B, 0x80,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x17, 0xFF, 0xFB, 0xFF, 0xFC, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0xE8, 0x00, 0x0C, 0x40, 0x00, 0xC2, 0x00, 0x0C, 0x10, 0x01,
  0xC0, 0x80, 0x1C, 0x04, 0x01, 0xC0, 0x20, 0x18, 0x01, 0x01, 0x80, 0x08,
  0x18, 0x00, 0x41, 0xC0, 0x02, 0x1F, 0x00, 0x13, 0x98, 0x00, 0xB8, 0x60,
  0x07, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x00, 0x38, 0x08, 0x00, 0xC0, 0x40,
  0x03, 0x02, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x80, 0x01, 0xC4, 0x00, 0x06,
  0x20, 0x00, 0x19, 0x00, 0x00, 0x68, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC7, 0xC0, 0xF8, 0xCF, 0xE1, 0xFC, 0xD8, 0x73, 0x0E,
  0xE0, 0x34, 0x06, 0xE0, 0x18, 0x02, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC1, 0xF8, 0x31,
  0xFF, 0x8D, 0xC0, 0xF3, 0x40, 0x0E, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x10, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x00,
  0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x24, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x38, 0x0F, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xC1,
  0xF8, 0x0C, 0x7F, 0xE0, 0xCC, 0x07, 0x8D, 0x00, 0x1C, 0xE0, 0x00, 0xCC,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0xCD, 0x00, 0x1C, 0xDC,
  0x07, 0x8C, 0x7F, 0xE0, 0xC1, 0xF8, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x30, 0x7F, 0xE3, 0x1E, 0x03,
  0x33, 0x80, 0x0B, 0x30, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x30, 0x00, 0x73, 0x80, 0x0B, 0x1E, 0x03, 0x30, 0x7F, 0xE3, 0x01, 0xF8,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x4E, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xE0,
  0x1E, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x8E, 0x00, 0x0E, 0x1F,
  0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x0B, 0x3C,
  0x0E, 0xC7, 0xFF, 0x30, 0x7F, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x00,
  0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x10, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x68, 0x03, 0x40, 0x12, 0x00, 0x90, 0x04,
  0xC0, 0x26, 0x03, 0x30, 0x19, 0x80, 0xC4, 0x06, 0x60, 0x21, 0x01, 0x98,
  0x08, 0x60, 0x62, 0x06, 0x18, 0x10, 0x81, 0x82, 0x04, 0x30, 0x40, 0x83,
  0x0C, 0x10, 0x30, 0xC3, 0x0C, 0x0C, 0x30, 0x43, 0x03, 0x08, 0x10, 0x80,
  0x42, 0x06, 0x20, 0x18, 0x81, 0x98, 0x06, 0x60, 0x66, 0x01, 0x98, 0x19,
  0x00, 0x26, 0x02, 0x40, 0x0D, 0x00, 0xB0, 0x03, 0x40, 0x3C, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x30, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0,
  0x0C, 0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x20, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0x1F, 0xC0, 0x03, 0x38, 0xE0, 0x03,
  0x30, 0x70, 0x03, 0x60, 0x38, 0x02, 0x40, 0x1C, 0x06, 0xC0, 0x0E, 0x0C,
  0xC0, 0x07, 0x1C, 0xC0, 0x03, 0xF8, 0x80, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 4, 35, 30, 13, -35 },
  { 19, 8, 13, 30, 11, -37 },
  { 32, 28, 35, 30, 1, -35 },
  { 155, 24, 47, 30, 3, -41 },
  { 296, 28, 37, 30, 1, -36 },
  { 426, 25, 37, 30, 2, -36 },
  { 542, 2, 13, 30, 14, -37 },
  { 546, 13, 45, 30, 11, -38 },
  { 620, 13, 45, 30, 6, -38 },
  { 694, 26, 25, 30, 2, -27 },
  { 776, 24, 24, 30, 3, -27 },
  { 848, 6, 13, 30, 11, -5 },
  { 858, 14, 2, 30, 8, -16 },
  { 862, 4, 4, 30, 13, -4 },
  { 864, 20, 45, 30, 5, -38 },
  { 977, 24, 37, 30, 3, -36 },
  { 1088, 24, 35, 30, 4, -35 },
  { 1193, 22, 36, 30, 4, -36 },
  { 1292, 22, 37, 30, 3, -36 },
  { 1394, 26, 35, 30, 2, -35 },
  { 1508, 22, 36, 30, 4, -35 },
  { 1607, 22, 36, 30, 4, -35 },
  { 1706, 22, 35, 30, 4, -35 },
  { 1803, 24, 37, 30, 3, -36 },
  { 1914, 22, 36, 30, 4, -36 },
  { 2013, 4, 26, 30, 13, -26 },
  { 2026, 6, 34, 30, 11, -26 },
  { 2052, 22, 27, 30, 4, -29 },
  { 2127, 24, 11, 30, 3, -21 },
  { 2160, 22, 27, 30, 4, -29 },
  { 2235, 20, 36, 30, 5, -36 },
  { 2325, 21, 41, 30, 4, -36 },
  { 2433, 26, 35, 30, 2, -35 },
  { 2547, 21, 35, 30, 5, -35 },
  { 2639, 22, 37, 30, 4, -36 },
  { 2741, 22, 35, 30, 5, -35 },
  { 2838, 21, 35, 30, 5, -35 },
  { 2930, 21, 35, 30, 5, -35 },
  { 3022, 23, 37, 30, 3, -36 },
  { 3129, 20, 35, 30, 5, -35 },
  { 3217, 22, 35, 30, 4, -35 },
  { 3314, 18, 36, 30, 5, -35 },
  { 3395, 23, 35, 30, 5, -35 },
  { 3496, 20, 35, 30, 7, -35 },
  { 3584, 22, 35, 30, 4, -35 },
  { 3681, 20, 35, 30, 5, -35 },
  { 3769, 24, 37, 30, 3, -36 },
  { 3880, 22, 35, 30, 5, -35 },
  { 3977, 24, 44, 30, 3, -36 },
  { 4109, 22, 35, 30, 5, -35 },
  { 4206, 24, 37, 30, 3, -36 },
  { 4317, 26, 35, 30, 2, -35 },
  { 4431, 20, 36, 30, 5, -35 },
  { 4521, 26, 35, 30, 2, -35 },
  { 4635, 24, 35, 30, 3, -35 },
  { 4740, 26, 35, 30, 2, -35 },
  { 4854, 28, 35, 30, 1, -35 },
  { 4977, 26, 35, 30, 2, -35 },
  { 5091, 12, 45, 30, 13, -38 },
  { 5159, 20, 45, 30, 5, -38 },
  { 5272, 12, 45, 30, 5, -38 },
  { 5340, 24, 19, 30, 3, -35 },
  { 5397, 24, 2, 30, 3, 6 },
  { 5403, 7, 9, 30, 10, -39 },
  { 5411, 23, 27, 30, 4, -26 },
  { 5489, 20, 38, 30, 6, -37 },
  { 5584, 20, 27, 30, 5, -26 },
  { 5652, 20, 38, 30, 4, -37 },
  { 5747, 22, 27, 30, 4, -26 },
  { 5822, 23, 37, 30, 4, -37 },
  { 5929, 24, 40, 30, 4, -29 },
  { 6049, 18, 37, 30, 6, -37 },
  { 6133, 21, 37, 30, 6, -37 },
  { 6231, 17, 47, 30, 5, -37 },
  { 6331, 21, 37, 30, 7, -37 },
  { 6429, 22, 37, 30, 4, -37 },
  { 6531, 24, 26, 30, 3, -26 },
  { 6609, 18, 26, 30, 6, -26 },
  { 6668, 22, 27, 30, 4, -26 },
  { 6743, 20, 36, 30, 6, -26 },
  { 6833, 20, 36, 30, 4, -26 },
  { 6923, 24, 26, 30, 4, -26 },
  { 7001, 22, 27, 30, 4, -26 },
  { 7076, 24, 35, 30, 2, -35 },
  { 7181, 18, 27, 30, 6, -26 },
  { 7242, 22, 26, 30, 4, -26 },
  { 7314, 26, 26, 30, 2, -26 },
  { 7399, 22, 26, 30, 4, -26 },
  { 7471, 22, 36, 30, 4, -26 },
  { 7570, 20, 26, 30, 5, -26 },
  { 7635, 18, 45, 30, 6, -38 },
  { 7737, 2, 45, 30, 14, -38 },
  { 7749, 18, 45, 30, 6, -38 },
  { 7851, 24, 10, 30, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_EXTRALIGHT50PT7B_H_
