#ifndef _IBMPLEXMONO_EXTRALIGHT69PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x82,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF,
  0x9E, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xF8, 0x61, 0xF8, 0x01, 0xE0, 0x30, 0x1E, 0x01, 0xC0, 0x18, 0x03, 0x81,
  0xC0, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x38, 0xE0, 0x03, 0x00, 0x08,
  0x70, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x0F, 0xC6,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x61, 0xF8, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x06, 0x60, 0x00, 0xC0, 0x07, 0x78, 0x00, 0x60, 0x03,
  0x9E, 0x00, 0x30, 0x03, 0x87, 0x80, 0x18, 0x01, 0xC1, 0xE0, 0x0C, 0x03,
  0xC0, 0x7C, 0x06, 0x03, 0xC0, 0x0F, 0xC3, 0x0F, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x71, 0xE0, 0x78, 0x00, 0x03,
  0x8E, 0x00, 0xE0, 0x00, 0x0C, 0x30, 0x01, 0xC0, 0x00, 0x71, 0xC0, 0x03,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x30,
  0xE0, 0x00, 0x60, 0x01, 0x83, 0x00, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x07,
  0x00, 0x30, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x06, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0x1E, 0x07, 0x80,
  0xC0, 0x00, 0x3F, 0xF8, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0C, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x1E, 0x0F, 0x00, 0x01, 0x80, 0xE0,
  0x0E, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x30, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x01, 0x81, 0xC0, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x30, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x01, 0x86, 0x00,
  0x0E, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x01,
  0xC7, 0x00, 0x00, 0xE0, 0x0E, 0x18, 0x00, 0x01, 0xE0, 0xF0, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x1F, 0xE0, 0xE1, 0xC0,
  0x03, 0xFC, 0x30, 0x18, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x80,
  0x38, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x18, 0x00, 0x38, 0x06, 0x07,
  0x00, 0x03, 0x80, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x18, 0x00, 0x07, 0x07,
  0x03, 0x00, 0x00, 0x70, 0xC0, 0x60, 0x00, 0x07, 0x18, 0x0C, 0x00, 0x00,
  0x73, 0x01, 0x80, 0x00, 0x07, 0x60, 0x30, 0x00, 0x00, 0x7C, 0x06, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x00, 0xCE, 0x03, 0x80, 0x00, 0x30,
  0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x7C, 0x03,
  0xC0, 0x0E, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x0F, 0xCF, 0xE0, 0x18, 0x0F, 0xE0,
  0x3F, 0xC3, 0x0F, 0xE0, 0x00, 0xFF, 0x6F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xF8, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x86, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x01, 0xFF, 0x00, 0x18, 0x7F, 0xFE, 0x00, 0xCF, 0x00, 0x7C,
  0x06, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x07,
  0xF8, 0x00, 0x70, 0xFF, 0xFC, 0x01, 0xCF, 0x80, 0xFC, 0x06, 0x70, 0x00,
  0x78, 0x1B, 0x80, 0x00, 0x70, 0xE8, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xD8, 0x78, 0x00, 0x06, 0x60, 0xF0, 0x00, 0x73, 0x80, 0xF8,
  0x07, 0x8C, 0x01, 0xFF, 0xF8, 0x30, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0xEF, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0xFE,
  0x78, 0x0F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x1F, 0x86, 0x60, 0x03, 0xFF, 0x37, 0x00, 0x7C, 0x1D,
  0xF8, 0x03, 0x80, 0x2F, 0xC0, 0x38, 0x00, 0xFC, 0x01, 0x80, 0x07, 0xE0,
  0x1C, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0xF8, 0x06, 0x00, 0x07, 0xC0, 0x30,
  0x00, 0x3E, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x7C, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF8,
  0x0E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x01, 0xF0, 0x0C,
  0x00, 0x0F, 0x80, 0x60, 0x00, 0x7C, 0x03, 0x00, 0x03, 0xF0, 0x1C, 0x00,
  0x1F, 0x80, 0x60, 0x01, 0xEC, 0x03, 0x80, 0x0F, 0x60, 0x0E, 0x01, 0xBB,
  0x00, 0x3E, 0x79, 0xD8, 0x00, 0xFF, 0x8E, 0xC0, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x0F, 0x81, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0xF8, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x78, 0x30, 0x00,
  0x00, 0xF1, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x07, 0xC3, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x21, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x30,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x01, 0x70, 0xE0,
  0x00, 0x06, 0xE0, 0xE0, 0x00, 0x19, 0xC0, 0xF0, 0x00, 0x63, 0x80, 0xFC,
  0x07, 0x87, 0x00, 0x7F, 0xFE, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0x80, 0x00, 0x38, 0x3B, 0x80, 0x00, 0x70, 0xE7, 0x00, 0x00, 0xE3,
  0x87, 0x00, 0x01, 0xCE, 0x0F, 0x00, 0x03, 0xB8, 0x0E, 0x00, 0x07, 0x60,
  0x0E, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x03,
  0xFD, 0xC0, 0x00, 0x0D, 0xF3, 0x00, 0x00, 0x77, 0xCE, 0x00, 0x01, 0x9F,
  0x18, 0x00, 0x0E, 0x7C, 0x70, 0x00, 0x31, 0xF0, 0xC0, 0x01, 0xC7, 0xC3,
  0x80, 0x06, 0x1F, 0x06, 0x00, 0x18, 0x7C, 0x18, 0x00, 0xE1, 0xF0, 0x70,
  0x03, 0x07, 0xC0, 0xC0, 0x1C, 0x1F, 0x03, 0x80, 0x60, 0x7C, 0x06, 0x03,
  0x81, 0xF0, 0x1C, 0x0C, 0x07, 0xC0, 0x30, 0x30, 0x1F, 0x00, 0xC1, 0x80,
  0x7C, 0x03, 0x86, 0x01, 0xF0, 0x06, 0x38, 0x07, 0xC0, 0x1C, 0xC0, 0x1F,
  0x00, 0x37, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x20, 0x01, 0xF0, 0x00,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x0F,
  0x98, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xE3, 0x00, 0x00, 0x1F, 0x1C,
  0x00, 0x00, 0xF8, 0x60, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x3E, 0x0C, 0x00,
  0x01, 0xF0, 0x70, 0x00, 0x0F, 0x81, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x03,
  0xE0, 0x30, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF8, 0x06, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x3E, 0x00, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x18,
  0x00, 0x7C, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0x60, 0x07, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x0C, 0x01, 0xF0,
  0x00, 0x70, 0x0F, 0x80, 0x01, 0x80, 0x7C, 0x00, 0x0E, 0x03, 0xE0, 0x00,
  0x30, 0x1F, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x38,
  0x3E, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x18, 0x7C,
  0x00, 0x00, 0xE3, 0xE0, 0x00, 0x03, 0x1F, 0x00, 0x00, 0x1C, 0xF8, 0x00,
  0x00, 0x67, 0xC0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x0D, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x04, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x1C, 0x00, 0x31, 0x80,
  0x07, 0x80, 0x0C, 0x60, 0x01, 0xE0, 0x03, 0x1C, 0x00, 0xF8, 0x00, 0xC7,
  0x00, 0x36, 0x00, 0x31, 0xC0, 0x0D, 0xC0, 0x0C, 0x30, 0x07, 0x30, 0x03,
  0x0C, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x70, 0xC0, 0x18, 0x60,
  0x1C, 0x30, 0x0E, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1,
  0xC0, 0x60, 0xC0, 0x70, 0x30, 0x18, 0x38, 0x18, 0x0C, 0x06, 0x0E, 0x06,
  0x03, 0x81, 0x83, 0x81, 0x80, 0xE0, 0x60, 0x60, 0xE0, 0x18, 0x18, 0x18,
  0x30, 0x06, 0x06, 0x06, 0x0C, 0x01, 0xC3, 0x81, 0x83, 0x00, 0x30, 0xE0,
  0x61, 0xC0, 0x0C, 0x30, 0x18, 0x60, 0x03, 0x0C, 0x06, 0x18, 0x00, 0xE3,
  0x01, 0x8E, 0x00, 0x18, 0xC0, 0x73, 0x00, 0x06, 0x30, 0x1C, 0xC0, 0x01,
  0xCC, 0x07, 0x30, 0x00, 0x33, 0x00, 0xDC, 0x00, 0x0C, 0xC0, 0x36, 0x00,
  0x03, 0x70, 0x0D, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x70,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x20,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x02, 0xC0, 0x70, 0x00, 0x02, 0xC0, 0x38, 0x00, 0x04, 0xC0,
  0x3C, 0x00, 0x18, 0xC0, 0x1F, 0x00, 0xF0, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0xFC, 0x00,
  0xE1, 0xFF, 0xF8, 0x0E, 0x3C, 0x07, 0xC0, 0xE6, 0x00, 0x0E, 0x0E, 0xC0,
  0x00, 0x70, 0xF8, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x03,
  0x8E, 0xC0, 0x00, 0x70, 0xE6, 0x00, 0x0E, 0x0E, 0x3C, 0x07, 0xC0, 0xE1,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x47, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x23,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x03, 0xFE, 0x03,
  0x00, 0xFF, 0xF8, 0x30, 0x3E, 0x01, 0xE3, 0x07, 0x80, 0x07, 0x30, 0xE0,
  0x00, 0x1B, 0x1C, 0x00, 0x00, 0xB1, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0xB0, 0xE0, 0x00, 0x1B, 0x07, 0x80, 0x07, 0x30, 0x3E, 0x01, 0xC3, 0x00,
  0xFF, 0xF8, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE3, 0x00, 0x00,
  0xFF, 0xFB, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xFF, 0x00, 0xE1,
  0xFF, 0xF0, 0x39, 0xE0, 0x1F, 0x0E, 0xE0, 0x01, 0xE3, 0xA0, 0x00, 0x3C,
  0xF8, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x78, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x0C, 0x1F, 0x80, 0x00, 0x30, 0xF7, 0x00, 0x00, 0xC7, 0x0E, 0x00, 0x03,
  0x38, 0x1C, 0x00, 0x0D, 0xC0, 0x38, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0F,
  0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC3, 0xF0, 0x07, 0xE0, 0xC7, 0xFC, 0x1F, 0xF8, 0xCC, 0x1E, 0x38,
  0x3C, 0xD8, 0x07, 0x20, 0x0E, 0xF0, 0x03, 0x40, 0x0E, 0xE0, 0x03, 0x40,
  0x06, 0xE0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xE0, 0x3F, 0xC0, 0x38, 0x7F, 0xFC, 0x0E, 0x78, 0x07, 0xC3, 0xB8,
  0x00, 0x78, 0xE8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x3F, 0xC0, 0x0E, 0x1F, 0xFF, 0x80,
  0xE3, 0xC0, 0x7C, 0x0E, 0x60, 0x00, 0xE0, 0xEC, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0C, 0xF0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x38, 0xEC, 0x00, 0x07,
  0x0E, 0x60, 0x00, 0xE0, 0xE3, 0xC0, 0x7C, 0x0E, 0x1F, 0xFF, 0x80, 0xE0,
  0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x30, 0x0F, 0xFF, 0x83, 0x03, 0xE0, 0x1E, 0x30, 0x78,
  0x00, 0x73, 0x0E, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x0B, 0x1C, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x0B, 0x0E, 0x00, 0x01, 0xB0, 0x78, 0x00, 0x73, 0x03,
  0xE0, 0x1C, 0x30, 0x0F, 0xFF, 0x83, 0x00, 0x3F, 0xE0, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0xE4, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0B, 0x38, 0x00, 0x0D, 0x8E, 0x00, 0x1C, 0xC3,
  0xE0, 0x3C, 0x60, 0xFF, 0xF8, 0x30, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1B, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x01,
  0xB0, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0x38, 0x00, 0x66, 0x00, 0x18,
  0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01, 0x8C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x18, 0x30,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x70, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x1C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06, 0x06, 0x00,
  0x60, 0xC0, 0x38, 0x30, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x06,
  0x18, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00, 0x18,
  0xC0, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x06, 0x30, 0x01, 0x98,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x06, 0xC0,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x01, 0xB0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x83, 0xFC,
  0x00, 0x00, 0xC3, 0x87, 0x00, 0x00, 0x63, 0x81, 0xC0, 0x00, 0x33, 0x80,
  0x70, 0x00, 0x39, 0x80, 0x1C, 0x00, 0x19, 0xC0, 0x07, 0x00, 0x0C, 0xC0,
  0x01, 0xC0, 0x0E, 0x60, 0x00, 0x70, 0x06, 0x30, 0x00, 0x1C, 0x06, 0x30,
  0x00, 0x07, 0x8F, 0x18, 0x00, 0x01, 0xFF, 0x0C, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 6, 48, 41, 18, -48 },
  { 37, 12, 18, 41, 15, -51 },
  { 64, 39, 48, 41, 1, -48 },
  { 298, 33, 64, 41, 4, -56 },
  { 562, 38, 50, 41, 2, -49 },
  { 800, 35, 50, 41, 3, -49 },
  { 1019, 3, 18, 41, 19, -51 },
  { 1026, 17, 62, 41, 16, -52 },
  { 1158, 17, 62, 41, 9, -52 },
  { 1290, 35, 34, 41, 3, -38 },
  { 1439, 33, 34, 41, 4, -38 },
  { 1580, 8, 17, 41, 15, -6 },
  { 1597, 19, 2, 41, 11, -22 },
  { 1602, 6, 6, 41, 18, -6 },
  { 1607, 27, 62, 41, 7, -52 },
  { 1817, 32, 50, 41, 5, -49 },
  { 2017, 33, 48, 41, 5, -48 },
  { 2215, 30, 49, 41, 6, -49 },
  { 2399, 30, 50, 41, 4, -49 },
  { 2587, 35, 48, 41, 3, -48 },
  { 2797, 29, 49, 41, 6, -48 },
  { 2975, 30, 49, 41, 6, -48 },
  { 3159, 31, 48, 41, 5, -48 },
  { 3345, 32, 50, 41, 5, -49 },
  { 3545, 30, 49, 41, 6, -49 },
  { 3729, 6, 37, 41, 18, -37 },
  { 3757, 9, 48, 41, 15, -37 },
  { 3811, 30, 38, 41, 6, -40 },
  { 3954, 33, 14, 41, 4, -28 },
  { 4012, 30, 38, 41, 6, -40 },
  { 4155, 28, 49, 41, 7, -49 },
  { 4327, 29, 56, 41, 6, -49 },
  { 4530, 35, 48, 41, 3, -48 },
  { 4740, 29, 48, 41, 7, -48 },
  { 4914, 31, 50, 41, 5, -49 },
  { 5108, 30, 48, 41, 7, -48 },
  { 5288, 29, 48, 41, 7, -48 },
  { 5462, 29, 48, 41, 7, -48 },
  { 5636, 31, 50, 41, 5, -49 },
  { 5830, 29, 48, 41, 6, -48 },
  { 6004, 29, 48, 41, 6, -48 },
  { 6178, 26, 49, 41, 6, -48 },
  { 6338, 31, 48, 41, 7, -48 },
  { 6524, 27, 48, 41, 10, -48 },
  { 6686, 30, 48, 41, 6, -48 },
  { 6866, 29, 48, 41, 6, -48 },
  { 7040, 32, 50, 41, 5, -49 },
  { 7240, 30, 48, 41, 7, -48 },
  { 7420, 32, 59, 41, 5, -49 },
  { 7656, 30, 48, 41, 7, -48 },
  { 7836, 33, 50, 41, 4, -49 },
  { 8043, 36, 48, 41, 3, -48 },
  { 8259, 29, 49, 41, 6, -48 },
  { 8437, 35, 48, 41, 3, -48 },
  { 8647, 34, 48, 41, 4, -48 },
  { 8851, 35, 48, 41, 3, -48 },
  { 9061, 38, 48, 41, 2, -48 },
  { 9289, 35, 48, 41, 3, -48 },
  { 9499, 17, 62, 41, 18, -52 },
  { 9631, 27, 62, 41, 7, -52 },
  { 9841, 17, 62, 41, 7, -52 },
  { 9973, 33, 26, 41, 4, -48 },
  { 10081, 33, 2, 41, 4, 8 },
  { 10090, 9, 12, 41, 14, -53 },
  { 10104, 32, 37, 41, 5, -36 },
  { 10252, 28, 52, 41, 8, -51 },
  { 10434, 28, 37, 41, 7, -36 },
  { 10564, 28, 52, 41, 5, -51 },
  { 10746, 30, 37, 41, 6, -36 },
  { 10885, 31, 51, 41, 6, -51 },
  { 11083, 32, 54, 41, 6, -39 },
  { 11299, 26, 51, 41, 8, -51 },
  { 11465, 29, 52, 41, 8, -52 },
  { 11654, 24, 66, 41, 7, -52 },
  { 11852, 30, 51, 41, 9, -51 },
  { 12044, 29, 51, 41, 6, -51 },
  { 12229, 32, 36, 41, 5, -36 },
  { 12373, 26, 36, 41, 8, -36 },
  { 12490, 30, 37, 41, 6, -36 },
  { 12629, 28, 50, 41, 8, -36 },
  { 12804, 28, 50, 41, 5, -36 },
  { 12979, 33, 36, 41, 5, -36 },
  { 13128, 30, 37, 41, 6, -36 },
  { 13267, 33, 48, 41, 3, -48 },
  { 13465, 25, 37, 41, 8, -36 },
  { 13581, 29, 36, 41, 6, -36 },
  { 13712, 37, 36, 41, 2, -36 },
  { 13879, 30, 36, 41, 6, -36 },
  { 14014, 31, 50, 41, 5, -36 },
  { 14208, 28, 36, 41, 7, -36 },
  { 14334, 26, 62, 41, 8, -52 },
  { 14536, 2, 62, 41, 20, -52 },
  { 14552, 26, 62, 41, 8, -52 },
  { 14754, 33, 13, 41, 4, -27 },
};

const GFXfont IBMPlexMono_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_EXTRALIGHT69PT7B_H_
