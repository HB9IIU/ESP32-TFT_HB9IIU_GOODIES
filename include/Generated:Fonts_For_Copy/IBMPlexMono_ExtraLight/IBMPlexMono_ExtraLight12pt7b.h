#ifndef _IBMPLEXMONO_EXTRALIGHT12PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xFC, 0x2C, 0x51, 0x99, 0x42, 0x99, 0xD2, 0x28, 0x23, 0xAB,
  0x4E, 0x1C, 0xB5, 0x79, 0x00, 0x63, 0x2A, 0x63, 0x42, 0xCA, 0x54, 0xC6,
  0x30, 0x91, 0x01, 0x35, 0x51, 0x22, 0x3B, 0xE0, 0x72, 0x49, 0x24, 0x91,
  0x80, 0xA5, 0x55, 0x68, 0x20, 0x8A, 0xDC, 0x52, 0x20, 0x21, 0x09, 0xF2,
  0x10, 0x80, 0xE0, 0xE0, 0x80, 0x08, 0x84, 0x22, 0x11, 0x08, 0x44, 0x20,
  0x74, 0x63, 0x1A, 0xC6, 0x2E, 0x21, 0x8A, 0x08, 0x20, 0x82, 0x3F, 0x74,
  0x62, 0x11, 0x13, 0x1F, 0x74, 0x42, 0xE1, 0x86, 0x2E, 0x10, 0xC5, 0x24,
  0x93, 0xF1, 0x04, 0x7C, 0x21, 0xE8, 0x86, 0x2E, 0x32, 0x21, 0xE8, 0xC6,
  0x2E, 0xFC, 0x64, 0x22, 0x11, 0x08, 0x74, 0x62, 0x6C, 0xC6, 0x2E, 0x74,
  0x63, 0x17, 0x84, 0x4C, 0x84, 0x87, 0x08, 0x99, 0x04, 0x18, 0x20, 0xF8,
  0x3E, 0x82, 0x0C, 0x11, 0x32, 0x00, 0x74, 0x62, 0x62, 0x00, 0x04, 0x74,
  0x6F, 0x9C, 0xE6, 0xF0, 0x78, 0x21, 0x85, 0x14, 0x93, 0xE8, 0xA3, 0xF4,
  0x63, 0xE8, 0xC6, 0x3F, 0x74, 0x61, 0x08, 0x42, 0x2E, 0xF4, 0x63, 0x18,
  0xC6, 0x3E, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10,
  0x74, 0x61, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08,
  0x42, 0x10, 0x9F, 0x78, 0x42, 0x10, 0x86, 0x2E, 0x8E, 0x4A, 0x28, 0xE2,
  0x48, 0xA3, 0x88, 0x88, 0x88, 0x8F, 0x8C, 0xF7, 0xDA, 0xC6, 0x31, 0x8E,
  0x73, 0x5A, 0xCE, 0x71, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xFC, 0x63, 0x1F,
  0xC2, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x21, 0xC0, 0xFC, 0x63, 0x1F,
  0xD2, 0x51, 0x74, 0x61, 0xC1, 0x86, 0x2F, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x8E, 0x28, 0xA4, 0x51, 0x46,
  0x08, 0x86, 0x2A, 0xBA, 0xDB, 0x6D, 0xA2, 0x8E, 0x25, 0x08, 0x61, 0x48,
  0xA3, 0x82, 0x88, 0xA1, 0x81, 0x02, 0x04, 0x08, 0xF8, 0x21, 0x08, 0x42,
  0x08, 0x3F, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x84, 0x10, 0x84, 0x10, 0x82,
  0x10, 0x82, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x22, 0xA5, 0x18, 0x80, 0xF8,
  0x90, 0x74, 0x85, 0xE9, 0x74, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0xF0, 0x74,
  0x61, 0x08, 0xB8, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x78, 0x74, 0x7F, 0x08,
  0xB8, 0x39, 0x09, 0xF2, 0x10, 0x84, 0xF8, 0x0D, 0xC8, 0xA2, 0x72, 0x07,
  0xA1, 0xF8, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x88, 0x20, 0x01, 0xC2, 0x10,
  0x84, 0xF8, 0x10, 0x0F, 0x11, 0x11, 0x11, 0xF0, 0x84, 0x21, 0x2A, 0x62,
  0x92, 0x98, 0xE1, 0x08, 0x42, 0x10, 0x84, 0xF8, 0xDD, 0x6B, 0x5A, 0xD4,
  0xB6, 0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xB6, 0x63, 0x18, 0xFA,
  0x10, 0x7C, 0x63, 0x18, 0xBC, 0x21, 0xDD, 0x84, 0x10, 0x43, 0xE0, 0x74,
  0x78, 0x38, 0xBC, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x07, 0x8C, 0x63, 0x18,
  0xBC, 0x8C, 0x64, 0xA6, 0x10, 0x93, 0x6A, 0xD5, 0x66, 0xC8, 0x80, 0x8A,
  0x98, 0xC5, 0x44, 0x8C, 0x64, 0xA6, 0x11, 0x18, 0xF8, 0x88, 0x88, 0x7C,
  0x3A, 0x08, 0x41, 0x70, 0xC4, 0x22, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x84,
  0x1D, 0x88, 0x21, 0x38, 0xCE, 0xA9, 0x80,
};

const GFXglyph IBMPlexMono_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 3, 7, 3, -9 },
  { 3, 7, 8, 7, 0, -8 },
  { 10, 5, 10, 7, 1, -9 },
  { 17, 7, 8, 7, 0, -8 },
  { 24, 7, 8, 7, 0, -8 },
  { 31, 1, 3, 7, 3, -9 },
  { 32, 3, 11, 7, 3, -9 },
  { 37, 2, 11, 7, 2, -9 },
  { 40, 6, 6, 7, 1, -7 },
  { 45, 5, 7, 7, 1, -7 },
  { 50, 1, 3, 7, 3, -1 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 1, 1, 7, 3, -1 },
  { 53, 5, 11, 7, 1, -9 },
  { 60, 5, 8, 7, 1, -8 },
  { 65, 6, 8, 7, 1, -8 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 6, 8, 7, 1, -8 },
  { 87, 5, 8, 7, 1, -8 },
  { 92, 5, 8, 7, 1, -8 },
  { 97, 5, 8, 7, 1, -8 },
  { 102, 5, 8, 7, 1, -8 },
  { 107, 5, 8, 7, 1, -8 },
  { 112, 1, 6, 7, 3, -6 },
  { 113, 1, 8, 7, 3, -6 },
  { 114, 5, 7, 7, 1, -7 },
  { 119, 5, 3, 7, 1, -5 },
  { 121, 5, 7, 7, 1, -7 },
  { 126, 5, 8, 7, 1, -8 },
  { 131, 5, 9, 7, 1, -8 },
  { 137, 6, 8, 7, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 5, 8, 7, 1, -8 },
  { 188, 6, 8, 7, 1, -8 },
  { 194, 4, 8, 7, 2, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 5, 8, 7, 1, -8 },
  { 208, 5, 8, 7, 1, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 5, 10, 7, 1, -8 },
  { 225, 5, 8, 7, 1, -8 },
  { 230, 5, 8, 7, 1, -8 },
  { 235, 7, 8, 7, 0, -8 },
  { 242, 5, 8, 7, 1, -8 },
  { 247, 6, 8, 7, 1, -8 },
  { 253, 6, 8, 7, 1, -8 },
  { 259, 6, 8, 7, 1, -8 },
  { 265, 7, 8, 7, 0, -8 },
  { 272, 6, 8, 7, 1, -8 },
  { 278, 3, 11, 7, 3, -9 },
  { 283, 5, 11, 7, 1, -9 },
  { 290, 3, 11, 7, 1, -9 },
  { 295, 5, 5, 7, 1, -8 },
  { 299, 5, 1, 7, 1, 1 },
  { 300, 2, 2, 7, 2, -10 },
  { 301, 5, 6, 7, 1, -6 },
  { 305, 5, 9, 7, 1, -9 },
  { 311, 5, 6, 7, 1, -6 },
  { 315, 5, 9, 7, 1, -9 },
  { 321, 5, 6, 7, 1, -6 },
  { 325, 5, 9, 7, 1, -9 },
  { 331, 6, 9, 7, 1, -7 },
  { 338, 5, 9, 7, 1, -9 },
  { 344, 5, 9, 7, 1, -9 },
  { 350, 4, 11, 7, 1, -9 },
  { 356, 5, 9, 7, 2, -9 },
  { 362, 5, 9, 7, 1, -9 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 5, 6, 7, 1, -6 },
  { 376, 5, 6, 7, 1, -6 },
  { 380, 5, 8, 7, 1, -6 },
  { 385, 5, 8, 7, 1, -6 },
  { 390, 6, 6, 7, 1, -6 },
  { 395, 5, 6, 7, 1, -6 },
  { 399, 6, 8, 7, 0, -8 },
  { 405, 5, 6, 7, 1, -6 },
  { 409, 5, 6, 7, 1, -6 },
  { 413, 7, 6, 7, 0, -6 },
  { 419, 5, 6, 7, 1, -6 },
  { 423, 5, 8, 7, 1, -6 },
  { 428, 5, 6, 7, 1, -6 },
  { 432, 5, 11, 7, 1, -9 },
  { 439, 1, 11, 7, 3, -9 },
  { 441, 5, 11, 7, 1, -9 },
  { 448, 6, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_EXTRALIGHT12PT7B_H_
