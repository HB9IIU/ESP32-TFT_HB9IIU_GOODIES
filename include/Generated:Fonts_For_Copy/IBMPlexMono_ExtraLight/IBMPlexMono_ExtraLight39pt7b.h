#ifndef _IBMPLEXMONO_EXTRALIGHT39PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x00, 0xFF, 0x80,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x84, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x01, 0x83, 0x01, 0xFE, 0x0F,
  0xF0, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x04, 0x03, 0xF8, 0x1F, 0xC0, 0x20,
  0x40, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0,
  0x18, 0xCE, 0x04, 0x18, 0x61, 0x03, 0x02, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xC0, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0D, 0x01, 0x81, 0x70, 0x30, 0x63, 0x06, 0x18, 0x38, 0xC6, 0x01,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0x00, 0x09, 0x86, 0x00, 0xD8, 0x10, 0x04, 0x80, 0xC0, 0x4C, 0x02,
  0x06, 0x60, 0x10, 0x23, 0x00, 0x83, 0x18, 0x04, 0x10, 0xC0, 0x21, 0x02,
  0x03, 0x08, 0x18, 0x10, 0x80, 0x61, 0x8C, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x21, 0x86, 0x02, 0x18, 0x10, 0x10, 0x80, 0xC1,
  0x0C, 0x02, 0x18, 0x60, 0x10, 0x82, 0x00, 0x88, 0x10, 0x04, 0x40, 0xC0,
  0x24, 0x02, 0x03, 0x60, 0x10, 0x12, 0x00, 0x61, 0xB0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x60, 0xC0, 0x0C, 0x06, 0x00, 0x80, 0x20, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x98, 0x0F, 0x10, 0xC0,
  0x82, 0x04, 0x08, 0x60, 0x20, 0x84, 0x01, 0x08, 0x40, 0x18, 0x8C, 0x00,
  0xD8, 0xC0, 0x07, 0x04, 0x00, 0x30, 0x40, 0x03, 0x86, 0x00, 0x28, 0x30,
  0x04, 0x41, 0x81, 0x82, 0x07, 0xE0, 0x30, 0xFF, 0xC0, 0x01, 0x81, 0x81,
  0x81, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x30, 0x10, 0x10, 0x30, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0E, 0x04,
  0x07, 0x3C, 0x47, 0xC0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0x90, 0x00, 0x11, 0x80, 0x02, 0x0C, 0x00, 0x60, 0x40, 0x0C, 0x06, 0x00,
  0x80, 0x30, 0x18, 0x01, 0x80, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x37, 0x66, 0x64, 0xCC, 0x88, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x07, 0x01, 0x00,
  0x60, 0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x0C, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C,
  0x10, 0x06, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0xD8, 0x00,
  0x66, 0x00, 0x31, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x02, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x0C, 0x0E,
  0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x36, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x18, 0x18, 0x20, 0x04,
  0x40, 0x02, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x38, 0x18, 0x0F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1A, 0x00, 0x01, 0x20, 0x00, 0x32,
  0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x01, 0x82, 0x00, 0x10,
  0x20, 0x03, 0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x08,
  0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x7E, 0x06, 0xC0, 0xC3,
  0x80, 0x30, 0x80, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x06, 0x60,
  0x06, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x7E, 0x04, 0xC0, 0xC2, 0x80, 0x33,
  0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x40, 0x06, 0x30, 0x06, 0x0E,
  0x06, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x34, 0x00, 0x12, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0x03, 0x03, 0x00, 0x21, 0x80, 0x04, 0x40,
  0x01, 0x90, 0x00, 0x64, 0x00, 0x19, 0x00, 0x06, 0x40, 0x01, 0x98, 0x00,
  0x43, 0x00, 0x20, 0x70, 0x30, 0x03, 0xF0, 0x07, 0x03, 0x02, 0x00, 0x31,
  0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x06, 0x20, 0x03, 0x06, 0x03,
  0x80, 0x7F, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x0C, 0x01, 0x84, 0x00, 0x64,
  0x00, 0x12, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x29, 0x80, 0x1C, 0x70, 0x36, 0x0F,
  0xE2, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x77, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x37, 0x66, 0x64, 0xCC, 0x88, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xE0, 0x18, 0x18, 0x60, 0x0C, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x03, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x00, 0x03, 0xF0, 0x06, 0x0E, 0x06, 0x01, 0x86,
  0x00, 0x42, 0x00, 0x31, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x79,
  0x20, 0xC2, 0xD0, 0x40, 0xF8, 0x40, 0x3C, 0x20, 0x1E, 0x10, 0x0F, 0x08,
  0x07, 0x84, 0x03, 0xC2, 0x01, 0xE1, 0x00, 0xF0, 0x80, 0x78, 0x40, 0x34,
  0x30, 0x1A, 0x0C, 0x1D, 0x03, 0xF6, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x0B, 0x00, 0x01, 0x90, 0x00,
  0x11, 0x00, 0x01, 0x18, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0xC0,
  0x06, 0x04, 0x00, 0x40, 0x40, 0x04, 0x06, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x30, 0x18, 0x01, 0x01, 0xFF, 0xF0, 0x10, 0x01, 0x83, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x30, 0xFF, 0xE0, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xF0, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C, 0xFF,
  0xF0, 0x03, 0xF8, 0x07, 0x07, 0x06, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x0B,
  0x00, 0x05, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x04,
  0x80, 0x02, 0x60, 0x03, 0x18, 0x03, 0x07, 0x07, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x60, 0x1C, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x09,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x1C, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x06,
  0x06, 0x06, 0x01, 0x84, 0x00, 0x66, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x05,
  0x10, 0x02, 0x86, 0x06, 0x40, 0xFC, 0x20, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x3F, 0xFC, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF0,
  0x02, 0x40, 0x18, 0xC1, 0xC1, 0xFC, 0x00, 0x80, 0x01, 0xA0, 0x00, 0xC8,
  0x00, 0x22, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x03, 0x02, 0x01,
  0x80, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x30, 0x02, 0x18, 0x00, 0x87, 0x00,
  0x22, 0x60, 0x09, 0x08, 0x02, 0xC3, 0x00, 0xE0, 0x60, 0x30, 0x08, 0x08,
  0x03, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x62, 0x00,
  0x08, 0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xE8, 0x00, 0xF6, 0x00, 0x59, 0x00,
  0x6C, 0xC0, 0x26, 0x20, 0x33, 0x10, 0x11, 0x8C, 0x08, 0xC2, 0x08, 0x61,
  0x84, 0x30, 0x46, 0x18, 0x32, 0x0C, 0x0B, 0x06, 0x07, 0x03, 0x01, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xA0, 0x03, 0xB0, 0x03, 0x90, 0x03,
  0x98, 0x03, 0x88, 0x03, 0x8C, 0x03, 0x84, 0x03, 0x86, 0x03, 0x82, 0x03,
  0x83, 0x03, 0x81, 0x03, 0x81, 0x83, 0x80, 0x83, 0x80, 0xC3, 0x80, 0x43,
  0x80, 0x63, 0x80, 0x23, 0x80, 0x33, 0x80, 0x13, 0x80, 0x1B, 0x80, 0x0B,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x03, 0xF0, 0x03, 0x07, 0x01, 0x00,
  0x60, 0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C,
  0x10, 0x06, 0x03, 0x03, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x40, 0x06, 0x20,
  0x00, 0x90, 0x00, 0x68, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00,
  0x63, 0xFF, 0xE1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x07, 0x01, 0x00, 0x60,
  0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C, 0x10,
  0x06, 0x03, 0x03, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0xFC, 0xFF, 0xF8, 0x40, 0x06, 0x20, 0x00, 0x90,
  0x00, 0x68, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00, 0x63, 0xFF,
  0xE1, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x18, 0x10, 0x06, 0x08,
  0x01, 0x04, 0x00, 0xC2, 0x00, 0x31, 0x00, 0x08, 0x80, 0x06, 0x40, 0x01,
  0xA0, 0x00, 0x60, 0x03, 0xFC, 0x01, 0x80, 0xE0, 0xC0, 0x06, 0x10, 0x00,
  0x66, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xD0, 0x00, 0x17, 0x00, 0x06,
  0x30, 0x01, 0x83, 0x80, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30, 0x18, 0x0F,
  0xE0, 0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x26, 0x00,
  0x04, 0x40, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x10, 0x01, 0x83, 0x00,
  0x20, 0x60, 0x04, 0x04, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x01,
  0x80, 0x20, 0x20, 0x06, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x84,
  0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x64, 0x00, 0x05, 0x80, 0x00, 0xB0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00,
  0x03, 0x40, 0x60, 0x68, 0x1C, 0x09, 0x02, 0x81, 0x20, 0x58, 0x26, 0x09,
  0x04, 0xC3, 0x20, 0x98, 0x44, 0x13, 0x08, 0xC2, 0x23, 0x08, 0x44, 0x41,
  0x18, 0x88, 0x33, 0x11, 0x06, 0x62, 0x60, 0x48, 0x48, 0x09, 0x09, 0x01,
  0xA1, 0xE0, 0x14, 0x3C, 0x02, 0x87, 0x00, 0x70, 0x60, 0x0E, 0x00, 0xC0,
  0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x01, 0x00,
  0x80, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x31, 0x80,
  0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1B, 0x00, 0x01, 0x18, 0x00, 0x30, 0x80, 0x06, 0x0C, 0x00, 0x40,
  0x60, 0x0C, 0x02, 0x01, 0x80, 0x30, 0x10, 0x01, 0x83, 0x00, 0x08, 0x60,
  0x00, 0xC4, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x88, 0x00, 0x0C, 0x60, 0x00, 0x41, 0x80, 0x06, 0x04, 0x00, 0x60, 0x30,
  0x02, 0x00, 0x80, 0x30, 0x06, 0x03, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80,
  0x03, 0x18, 0x00, 0x0C, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x06, 0xC0, 0x00, 0x8C, 0x00, 0x30, 0x80, 0x04, 0x18, 0x01, 0x81,
  0x00, 0x20, 0x30, 0x08, 0x02, 0x03, 0x00, 0x20, 0x40, 0x06, 0x18, 0x00,
  0x42, 0x00, 0x0C, 0x80, 0x00, 0xB0, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x86,
  0x10, 0x43, 0x08, 0x20, 0x0F, 0xE0, 0x0E, 0x0E, 0x06, 0x00, 0xC1, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x03, 0xFF, 0x83, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x88,
  0x00, 0x62, 0x00, 0x18, 0xC0, 0x06, 0x10, 0x07, 0x83, 0x02, 0x60, 0x7F,
  0x0F, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x1F, 0x82, 0x40, 0xC5, 0x00, 0x4C,
  0x00, 0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x1A, 0x80, 0x24, 0x81, 0x88, 0xFC, 0x00, 0x07, 0xF0, 0x1C, 0x18,
  0x30, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x02, 0x20, 0x03, 0x30, 0x06, 0x1C, 0x1C, 0x07, 0xF0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x18, 0x1B, 0x30, 0x07,
  0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x03, 0x30, 0x07, 0x18, 0x1B, 0x07, 0xE3, 0x03, 0xF0,
  0x06, 0x06, 0x04, 0x01, 0x84, 0x00, 0x66, 0x00, 0x12, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x20, 0x01, 0x08, 0x01,
  0x03, 0x03, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x80, 0x30, 0x30, 0x0C, 0x02, 0x03, 0x00, 0x20, 0x40,
  0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x60, 0xC0,
  0x08, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x0F, 0xE0, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0x03, 0x00,
  0x18, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00,
  0x09, 0x80, 0x02, 0x18, 0x01, 0x80, 0xFF, 0xC0, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x3F, 0x09, 0x03, 0x38, 0x06, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFF,
  0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F,
  0xFF, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xA0,
  0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x03, 0x01, 0x03, 0x00,
  0x82, 0x00, 0x47, 0x80, 0x26, 0x40, 0x16, 0x30, 0x0E, 0x0C, 0x06, 0x03,
  0x02, 0x00, 0xC1, 0x00, 0x30, 0x80, 0x08, 0x40, 0x06, 0x20, 0x01, 0x90,
  0x00, 0x68, 0x00, 0x18, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x0F, 0xFF, 0xF8, 0x9E, 0x1F, 0x28, 0x48, 0x6C, 0x0C,
  0x0A, 0x03, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E, 0x02, 0x03,
  0x80, 0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0,
  0x20, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38, 0x08,
  0x0E, 0x02, 0x03, 0x8F, 0xC2, 0x40, 0xCE, 0x01, 0xB0, 0x02, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x84, 0x00, 0x66, 0x00,
  0x12, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x02,
  0x20, 0x03, 0x08, 0x03, 0x03, 0x03, 0x00, 0x7E, 0x00, 0x8F, 0xC1, 0x20,
  0x62, 0x80, 0x26, 0x00, 0x68, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0xC0, 0x0D, 0x40, 0x12, 0x40, 0xC4, 0x7E, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xE3, 0x18, 0x1B, 0x30, 0x07, 0x60, 0x03, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03,
  0x30, 0x07, 0x18, 0x1B, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x0F,
  0xE0, 0x26, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0,
  0x0C, 0x07, 0x0C, 0x00, 0xC4, 0x00, 0x36, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x40, 0x01, 0x98, 0x00,
  0x87, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x40, 0x1C, 0xE0, 0xD8, 0x7E, 0x30,
  0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x80,
  0x10, 0x40, 0x18, 0x30, 0x08, 0x08, 0x04, 0x04, 0x06, 0x03, 0x02, 0x00,
  0x83, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x01, 0x20,
  0x00, 0xB0, 0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x0A, 0x03, 0x80,
  0x50, 0x14, 0x06, 0x80, 0xA0, 0x24, 0x04, 0x81, 0x30, 0x64, 0x08, 0x82,
  0x20, 0x44, 0x11, 0x06, 0x20, 0x84, 0x21, 0x0C, 0x21, 0x0C, 0x41, 0x08,
  0x62, 0x08, 0x41, 0x10, 0x22, 0x09, 0x81, 0x30, 0x48, 0x09, 0x02, 0x40,
  0x48, 0x1A, 0x01, 0x40, 0x50, 0x0A, 0x03, 0x00, 0x50, 0x18, 0x03, 0x00,
  0xC0, 0x01, 0xB0, 0x01, 0x8C, 0x00, 0x83, 0x00, 0x80, 0x80, 0xC0, 0x20,
  0xC0, 0x18, 0x40, 0x06, 0x40, 0x01, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x2C, 0x00, 0x23, 0x00, 0x30, 0x80, 0x30, 0x60, 0x10, 0x18, 0x10, 0x06,
  0x18, 0x01, 0x18, 0x00, 0xD8, 0x00, 0x30, 0xC0, 0x00, 0xA0, 0x00, 0xD0,
  0x00, 0x4C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08,
  0x18, 0x04, 0x04, 0x06, 0x03, 0x02, 0x00, 0x83, 0x00, 0x61, 0x00, 0x10,
  0x80, 0x08, 0x80, 0x06, 0x40, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x03,
  0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x01, 0x81, 0xFC, 0x00, 0x0E, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x0E, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x26, 0x30, 0x04, 0x83, 0x01, 0xA0,
  0x20, 0x24, 0x02, 0x05, 0x80, 0x31, 0x20, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 27, 23, 10, -27 },
  { 12, 7, 10, 23, 8, -29 },
  { 21, 22, 27, 23, 1, -27 },
  { 96, 19, 35, 23, 2, -31 },
  { 180, 21, 27, 23, 1, -27 },
  { 251, 20, 27, 23, 1, -27 },
  { 319, 1, 10, 23, 11, -29 },
  { 321, 9, 35, 23, 9, -30 },
  { 361, 9, 35, 23, 5, -30 },
  { 401, 20, 19, 23, 2, -21 },
  { 449, 19, 19, 23, 2, -21 },
  { 495, 4, 10, 23, 9, -4 },
  { 500, 11, 1, 23, 6, -12 },
  { 502, 3, 3, 23, 10, -3 },
  { 504, 15, 35, 23, 4, -30 },
  { 570, 18, 27, 23, 3, -27 },
  { 631, 18, 27, 23, 3, -27 },
  { 692, 17, 27, 23, 3, -27 },
  { 750, 16, 27, 23, 3, -27 },
  { 804, 20, 27, 23, 2, -27 },
  { 872, 17, 27, 23, 3, -27 },
  { 930, 17, 27, 23, 3, -27 },
  { 988, 17, 27, 23, 3, -27 },
  { 1046, 18, 27, 23, 3, -27 },
  { 1107, 17, 27, 23, 3, -27 },
  { 1165, 3, 20, 23, 10, -20 },
  { 1173, 4, 26, 23, 9, -20 },
  { 1186, 17, 21, 23, 3, -22 },
  { 1231, 19, 8, 23, 2, -16 },
  { 1250, 17, 21, 23, 3, -22 },
  { 1295, 16, 27, 23, 4, -27 },
  { 1349, 17, 31, 23, 3, -27 },
  { 1415, 20, 27, 23, 2, -27 },
  { 1483, 16, 27, 23, 4, -27 },
  { 1537, 17, 27, 23, 3, -27 },
  { 1595, 17, 27, 23, 4, -27 },
  { 1653, 16, 27, 23, 4, -27 },
  { 1707, 16, 27, 23, 4, -27 },
  { 1761, 17, 27, 23, 3, -27 },
  { 1819, 16, 27, 23, 4, -27 },
  { 1873, 16, 27, 23, 4, -27 },
  { 1927, 14, 27, 23, 4, -27 },
  { 1975, 18, 27, 23, 4, -27 },
  { 2036, 16, 27, 23, 5, -27 },
  { 2090, 17, 27, 23, 3, -27 },
  { 2148, 16, 27, 23, 4, -27 },
  { 2202, 18, 27, 23, 3, -27 },
  { 2263, 17, 27, 23, 4, -27 },
  { 2321, 18, 32, 23, 3, -27 },
  { 2393, 17, 27, 23, 4, -27 },
  { 2451, 19, 27, 23, 2, -27 },
  { 2516, 21, 27, 23, 1, -27 },
  { 2587, 16, 27, 23, 4, -27 },
  { 2641, 19, 27, 23, 2, -27 },
  { 2706, 19, 27, 23, 2, -27 },
  { 2771, 20, 27, 23, 2, -27 },
  { 2839, 21, 27, 23, 1, -27 },
  { 2910, 20, 27, 23, 2, -27 },
  { 2978, 10, 35, 23, 10, -30 },
  { 3022, 15, 35, 23, 4, -30 },
  { 3088, 9, 35, 23, 4, -30 },
  { 3128, 19, 15, 23, 2, -27 },
  { 3164, 19, 1, 23, 2, 5 },
  { 3167, 5, 7, 23, 8, -30 },
  { 3172, 18, 20, 23, 3, -20 },
  { 3217, 15, 29, 23, 5, -29 },
  { 3272, 16, 20, 23, 4, -20 },
  { 3312, 16, 29, 23, 3, -29 },
  { 3370, 17, 20, 23, 3, -20 },
  { 3413, 18, 29, 23, 3, -29 },
  { 3479, 19, 29, 23, 3, -21 },
  { 3548, 14, 29, 23, 5, -29 },
  { 3599, 17, 29, 23, 4, -29 },
  { 3661, 13, 37, 23, 4, -29 },
  { 3722, 17, 29, 23, 5, -29 },
  { 3784, 17, 29, 23, 3, -29 },
  { 3846, 18, 20, 23, 3, -20 },
  { 3891, 14, 20, 23, 5, -20 },
  { 3926, 17, 20, 23, 3, -20 },
  { 3969, 15, 28, 23, 5, -20 },
  { 4022, 16, 28, 23, 3, -20 },
  { 4078, 19, 20, 23, 3, -20 },
  { 4126, 17, 20, 23, 3, -20 },
  { 4169, 19, 27, 23, 1, -27 },
  { 4234, 15, 20, 23, 4, -20 },
  { 4272, 17, 20, 23, 3, -20 },
  { 4315, 21, 20, 23, 1, -20 },
  { 4368, 17, 20, 23, 3, -20 },
  { 4411, 17, 28, 23, 3, -20 },
  { 4471, 16, 20, 23, 4, -20 },
  { 4511, 15, 35, 23, 4, -30 },
  { 4577, 1, 35, 23, 11, -30 },
  { 4582, 15, 35, 23, 4, -30 },
  { 4648, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_EXTRALIGHT39PT7B_H_
