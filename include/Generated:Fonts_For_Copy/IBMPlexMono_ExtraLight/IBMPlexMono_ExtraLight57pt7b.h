#ifndef _IBMPLEXMONO_EXTRALIGHT57PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x61, 0x08, 0x40, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0x7F, 0xDE, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0x84, 0x3C, 0x07, 0x01, 0x03, 0xC3, 0x80, 0x40,
  0x38, 0xC0, 0x10, 0x07, 0x60, 0x04, 0x00, 0x98, 0x01, 0x00, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x10, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01, 0x00, 0x06,
  0x00, 0x40, 0x01, 0x80, 0x10, 0x00, 0x70, 0x04, 0x00, 0x0C, 0x01, 0x00,
  0x03, 0xC0, 0x40, 0x00, 0x78, 0x10, 0x00, 0x07, 0xE4, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x13, 0xF0, 0x00, 0x04, 0x0E, 0x00,
  0x01, 0x01, 0xC0, 0x00, 0x40, 0x38, 0x00, 0x10, 0x07, 0x00, 0x04, 0x00,
  0xC0, 0x01, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x04,
  0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x40, 0x0D, 0x00, 0x10, 0x03, 0xC0,
  0x04, 0x01, 0xD8, 0x01, 0x00, 0x67, 0x80, 0x40, 0x38, 0x70, 0x10, 0x3C,
  0x0F, 0x84, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x0F, 0xFC,
  0x00, 0x06, 0x1C, 0x1E, 0x00, 0x0C, 0x38, 0x06, 0x00, 0x0C, 0x30, 0x03,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x01, 0x80, 0x30, 0x60, 0x01,
  0x80, 0x60, 0x60, 0x01, 0x80, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x60, 0x01, 0x81, 0x00, 0x60, 0x03,
  0x03, 0x00, 0x30, 0x03, 0x06, 0x00, 0x38, 0x06, 0x06, 0x00, 0x1C, 0x1E,
  0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x30, 0x38, 0x38, 0x00, 0x60, 0x60, 0x1C, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80,
  0x80, 0x06, 0x01, 0x01, 0x80, 0x02, 0x03, 0x01, 0x80, 0x02, 0x06, 0x01,
  0x80, 0x02, 0x06, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x80, 0x06, 0x0C, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x10, 0x00, 0xC0, 0x0C, 0x30, 0x00,
  0x60, 0x1C, 0x60, 0x00, 0x38, 0x38, 0x60, 0x00, 0x1F, 0xF0, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x73, 0x00, 0x1F, 0x86, 0x0C, 0x00, 0xC0, 0x60, 0x70,
  0x06, 0x06, 0x01, 0xC0, 0x20, 0x70, 0x07, 0x03, 0x03, 0x00, 0x1C, 0x18,
  0x18, 0x00, 0x60, 0xC1, 0xC0, 0x01, 0x86, 0x0C, 0x00, 0x06, 0x30, 0x60,
  0x00, 0x19, 0x83, 0x00, 0x00, 0xE8, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x78, 0x18, 0x00, 0x02, 0xE0, 0xE0, 0x00, 0x33,
  0x03, 0x80, 0x03, 0x0C, 0x1E, 0x00, 0x30, 0x30, 0x7C, 0x07, 0x00, 0xC0,
  0xFF, 0xF0, 0x07, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38,
  0x01, 0x80, 0x0D, 0xF8, 0x0C, 0x07, 0xF1, 0xF8, 0x61, 0xF8, 0x01, 0xFB,
  0x7E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xC7, 0x1C, 0x61, 0x86,
  0x30, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBF, 0xEF, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00,
  0x7C, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x79, 0x80, 0x00,
  0x1E, 0x30, 0x00, 0x07, 0x86, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x7C, 0x03, 0x80,
  0x0F, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0x80, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xFF,
  0x00, 0x23, 0xFF, 0xE0, 0x67, 0x00, 0xF0, 0x6C, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x7F, 0x00, 0x63, 0xFF, 0xE0, 0x67, 0x00, 0xF0, 0xCC, 0x00,
  0x38, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x78, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x18, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0x80, 0x78, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x80, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x71, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0x61, 0xC0, 0x03, 0x30, 0x7C, 0x07, 0x98, 0x1F, 0xFF, 0x18, 0x01,
  0xFE, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0xF7, 0xBF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0xFB, 0xC0,
  0x3C, 0x78, 0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71,
  0xE3, 0xC7, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x18, 0x30, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x1C, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x40, 0x07, 0xC2, 0xC0, 0x1F, 0xF2, 0xC0, 0x38, 0x1B, 0xC0, 0x70,
  0x0B, 0xC0, 0x60, 0x07, 0xC0, 0xC0, 0x07, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0x60,
  0x0B, 0xC0, 0x70, 0x1B, 0x40, 0x3F, 0xF3, 0x60, 0x0F, 0xE3, 0x60, 0x01,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06,
  0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x33, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x01, 0xE0, 0x03, 0x80, 0x3E, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x03, 0xE0,
  0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x58, 0x38, 0x00, 0xCC, 0x0F, 0x01, 0xE6,
  0x03, 0xFF, 0xC3, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xE0, 0x03, 0x81, 0xE0, 0x3C, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x0C, 0x1F,
  0x00, 0x03, 0x0C, 0xC0, 0x00, 0xC6, 0x38, 0x00, 0x33, 0x07, 0x00, 0x0D,
  0xC0, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x38, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xBF, 0x00, 0x00, 0xDE, 0xC0, 0x00, 0xCF, 0x60, 0x00, 0x67, 0x98, 0x00,
  0x63, 0xCC, 0x00, 0x31, 0xE3, 0x00, 0x18, 0xF1, 0x80, 0x18, 0x78, 0x60,
  0x0C, 0x3C, 0x30, 0x0C, 0x1E, 0x18, 0x06, 0x0F, 0x06, 0x06, 0x07, 0x83,
  0x03, 0x03, 0xC0, 0xC3, 0x01, 0xE0, 0x61, 0x80, 0xF0, 0x18, 0xC0, 0x78,
  0x0C, 0xC0, 0x3C, 0x03, 0x60, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x08, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0xC6, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3,
  0x80, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0,
  0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x03, 0xC0,
  0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x03, 0x03, 0xC0,
  0x03, 0x03, 0xC0, 0x01, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x7C, 0x07, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x07, 0x00, 0x66, 0x00, 0xF0, 0x06,
  0x60, 0x0F, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x20, 0x09, 0x80, 0x63, 0x01,
  0x98, 0x06, 0x30, 0x19, 0x80, 0x63, 0x01, 0x88, 0x04, 0x30, 0x10, 0xC0,
  0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x06, 0x0C, 0x30,
  0x60, 0x60, 0xC3, 0x06, 0x06, 0x0C, 0x30, 0x60, 0x60, 0xC1, 0x04, 0x03,
  0x0C, 0x18, 0xC0, 0x30, 0xC1, 0x8C, 0x03, 0x0C, 0x18, 0xC0, 0x18, 0x81,
  0x98, 0x01, 0x98, 0x19, 0x80, 0x19, 0x81, 0x98, 0x01, 0x98, 0x19, 0x80,
  0x0D, 0x81, 0xB0, 0x00, 0xD8, 0x1B, 0x00, 0x0D, 0x81, 0xB0, 0x00, 0x58,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x40, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x08, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xB0, 0x1C, 0x00, 0x66, 0x03,
  0xE0, 0x38, 0xFE, 0x1F, 0xFE, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x0F, 0xE0, 0x18,
  0xFF, 0xF0, 0x33, 0x80, 0xF0, 0x6C, 0x00, 0x70, 0xF0, 0x00, 0x71, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0x6C, 0x00, 0x70, 0xCE, 0x03, 0xC1, 0x8F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x03, 0xC0, 0x70,
  0x01, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x18, 0x60, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x78,
  0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0xF0, 0x60, 0x7F, 0xF8,
  0xC1, 0xE0, 0x39, 0x87, 0x00, 0x1B, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x80, 0x00, 0x33, 0x00, 0x00, 0x67, 0x00, 0x01, 0xC7, 0x00, 0x07,
  0x87, 0x00, 0x1B, 0x07, 0x80, 0xE6, 0x07, 0xFF, 0x8C, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x30, 0x00, 0x07, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x38,
  0x07, 0x80, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0x98, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x0F, 0xE0, 0x63, 0xFF, 0xC3, 0x38,
  0x0F, 0x1B, 0x00, 0x1C, 0xD0, 0x00, 0x67, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x71, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0xF8, 0x00, 0x31, 0xCC, 0x00, 0x19, 0xC3, 0x00,
  0x0D, 0xC0, 0xC0, 0x07, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x07,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x33, 0xFC, 0x3F, 0xCD, 0x83, 0x98,
  0x3B, 0x40, 0x6C, 0x07, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C,
  0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0,
  0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C,
  0x00, 0xF0, 0x03, 0x00, 0x30, 0x00, 0xFE, 0x06, 0x3F, 0xFC, 0x33, 0x80,
  0xF1, 0xB0, 0x01, 0xCD, 0x00, 0x06, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x0F, 0x80, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0x8F, 0xFF, 0x03, 0x38, 0x0F, 0x06, 0xC0, 0x07, 0x0F, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73,
  0xC0, 0x01, 0xC6, 0xC0, 0x07, 0x0C, 0xE0, 0x3C, 0x18, 0xFF, 0xF0, 0x30,
  0x7F, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x8C, 0x1E, 0x03, 0x98, 0x70, 0x01, 0xB1, 0xC0, 0x01, 0xE7, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x78, 0x70, 0x01, 0xB0, 0x78, 0x0E, 0x60, 0x7F, 0xF8, 0xC0, 0x3F, 0xC1,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x03, 0x83,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x39, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x87,
  0x80, 0x01, 0xC0, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x70,
  0x00, 0x39, 0x80, 0x01, 0xCE, 0x00, 0x36, 0x3C, 0x07, 0x30, 0xFF, 0xF1,
  0x80, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x34, 0x00, 0x78, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0x60, 0x04, 0xC0,
  0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x10, 0x06,
  0x20, 0x08, 0x60, 0x18, 0xC0, 0x61, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x08, 0x0C, 0x30, 0x10, 0x30, 0x30, 0x40, 0xC0, 0xC0, 0xC1, 0x83,
  0x03, 0x03, 0x06, 0x0C, 0x04, 0x08, 0x18, 0x20, 0x18, 0x60, 0x61, 0x80,
  0x61, 0x81, 0x86, 0x01, 0x86, 0x02, 0x18, 0x02, 0x18, 0x0C, 0x40, 0x0C,
  0x40, 0x33, 0x00, 0x33, 0x00, 0xCC, 0x00, 0xCC, 0x03, 0x30, 0x01, 0x30,
  0x04, 0x80, 0x06, 0xC0, 0x1E, 0x00, 0x1A, 0x00, 0x78, 0x00, 0x68, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x30, 0xFF,
  0x00, 0x03, 0x1C, 0x78, 0x00, 0x33, 0x81, 0xC0, 0x02, 0x30, 0x0C, 0x00,
  0x62, 0x00, 0x60, 0x06, 0x60, 0x03, 0x00, 0xC6, 0x00, 0x18, 0x0C, 0x40,
  0x01, 0xE3, 0x8C, 0x00, 0x07, 0xF0, 0xC0, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 5, 40, 34, 15, -40 },
  { 26, 10, 15, 34, 12, -42 },
  { 45, 32, 40, 34, 1, -40 },
  { 205, 26, 53, 34, 4, -46 },
  { 378, 32, 41, 34, 1, -40 },
  { 542, 29, 41, 34, 2, -40 },
  { 691, 2, 15, 34, 16, -42 },
  { 695, 14, 51, 34, 13, -43 },
  { 785, 14, 51, 34, 7, -43 },
  { 875, 29, 28, 34, 3, -31 },
  { 977, 27, 28, 34, 4, -31 },
  { 1072, 6, 14, 34, 13, -5 },
  { 1083, 16, 2, 34, 9, -18 },
  { 1087, 5, 5, 34, 15, -5 },
  { 1091, 22, 51, 34, 6, -43 },
  { 1232, 26, 41, 34, 4, -40 },
  { 1366, 27, 40, 34, 4, -40 },
  { 1501, 25, 40, 34, 5, -40 },
  { 1626, 24, 41, 34, 4, -40 },
  { 1749, 29, 40, 34, 3, -40 },
  { 1894, 24, 41, 34, 5, -40 },
  { 2017, 24, 41, 34, 5, -40 },
  { 2140, 25, 40, 34, 4, -40 },
  { 2265, 26, 41, 34, 4, -40 },
  { 2399, 25, 40, 34, 5, -40 },
  { 2524, 5, 31, 34, 15, -31 },
  { 2544, 7, 40, 34, 13, -31 },
  { 2579, 24, 31, 34, 5, -33 },
  { 2672, 27, 13, 34, 4, -24 },
  { 2716, 24, 31, 34, 5, -33 },
  { 2809, 24, 40, 34, 5, -40 },
  { 2929, 24, 46, 34, 5, -40 },
  { 3067, 29, 40, 34, 3, -40 },
  { 3212, 25, 40, 34, 5, -40 },
  { 3337, 26, 41, 34, 4, -40 },
  { 3471, 24, 40, 34, 6, -40 },
  { 3591, 23, 40, 34, 6, -40 },
  { 3706, 24, 40, 34, 6, -40 },
  { 3826, 25, 41, 34, 4, -40 },
  { 3955, 24, 40, 34, 5, -40 },
  { 4075, 24, 40, 34, 5, -40 },
  { 4195, 22, 41, 34, 5, -40 },
  { 4308, 26, 40, 34, 6, -40 },
  { 4438, 22, 40, 34, 8, -40 },
  { 4548, 25, 40, 34, 5, -40 },
  { 4673, 24, 40, 34, 5, -40 },
  { 4793, 26, 41, 34, 4, -40 },
  { 4927, 24, 40, 34, 6, -40 },
  { 5047, 26, 49, 34, 4, -40 },
  { 5207, 24, 40, 34, 6, -40 },
  { 5327, 27, 41, 34, 3, -40 },
  { 5466, 30, 40, 34, 2, -40 },
  { 5616, 24, 41, 34, 5, -40 },
  { 5739, 28, 40, 34, 3, -40 },
  { 5879, 28, 40, 34, 3, -40 },
  { 6019, 29, 40, 34, 3, -40 },
  { 6164, 32, 40, 34, 1, -40 },
  { 6324, 28, 40, 34, 3, -40 },
  { 6464, 14, 51, 34, 15, -43 },
  { 6554, 22, 51, 34, 6, -43 },
  { 6695, 14, 51, 34, 6, -43 },
  { 6785, 27, 22, 34, 4, -40 },
  { 6860, 28, 2, 34, 3, 7 },
  { 6867, 8, 10, 34, 11, -44 },
  { 6877, 27, 31, 34, 4, -30 },
  { 6982, 23, 43, 34, 7, -42 },
  { 7106, 23, 31, 34, 6, -30 },
  { 7196, 23, 43, 34, 4, -42 },
  { 7320, 24, 31, 34, 5, -30 },
  { 7413, 26, 42, 34, 5, -42 },
  { 7550, 27, 45, 34, 5, -33 },
  { 7702, 21, 42, 34, 7, -42 },
  { 7813, 25, 42, 34, 6, -42 },
  { 7945, 21, 53, 34, 5, -42 },
  { 8085, 25, 42, 34, 7, -42 },
  { 8217, 24, 42, 34, 5, -42 },
  { 8343, 26, 30, 34, 4, -30 },
  { 8441, 21, 30, 34, 7, -30 },
  { 8520, 24, 31, 34, 5, -30 },
  { 8613, 23, 41, 34, 7, -30 },
  { 8731, 23, 41, 34, 4, -30 },
  { 8849, 28, 29, 34, 4, -29 },
  { 8951, 25, 31, 34, 5, -30 },
  { 9048, 28, 40, 34, 2, -40 },
  { 9188, 21, 30, 34, 6, -29 },
  { 9267, 24, 29, 34, 5, -29 },
  { 9354, 30, 29, 34, 2, -29 },
  { 9463, 25, 29, 34, 5, -29 },
  { 9554, 26, 40, 34, 4, -29 },
  { 9684, 23, 29, 34, 6, -29 },
  { 9768, 22, 51, 34, 6, -43 },
  { 9909, 2, 51, 34, 16, -43 },
  { 9922, 22, 51, 34, 6, -43 },
  { 10063, 28, 11, 34, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_EXTRALIGHT57PT7B_H_
