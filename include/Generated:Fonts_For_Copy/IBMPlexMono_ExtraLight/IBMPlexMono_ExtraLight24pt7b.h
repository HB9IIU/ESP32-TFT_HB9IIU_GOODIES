#ifndef _IBMPLEXMONO_EXTRALIGHT24PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x5A, 0x03, 0xC0, 0x99, 0x99, 0x99, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x01, 0x08, 0x04, 0x41, 0xF1, 0xF0, 0x44, 0x01, 0x10, 0x08,
  0x40, 0x21, 0x00, 0x88, 0x3E, 0x3E, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04,
  0x20, 0x11, 0x00, 0x02, 0x00, 0x20, 0x1F, 0x83, 0x26, 0x42, 0x24, 0x21,
  0x42, 0x04, 0x20, 0x62, 0x03, 0xA0, 0x0F, 0x80, 0x26, 0x02, 0x20, 0x21,
  0x02, 0x18, 0x21, 0x42, 0x23, 0x26, 0x0F, 0x80, 0x20, 0x02, 0x00, 0x78,
  0x1E, 0x20, 0xA1, 0x09, 0x08, 0x48, 0x64, 0x42, 0x23, 0x12, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x06, 0xC4, 0x24, 0x22, 0x20, 0xA1, 0x05, 0x08, 0x50,
  0x62, 0x81, 0xE0, 0x1E, 0x03, 0x10, 0x20, 0x84, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x28, 0x74, 0x44, 0x82, 0x48, 0x34, 0x81, 0xC8, 0x08,
  0x80, 0xC4, 0x12, 0x3E, 0x10, 0xFC, 0x08, 0x88, 0x84, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x42, 0x08, 0x20, 0x80, 0xC0, 0x82, 0x04, 0x08,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x42, 0x08, 0xC0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x13, 0xAE, 0x07, 0x00, 0x50,
  0x09, 0x01, 0x08, 0x10, 0x42, 0x04, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x2D,
  0x25, 0x00, 0xFC, 0xF0, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x0C, 0x31, 0x01, 0x40,
  0x28, 0x05, 0x00, 0x60, 0x0C, 0x61, 0x8C, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0x90, 0x13, 0x0C, 0x1F, 0x00, 0x0C, 0x03, 0x80, 0xD0, 0x32,
  0x0C, 0x41, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x1F, 0x0C, 0x31, 0x02, 0x40,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x3E, 0x18, 0x68, 0x08, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x78, 0x03, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x09, 0x06, 0x3E, 0x00, 0x00, 0xC0, 0x14, 0x01, 0x40, 0x24, 0x04,
  0x40, 0x84, 0x08, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x48, 0x04, 0xFF,
  0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7F, 0xD0, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x05, 0xF2, 0x86, 0x40, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x05, 0x86, 0x1E, 0x00, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10,
  0x04, 0x03, 0x7C, 0xA1, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05,
  0x86, 0x1F, 0x00, 0xFF, 0xE0, 0x18, 0x06, 0x02, 0x80, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30,
  0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00, 0x90, 0x13, 0x04,
  0x1F, 0x08, 0x32, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x13, 0x06, 0x3F,
  0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x1A, 0x02,
  0x60, 0xC3, 0xE8, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x16, 0x92, 0x80,
  0x00, 0x40, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x40, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x02, 0x03,
  0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x06, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x80, 0x61, 0xD8,
  0x8E, 0x41, 0x90, 0x64, 0x19, 0x06, 0x41, 0x90, 0x62, 0x18, 0x7E, 0x00,
  0x40, 0x10, 0x03, 0x00, 0x7E, 0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09,
  0x00, 0x88, 0x10, 0x81, 0x08, 0x10, 0x41, 0x04, 0x20, 0x43, 0xFE, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x01, 0x80, 0x10, 0xFF, 0x10, 0x12, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x28,
  0x03, 0x00, 0xA0, 0x14, 0x06, 0xFF, 0x00, 0x1F, 0x06, 0x11, 0x01, 0x20,
  0x28, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x80, 0xD0, 0x11, 0x04, 0x1F, 0x00, 0xFC, 0x20, 0xC8, 0x1A, 0x02,
  0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0,
  0x28, 0x1A, 0x0C, 0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0xD0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x1F, 0x08, 0x64, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0C, 0x83, 0x1F,
  0x40, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xFF,
  0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x3F, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x07, 0x02, 0xC2, 0x3E, 0x00, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88, 0x21,
  0x08, 0x23, 0x04, 0x40, 0x94, 0x14, 0x83, 0x08, 0x40, 0x88, 0x11, 0x01,
  0x20, 0x14, 0x02, 0x80, 0x20, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0x80, 0x70, 0x1C, 0x0E, 0x83, 0xA1, 0x68, 0x59, 0x16,
  0x49, 0x8A, 0x63, 0x18, 0x46, 0x21, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0xC0, 0x70, 0x1A, 0x06, 0x81, 0x90, 0x64, 0x18, 0x86, 0x21, 0x84,
  0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x03, 0x80, 0x40, 0x1F,
  0x0C, 0x31, 0x01, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x13, 0x0C, 0x1F, 0x00, 0xFF,
  0x90, 0x1A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xDF,
  0xF2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x1F,
  0x0C, 0x31, 0x01, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x13, 0x0C, 0x1E, 0x00, 0x80,
  0x10, 0x03, 0xE0, 0xFF, 0x90, 0x1A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x80, 0xDF, 0xF2, 0x10, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24,
  0x02, 0x80, 0x60, 0x1F, 0x83, 0x06, 0x40, 0x24, 0x01, 0x40, 0x04, 0x00,
  0x60, 0x03, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01,
  0x40, 0x23, 0x06, 0x0F, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x05, 0x82, 0x1F, 0x00, 0x80, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x20, 0x22, 0x04, 0x20, 0x42, 0x04, 0x10, 0x41, 0x08, 0x10, 0x80,
  0x88, 0x09, 0x00, 0x90, 0x05, 0x00, 0x60, 0x06, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x21, 0x46, 0x14, 0x62, 0x45, 0x24, 0x92,
  0x49, 0x24, 0x8A, 0x50, 0xA5, 0x0A, 0x50, 0xA5, 0x06, 0x20, 0x60, 0xC0,
  0x14, 0x02, 0x20, 0x21, 0x04, 0x10, 0x80, 0x88, 0x0D, 0x00, 0x60, 0x02,
  0x00, 0x50, 0x09, 0x00, 0x88, 0x10, 0x82, 0x04, 0x20, 0x24, 0x02, 0x80,
  0x10, 0x80, 0x1A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x08, 0x40, 0x22,
  0x01, 0x20, 0x05, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x0C, 0x01, 0x40, 0x48, 0x08, 0x82,
  0x10, 0x81, 0x10, 0x24, 0x02, 0x80, 0x20, 0xFF, 0xF0, 0x89, 0x10, 0x3E,
  0x18, 0x20, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x30, 0x24, 0x04, 0x80, 0x90,
  0x13, 0x0E, 0x3E, 0x70, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0B,
  0xE3, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02,
  0xC1, 0x2F, 0x80, 0x1F, 0x08, 0x24, 0x05, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x12, 0x08, 0x7C, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x13, 0xE5, 0x85, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x03, 0x61, 0x4F, 0x90, 0x1F, 0x18, 0x24, 0x06, 0x01, 0x80, 0x7F,
  0xF8, 0x02, 0x00, 0x80, 0x10, 0x16, 0x08, 0x7C, 0x07, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0xF8, 0x00, 0xE3, 0xE0,
  0x86, 0x20, 0x44, 0x04, 0x80, 0x90, 0x21, 0x0C, 0x1E, 0x04, 0x01, 0x00,
  0x20, 0x03, 0xFC, 0x80, 0x60, 0x0C, 0x01, 0x40, 0x67, 0xF0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0xC6, 0x81, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xFC, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x34, 0x08, 0x82, 0x10, 0x82, 0x20, 0x5C,
  0x0C, 0x41, 0x04, 0x20, 0x44, 0x08, 0x80, 0x90, 0x0C, 0xFC, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0xF1, 0xD1, 0x4E, 0x30,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2,
  0x10, 0x9E, 0x71, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x1F, 0x18, 0x64, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x16, 0x18, 0x7C, 0xBE, 0x30, 0x48, 0x0A, 0x02, 0x80,
  0xA0, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x2C, 0x12, 0xF8, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x3E, 0x58, 0x5C, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x36, 0x14, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0xF9, 0xE1, 0x40, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xE0, 0x3F, 0x18, 0x34, 0x09, 0x00,
  0x40, 0x0F, 0x80, 0x3C, 0x01, 0x00, 0x60, 0x16, 0x0C, 0x7C, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xF0,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xF0,
  0xA7, 0x90, 0x80, 0x60, 0x14, 0x09, 0x02, 0x20, 0x88, 0x42, 0x10, 0x48,
  0x12, 0x02, 0x80, 0xC0, 0x30, 0x82, 0x1C, 0x30, 0xA1, 0x85, 0x0A, 0x28,
  0x91, 0x24, 0x89, 0x24, 0x8A, 0x14, 0x50, 0xA2, 0x85, 0x0C, 0x28, 0x40,
  0x80, 0x80, 0x50, 0x22, 0x10, 0x44, 0x0A, 0x03, 0x00, 0xC0, 0x48, 0x11,
  0x08, 0x24, 0x0A, 0x01, 0x80, 0x70, 0x09, 0x01, 0x20, 0x42, 0x08, 0x42,
  0x08, 0x40, 0x90, 0x12, 0x01, 0x40, 0x30, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0xF0, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0xFF, 0x1F, 0x88, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x06, 0x3C, 0x03, 0x80, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20, 0x08, 0x03, 0xE3, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x38, 0x14,
  0x41, 0x42, 0x38, 0x32, 0x81, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 4, 6, 14, 5, -18 },
  { 9, 14, 17, 14, 0, -17 },
  { 39, 12, 21, 14, 1, -19 },
  { 71, 13, 17, 14, 1, -17 },
  { 99, 12, 17, 14, 1, -17 },
  { 125, 1, 6, 14, 7, -18 },
  { 126, 5, 21, 14, 6, -18 },
  { 140, 6, 21, 14, 3, -18 },
  { 156, 12, 12, 14, 1, -13 },
  { 174, 12, 11, 14, 1, -13 },
  { 191, 3, 6, 14, 5, -2 },
  { 194, 6, 1, 14, 4, -8 },
  { 195, 2, 2, 14, 6, -2 },
  { 196, 10, 21, 14, 2, -18 },
  { 223, 11, 17, 14, 2, -17 },
  { 247, 11, 17, 14, 2, -17 },
  { 271, 11, 17, 14, 2, -17 },
  { 295, 10, 17, 14, 2, -17 },
  { 317, 12, 17, 14, 1, -17 },
  { 343, 10, 17, 14, 2, -17 },
  { 365, 10, 17, 14, 2, -17 },
  { 387, 10, 17, 14, 2, -17 },
  { 409, 11, 17, 14, 2, -17 },
  { 433, 11, 17, 14, 2, -17 },
  { 457, 2, 13, 14, 6, -13 },
  { 461, 3, 17, 14, 5, -13 },
  { 468, 10, 13, 14, 2, -14 },
  { 485, 12, 5, 14, 1, -10 },
  { 493, 10, 13, 14, 2, -14 },
  { 510, 10, 17, 14, 2, -17 },
  { 532, 10, 20, 14, 2, -17 },
  { 557, 12, 17, 14, 1, -17 },
  { 583, 11, 17, 14, 2, -17 },
  { 607, 11, 17, 14, 2, -17 },
  { 631, 10, 17, 14, 3, -17 },
  { 653, 10, 17, 14, 2, -17 },
  { 675, 11, 17, 14, 2, -17 },
  { 699, 10, 17, 14, 2, -17 },
  { 721, 10, 17, 14, 2, -17 },
  { 743, 10, 17, 14, 2, -17 },
  { 765, 9, 17, 14, 2, -17 },
  { 785, 11, 17, 14, 2, -17 },
  { 809, 10, 17, 14, 3, -17 },
  { 831, 10, 17, 14, 2, -17 },
  { 853, 10, 17, 14, 2, -17 },
  { 875, 11, 17, 14, 2, -17 },
  { 899, 11, 17, 14, 2, -17 },
  { 923, 11, 20, 14, 2, -17 },
  { 951, 11, 17, 14, 2, -17 },
  { 975, 12, 17, 14, 1, -17 },
  { 1001, 13, 17, 14, 1, -17 },
  { 1029, 10, 17, 14, 2, -17 },
  { 1051, 12, 17, 14, 1, -17 },
  { 1077, 12, 17, 14, 1, -17 },
  { 1103, 12, 17, 14, 1, -17 },
  { 1129, 13, 17, 14, 1, -17 },
  { 1157, 12, 17, 14, 1, -17 },
  { 1183, 6, 21, 14, 6, -18 },
  { 1199, 10, 21, 14, 2, -18 },
  { 1226, 6, 21, 14, 2, -18 },
  { 1242, 11, 9, 14, 2, -17 },
  { 1255, 12, 1, 14, 1, 3 },
  { 1257, 3, 4, 14, 5, -18 },
  { 1259, 11, 12, 14, 2, -12 },
  { 1276, 10, 18, 14, 3, -18 },
  { 1299, 10, 12, 14, 2, -12 },
  { 1314, 10, 18, 14, 2, -18 },
  { 1337, 10, 12, 14, 2, -12 },
  { 1352, 11, 18, 14, 2, -18 },
  { 1377, 11, 18, 14, 2, -13 },
  { 1402, 9, 18, 14, 3, -18 },
  { 1423, 10, 18, 14, 3, -18 },
  { 1446, 9, 23, 14, 2, -18 },
  { 1472, 11, 18, 14, 3, -18 },
  { 1497, 10, 18, 14, 2, -18 },
  { 1520, 11, 12, 14, 2, -12 },
  { 1537, 9, 12, 14, 3, -12 },
  { 1551, 10, 12, 14, 2, -12 },
  { 1566, 10, 17, 14, 3, -12 },
  { 1588, 10, 17, 14, 2, -12 },
  { 1610, 11, 12, 14, 2, -12 },
  { 1627, 10, 12, 14, 2, -12 },
  { 1642, 12, 17, 14, 1, -17 },
  { 1668, 9, 12, 14, 3, -12 },
  { 1682, 10, 12, 14, 2, -12 },
  { 1697, 13, 12, 14, 1, -12 },
  { 1717, 10, 12, 14, 2, -12 },
  { 1732, 11, 17, 14, 2, -12 },
  { 1756, 10, 12, 14, 2, -12 },
  { 1771, 9, 21, 14, 3, -18 },
  { 1795, 1, 21, 14, 7, -18 },
  { 1798, 9, 21, 14, 3, -18 },
  { 1822, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_EXTRALIGHT24PT7B_H_
