#ifndef _IBMPLEXMONO_EXTRALIGHT38PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight38pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0xFF, 0x80,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x00, 0x41, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40,
  0x80, 0x02, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x82, 0x03, 0xF8, 0x1F, 0xC0,
  0x40, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x04, 0x07, 0xF0, 0x7F, 0x80, 0x83, 0x00, 0x0C,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x03, 0x11, 0xC3, 0x04, 0x18,
  0x81, 0x03, 0x60, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x60,
  0x40, 0x08, 0x10, 0x03, 0x04, 0x00, 0x61, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x04, 0x70, 0x01, 0x06, 0x00, 0x40, 0xC0, 0x10, 0x30, 0x04, 0x04,
  0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x14, 0x04, 0x0F, 0x81, 0x02, 0x30,
  0x41, 0x87, 0x11, 0x80, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x1F, 0x00, 0x19, 0x8C, 0x00, 0x90, 0x10, 0x08, 0x80,
  0x80, 0x4C, 0x06, 0x04, 0x40, 0x10, 0x62, 0x00, 0x82, 0x10, 0x04, 0x20,
  0xC0, 0x61, 0x02, 0x02, 0x10, 0x10, 0x11, 0x80, 0x63, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x0C, 0x03, 0x10, 0x30,
  0x31, 0x80, 0x81, 0x08, 0x04, 0x18, 0x40, 0x30, 0x82, 0x01, 0x88, 0x10,
  0x0C, 0x40, 0x80, 0x44, 0x06, 0x02, 0x60, 0x10, 0x32, 0x00, 0xC3, 0x30,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x61, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x01, 0x90,
  0x0F, 0x30, 0x81, 0x82, 0x04, 0x18, 0x60, 0x61, 0x84, 0x03, 0x10, 0x40,
  0x19, 0x0C, 0x00, 0xD0, 0xC0, 0x05, 0x04, 0x00, 0x30, 0x40, 0x03, 0x06,
  0x00, 0x48, 0x30, 0x08, 0xC1, 0x81, 0x06, 0x07, 0xC0, 0x30, 0xFF, 0xC0,
  0x01, 0x81, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x20, 0x60, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x0F, 0x02,
  0x0F, 0x3C, 0x4F, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x50, 0x00, 0x13,
  0x00, 0x06, 0x30, 0x01, 0x82, 0x00, 0x20, 0x20, 0x08, 0x06, 0x03, 0x00,
  0x60, 0x40, 0x04, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x76,
  0x66, 0x4C, 0xC8, 0x88, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0x46, 0x00, 0x32, 0x00,
  0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x0C, 0x40, 0x04, 0x30, 0x04, 0x0E, 0x0C, 0x01, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0xD0, 0x00, 0x64, 0x00, 0x31, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x07, 0xFF, 0xFC, 0x07,
  0xE0, 0x0C, 0x0C, 0x0C, 0x03, 0x0C, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x06,
  0x06, 0x0C, 0x01, 0x84, 0x00, 0x66, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x05, 0x80, 0x06,
  0x30, 0x06, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80,
  0x04, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30, 0x20, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0x40, 0x03, 0x0F, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x67, 0xF0,
  0x48, 0x1C, 0x50, 0x06, 0x20, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x02,
  0x60, 0x06, 0x38, 0x18, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x7E, 0x04, 0xC1, 0xC6, 0x80, 0x33,
  0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x04, 0xC0, 0x04, 0x30, 0x06, 0x0E,
  0x0E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00,
  0x68, 0x00, 0x24, 0x00, 0x32, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xF0, 0x0C, 0x0E, 0x0C, 0x01, 0x8C, 0x00, 0x64, 0x00,
  0x16, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x30, 0x01, 0x8C,
  0x01, 0x83, 0x03, 0x80, 0x7E, 0x00, 0xC0, 0xE1, 0x80, 0x08, 0x80, 0x02,
  0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x06, 0x80, 0x02, 0x60, 0x02, 0x0C, 0x06, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x0E, 0x0E, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x12, 0x00,
  0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x68,
  0x00, 0x36, 0x00, 0x39, 0x80, 0x28, 0x70, 0x64, 0x0F, 0xC6, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x76, 0x66, 0x4C, 0xC8, 0x88, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x08, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x70, 0x71, 0x80,
  0x32, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x03, 0x80, 0x7C, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xF0,
  0x0C, 0x18, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01,
  0x40, 0x01, 0x40, 0xF9, 0x41, 0x85, 0xC3, 0x03, 0xC2, 0x01, 0xC2, 0x01,
  0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x01, 0xC2, 0x01,
  0xC2, 0x01, 0xC3, 0x03, 0x41, 0x05, 0x40, 0xF9, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xFE,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x13, 0x00,
  0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0xC0, 0x02, 0x08, 0x00, 0xC1, 0x00,
  0x10, 0x30, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x02, 0x00, 0x80,
  0xC0, 0x10, 0x18, 0x03, 0x03, 0xFF, 0xE0, 0x40, 0x04, 0x18, 0x00, 0xC2,
  0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x58,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x10, 0xFF, 0xE0, 0x80, 0x18, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x1C, 0xFF, 0xF0, 0x03,
  0xF0, 0x06, 0x06, 0x06, 0x00, 0x86, 0x00, 0x62, 0x00, 0x1B, 0x00, 0x09,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x08, 0x80, 0x06,
  0x60, 0x06, 0x18, 0x02, 0x06, 0x06, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x80,
  0x30, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x30, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x03, 0xF0, 0x06, 0x0E, 0x04, 0x01, 0x84, 0x00, 0x46,
  0x00, 0x12, 0x00, 0x0B, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A,
  0x00, 0x0D, 0x80, 0x06, 0x40, 0x07, 0x10, 0x05, 0x86, 0x04, 0xC1, 0xFC,
  0x60, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x1F, 0xFE,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xF0, 0x01, 0x20, 0x06, 0x20, 0x08, 0x70, 0x60, 0x3F,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x88, 0x01, 0x84,
  0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0xC0, 0x40, 0xC0, 0x20, 0xC0,
  0x10, 0xC0, 0x08, 0xF0, 0x04, 0x48, 0x02, 0x46, 0x01, 0x41, 0x80, 0xE0,
  0x40, 0x60, 0x30, 0x20, 0x0C, 0x10, 0x02, 0x08, 0x01, 0x84, 0x00, 0x62,
  0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0x40, 0x01, 0xA0, 0x00, 0x60, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFF, 0xF8, 0xC0, 0x01, 0xF0, 0x01, 0xE8, 0x00, 0xF4, 0x00, 0xF9, 0x00,
  0x7C, 0x80, 0x2E, 0x60, 0x37, 0x10, 0x13, 0x8C, 0x19, 0xC2, 0x08, 0xE1,
  0x04, 0x70, 0xC6, 0x38, 0x22, 0x1C, 0x1B, 0x0E, 0x05, 0x07, 0x03, 0x83,
  0x80, 0x81, 0xC0, 0x40, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x32, 0x00, 0x66,
  0x00, 0xC4, 0x01, 0x8C, 0x03, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x18, 0x30,
  0x30, 0x20, 0x60, 0x60, 0xC0, 0x41, 0x80, 0xC3, 0x00, 0x86, 0x01, 0x8C,
  0x01, 0x18, 0x03, 0x30, 0x02, 0x60, 0x06, 0xC0, 0x05, 0x80, 0x0B, 0x00,
  0x0E, 0x00, 0x18, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0x46,
  0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x0C, 0x40, 0x04, 0x30, 0x04, 0x0E, 0x0C, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x0C, 0xFF, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x0E, 0x0C, 0x0C,
  0x01, 0x04, 0x00, 0x46, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x40, 0x04, 0x30, 0x04,
  0x0E, 0x0C, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0xFF, 0xF0, 0x81, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x18, 0x80,
  0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0x03, 0xFC, 0x03,
  0x01, 0xC3, 0x00, 0x18, 0x80, 0x03, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x14, 0x00,
  0x0F, 0x80, 0x02, 0x30, 0x01, 0x87, 0x01, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0,
  0x01, 0xA0, 0x02, 0x60, 0x0C, 0x60, 0x30, 0x3F, 0x80, 0xC0, 0x00, 0x78,
  0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x61, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x20, 0x06,
  0x0C, 0x00, 0xC1, 0x00, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x31, 0x00, 0x02,
  0x20, 0x00, 0x4C, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x2C,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0xC0, 0x48,
  0x1C, 0x09, 0x02, 0x81, 0x20, 0x50, 0x24, 0x1A, 0x0C, 0x82, 0x61, 0x98,
  0x44, 0x23, 0x08, 0x84, 0x23, 0x18, 0x84, 0x41, 0x10, 0x88, 0x22, 0x13,
  0x04, 0x42, 0x40, 0xC8, 0x48, 0x09, 0x09, 0x01, 0x21, 0x60, 0x2C, 0x28,
  0x07, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x18,
  0x80, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x10, 0x04, 0x03, 0x01, 0x80,
  0x20, 0x60, 0x02, 0x08, 0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0xD0, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x0D, 0x80, 0x01, 0x10, 0x00,
  0x43, 0x00, 0x18, 0x30, 0x02, 0x02, 0x00, 0x80, 0x60, 0x30, 0x06, 0x04,
  0x00, 0x41, 0x00, 0x0C, 0x60, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x1A, 0x00, 0x01, 0x88, 0x00, 0x08, 0x60, 0x00, 0xC1, 0x00,
  0x0C, 0x0C, 0x00, 0x40, 0x30, 0x06, 0x00, 0x80, 0x20, 0x06, 0x02, 0x00,
  0x18, 0x30, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x09, 0x80, 0x00, 0x68,
  0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0xFF,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x1B, 0x00, 0x04, 0x40, 0x02,
  0x18, 0x01, 0x82, 0x00, 0x40, 0x40, 0x30, 0x18, 0x08, 0x02, 0x04, 0x00,
  0xC3, 0x00, 0x10, 0x80, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x08,
  0xFF, 0xFF, 0xE0, 0x82, 0x18, 0x41, 0x0C, 0x0F, 0xE0, 0x1C, 0x18, 0x18,
  0x02, 0x08, 0x01, 0x88, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x07, 0xFE, 0x0C, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0xC0, 0x0C, 0x20, 0x0A, 0x1C, 0x19, 0x03,
  0xF0, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0, 0xD8, 0x18, 0xE0, 0x0C,
  0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x02, 0xE0, 0x06, 0xE0, 0x0C, 0xD8, 0x18, 0xC7, 0xE0, 0x07, 0xE0,
  0x30, 0x30, 0xC0, 0x33, 0x00, 0x34, 0x00, 0x48, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x01, 0x60, 0x06, 0x60, 0x08, 0x60, 0x60, 0x3F, 0x00,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x07, 0xE2, 0x30, 0x24, 0xC0, 0x2B, 0x00, 0x34, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x60, 0x06, 0x60,
  0x14, 0x60, 0x48, 0x3F, 0x10, 0x03, 0xF0, 0x06, 0x0C, 0x04, 0x01, 0x04,
  0x00, 0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x02, 0x20, 0x03, 0x08, 0x03, 0x03, 0x03, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0xF9, 0x00, 0xC1, 0xC0, 0x40, 0x10, 0x30, 0x06, 0x08,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x83, 0x00,
  0x60, 0x40, 0x10, 0x0C, 0x18, 0x01, 0xF8, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x01, 0x98,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x26, 0x00,
  0x18, 0xC0, 0x1C, 0x0F, 0xF8, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xC2, 0x41, 0x8E,
  0x01, 0x30, 0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x2F, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06,
  0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x40, 0x80, 0x80, 0x83, 0x00,
  0x86, 0x00, 0x8E, 0x00, 0x9B, 0x00, 0xB1, 0x80, 0xE0, 0xC0, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x30, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x9E, 0x1E,
  0x51, 0x90, 0xB0, 0x70, 0x70, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x8F, 0xC2, 0x41, 0x8E, 0x01, 0x30, 0x06,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00,
  0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0xC0, 0x06, 0x20, 0x02, 0x18, 0x02, 0x07, 0x06, 0x00, 0xFC, 0x00, 0xC7,
  0xE0, 0xD8, 0x18, 0xE0, 0x0C, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x06, 0xE0, 0x0C, 0xD8,
  0x18, 0xC7, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE2, 0x30, 0x24, 0xC0,
  0x2B, 0x00, 0x34, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0,
  0x01, 0x60, 0x06, 0x60, 0x14, 0x60, 0x48, 0x3F, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0xFF, 0x1F, 0xC0, 0x48, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x0C,
  0x06, 0x08, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0x30, 0x01, 0x86,
  0x03, 0x80, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50,
  0x01, 0x40, 0x0D, 0x80, 0x73, 0x83, 0x43, 0xF1, 0xC0, 0x01, 0xA0, 0x00,
  0x98, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x80, 0x30, 0x40, 0x10, 0x20,
  0x18, 0x18, 0x08, 0x04, 0x04, 0x02, 0x06, 0x01, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x80, 0x08, 0x80, 0x04, 0x40, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x30, 0x00, 0xC0, 0x60, 0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05,
  0x01, 0x40, 0xD0, 0x36, 0x08, 0x82, 0x20, 0x88, 0x22, 0x08, 0x82, 0x20,
  0x88, 0x22, 0x10, 0xC2, 0x21, 0x04, 0x63, 0x10, 0x44, 0x11, 0x04, 0x41,
  0x20, 0x64, 0x12, 0x02, 0x41, 0x20, 0x24, 0x12, 0x02, 0xC1, 0xC0, 0x28,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0xC0, 0x01, 0xB0, 0x01, 0x0C, 0x01, 0x82,
  0x01, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x18, 0xC0, 0x04, 0xC0, 0x03, 0x40,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x26, 0x00, 0x31, 0x80, 0x30,
  0x60, 0x30, 0x10, 0x10, 0x0C, 0x18, 0x03, 0x18, 0x00, 0xD8, 0x00, 0x30,
  0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x62, 0x00, 0x21, 0x00,
  0x30, 0xC0, 0x10, 0x20, 0x08, 0x18, 0x0C, 0x04, 0x04, 0x02, 0x06, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0xFE, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x07, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x81, 0xFF, 0x00, 0x1E, 0x00, 0x66, 0x20, 0x09, 0x82, 0x01, 0x20, 0x20,
  0x24, 0x02, 0x09, 0x80, 0x63, 0x20, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 27, 23, 10, -27 },
  { 12, 7, 10, 23, 8, -28 },
  { 21, 21, 27, 23, 1, -27 },
  { 92, 18, 35, 23, 2, -31 },
  { 171, 21, 27, 23, 1, -27 },
  { 242, 20, 27, 23, 1, -27 },
  { 310, 1, 10, 23, 11, -28 },
  { 312, 9, 34, 23, 9, -29 },
  { 351, 9, 34, 23, 5, -29 },
  { 390, 19, 19, 23, 2, -21 },
  { 436, 18, 19, 23, 2, -21 },
  { 479, 4, 10, 23, 9, -4 },
  { 484, 11, 1, 23, 6, -12 },
  { 486, 3, 3, 23, 10, -3 },
  { 488, 15, 34, 23, 4, -29 },
  { 552, 17, 27, 23, 3, -27 },
  { 610, 18, 27, 23, 3, -27 },
  { 671, 17, 27, 23, 3, -27 },
  { 729, 17, 27, 23, 2, -27 },
  { 787, 19, 27, 23, 2, -27 },
  { 852, 16, 27, 23, 3, -27 },
  { 906, 17, 27, 23, 3, -27 },
  { 964, 17, 27, 23, 3, -27 },
  { 1022, 17, 27, 23, 3, -27 },
  { 1080, 17, 27, 23, 3, -27 },
  { 1138, 3, 20, 23, 10, -20 },
  { 1146, 4, 26, 23, 9, -20 },
  { 1159, 17, 21, 23, 3, -22 },
  { 1204, 18, 8, 23, 2, -16 },
  { 1222, 17, 21, 23, 3, -22 },
  { 1267, 15, 27, 23, 4, -27 },
  { 1318, 16, 31, 23, 3, -27 },
  { 1380, 19, 27, 23, 2, -27 },
  { 1445, 16, 27, 23, 4, -27 },
  { 1499, 17, 27, 23, 3, -27 },
  { 1557, 16, 27, 23, 4, -27 },
  { 1611, 16, 27, 23, 4, -27 },
  { 1665, 16, 27, 23, 4, -27 },
  { 1719, 17, 27, 23, 3, -27 },
  { 1777, 15, 27, 23, 4, -27 },
  { 1828, 16, 27, 23, 3, -27 },
  { 1882, 15, 27, 23, 3, -27 },
  { 1933, 17, 27, 23, 4, -27 },
  { 1991, 15, 27, 23, 5, -27 },
  { 2042, 17, 27, 23, 3, -27 },
  { 2100, 15, 27, 23, 4, -27 },
  { 2151, 17, 27, 23, 3, -27 },
  { 2209, 16, 27, 23, 4, -27 },
  { 2263, 17, 32, 23, 3, -27 },
  { 2331, 16, 27, 23, 4, -27 },
  { 2385, 18, 27, 23, 2, -27 },
  { 2446, 20, 27, 23, 1, -27 },
  { 2514, 15, 27, 23, 4, -27 },
  { 2565, 19, 27, 23, 2, -27 },
  { 2630, 19, 27, 23, 2, -27 },
  { 2695, 19, 27, 23, 2, -27 },
  { 2760, 21, 27, 23, 1, -27 },
  { 2831, 19, 27, 23, 2, -27 },
  { 2896, 9, 34, 23, 10, -29 },
  { 2935, 15, 34, 23, 4, -29 },
  { 2999, 9, 34, 23, 4, -29 },
  { 3038, 18, 15, 23, 2, -27 },
  { 3072, 19, 1, 23, 2, 5 },
  { 3075, 5, 6, 23, 8, -29 },
  { 3079, 17, 20, 23, 3, -20 },
  { 3122, 16, 28, 23, 4, -28 },
  { 3178, 15, 20, 23, 4, -20 },
  { 3216, 15, 28, 23, 3, -28 },
  { 3269, 17, 20, 23, 3, -20 },
  { 3312, 17, 28, 23, 3, -28 },
  { 3372, 18, 29, 23, 3, -21 },
  { 3438, 14, 28, 23, 5, -28 },
  { 3487, 16, 29, 23, 4, -29 },
  { 3545, 13, 37, 23, 4, -29 },
  { 3606, 16, 28, 23, 5, -28 },
  { 3662, 16, 28, 23, 3, -28 },
  { 3718, 17, 20, 23, 3, -20 },
  { 3761, 14, 20, 23, 5, -20 },
  { 3796, 17, 20, 23, 3, -20 },
  { 3839, 16, 28, 23, 4, -20 },
  { 3895, 15, 28, 23, 3, -20 },
  { 3948, 18, 20, 23, 3, -20 },
  { 3993, 17, 20, 23, 3, -20 },
  { 4036, 19, 27, 23, 1, -27 },
  { 4101, 14, 20, 23, 4, -20 },
  { 4136, 17, 20, 23, 3, -20 },
  { 4179, 20, 20, 23, 1, -20 },
  { 4229, 17, 20, 23, 3, -20 },
  { 4272, 17, 28, 23, 3, -20 },
  { 4332, 15, 20, 23, 4, -20 },
  { 4370, 15, 34, 23, 4, -29 },
  { 4434, 1, 34, 23, 11, -29 },
  { 4439, 15, 34, 23, 4, -29 },
  { 4503, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLight38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_EXTRALIGHT38PT7B_H_
