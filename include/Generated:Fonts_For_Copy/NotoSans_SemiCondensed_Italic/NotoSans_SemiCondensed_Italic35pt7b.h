#ifndef _NOTOSANS_SEMICONDENSED_ITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0x00, 0x00, 0xE0, 0xF0,
  0xF0, 0xE0, 0x71, 0xDC, 0x77, 0x3B, 0x8E, 0xE3, 0xB8, 0xCC, 0x33, 0x0C,
  0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC0,
  0x1C, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x03,
  0x86, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x60, 0xC0, 0x0C,
  0x38, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x03, 0xFE,
  0x0F, 0xFF, 0x0E, 0x66, 0x1C, 0x40, 0x1C, 0xC0, 0x18, 0xC0, 0x1C, 0xC0,
  0x1C, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0x38, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x38, 0x83, 0x38, 0xE6, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0F, 0x80, 0x38, 0x7F, 0x01, 0xC3, 0x8C, 0x06, 0x0C, 0x30, 0x30, 0x70,
  0xC1, 0xC1, 0xC3, 0x06, 0x06, 0x0C, 0x30, 0x18, 0x31, 0xC0, 0x61, 0xC6,
  0x03, 0x87, 0x38, 0x0E, 0x19, 0xCF, 0xB8, 0xE6, 0x7F, 0x63, 0x3B, 0x9D,
  0xFD, 0xCC, 0x33, 0xE6, 0x70, 0xC0, 0x39, 0x83, 0x01, 0xC6, 0x1C, 0x06,
  0x38, 0x70, 0x38, 0xE1, 0xC1, 0xC3, 0x86, 0x06, 0x0C, 0x38, 0x38, 0x38,
  0xC1, 0xC0, 0xE7, 0x06, 0x01, 0xF8, 0x38, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0x30, 0xE0, 0x07, 0x3C, 0x00, 0xEF, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7B, 0x81, 0xCE, 0x38, 0x73, 0x87, 0x8E, 0xE0,
  0x73, 0x9C, 0x0F, 0xF3, 0x80, 0xFC, 0x70, 0x1F, 0x0E, 0x01, 0xC1, 0xC0,
  0xFC, 0x3E, 0x3F, 0xC3, 0xFF, 0x38, 0x3F, 0x87, 0x80, 0x77, 0x76, 0xEE,
  0xCC, 0xC0, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0xC3,
  0x03, 0xCC, 0x07, 0xFF, 0xC3, 0xFF, 0x0F, 0x1C, 0x7C, 0x03, 0x98, 0x3C,
  0x60, 0x71, 0xC0, 0x83, 0x80, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x30, 0xE0, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x3C, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0x80, 0x73, 0x00, 0xE7, 0x03, 0x8E,
  0x07, 0x1C, 0x1C, 0x3C, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x03, 0x83, 0xC7,
  0xE7, 0xFF, 0xB7, 0x3B, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xE3, 0xC0, 0xC0, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xE3, 0xC0, 0x80, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC4, 0x01, 0xE3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xB8, 0x03, 0x98, 0x01, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x01,
  0xC3, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x30,
  0x70, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x10, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x80, 0x78, 0xE1, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFE,
  0x03, 0xFC, 0x1F, 0x08, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE3, 0x81, 0xDF, 0xC3, 0x7F, 0xCF, 0x83, 0x9E, 0x07,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x9C, 0x0E, 0x1E, 0x78, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x07, 0xFE, 0x07, 0x8F, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x0F, 0x1C, 0x07, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1E, 0xF0, 0x3C, 0x38, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78, 0x78, 0x7F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0x1E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38,
  0x06, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x1E, 0x3C, 0x3E, 0x1F, 0xEE, 0x1F, 0xCC, 0x07, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x83, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x0E, 0x0F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0xF0, 0x70, 0x03, 0x80,
  0xF0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x1F, 0xC7, 0xFE, 0x38, 0xF2, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00,
  0x0C, 0x38, 0x3F, 0xC6, 0x18, 0x3F, 0xC3, 0x9C, 0x38, 0x61, 0xCC, 0x38,
  0x70, 0xEE, 0x18, 0x38, 0x67, 0x1C, 0x18, 0x33, 0x0C, 0x0C, 0x19, 0x86,
  0x0E, 0x1C, 0xC3, 0x07, 0x0E, 0xE3, 0x83, 0x06, 0x71, 0xC3, 0x87, 0x38,
  0x63, 0xE7, 0x0C, 0x3F, 0x3F, 0x06, 0x0F, 0x1F, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x81, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01,
  0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0x80, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x1D, 0xC0,
  0x07, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x38,
  0x0E, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x0E, 0x1C, 0x03,
  0x87, 0x01, 0xC1, 0xC1, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0E, 0x07, 0x83,
  0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7E, 0x38, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xE3, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0x03, 0xE0, 0xE0, 0x3C, 0x1C, 0x03,
  0x83, 0x80, 0x78, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x07, 0x87, 0x01, 0xE0,
  0xE0, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x1F, 0x8F, 0x87, 0xC0, 0x20, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x03, 0xFD, 0xC0, 0x7F, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x78, 0x03, 0x87, 0x00, 0x70,
  0xF0, 0x0E, 0x0F, 0x87, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x00,
  0x38, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E,
  0x3C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xEE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x70, 0x38,
  0x07, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xB8,
  0x37, 0x00, 0xEE, 0x1C, 0xC0, 0x73, 0x87, 0x30, 0x1D, 0xC1, 0xCC, 0x0E,
  0x70, 0x73, 0x03, 0x9C, 0x18, 0xE1, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x8E,
  0x38, 0xE0, 0xE3, 0x8E, 0x38, 0x38, 0xE7, 0x0E, 0x1C, 0x39, 0xC3, 0x87,
  0x0E, 0xE1, 0xC1, 0xC1, 0xB8, 0x70, 0x70, 0x7C, 0x1C, 0x18, 0x1E, 0x07,
  0x0E, 0x07, 0x81, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x07,
  0x80, 0x1C, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0x83, 0xF0, 0x0E, 0x0F, 0xC0,
  0x38, 0x3F, 0x00, 0xC0, 0xEC, 0x07, 0x03, 0x38, 0x1C, 0x1C, 0xE0, 0x70,
  0x73, 0x81, 0xC1, 0xC7, 0x06, 0x07, 0x1C, 0x38, 0x18, 0x70, 0xE0, 0xE0,
  0xC3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x70, 0x38, 0x19, 0xC1, 0xC0, 0x77,
  0x07, 0x01, 0xDC, 0x1C, 0x07, 0x70, 0x70, 0x0F, 0x81, 0x80, 0x3E, 0x0E,
  0x00, 0xF8, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00,
  0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x78, 0x03, 0xC7, 0x00, 0xF0, 0xF0, 0x3C,
  0x0F, 0x9F, 0x81, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xC7, 0xE1,
  0xFF, 0xC0, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xE1,
  0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x78,
  0x03, 0xC7, 0x00, 0xF0, 0xF0, 0x3C, 0x0F, 0x9F, 0x81, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xC0,
  0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0x87, 0x03, 0xC3, 0x83, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80,
  0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1E, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xF3, 0xC1, 0xE0, 0x20, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC4, 0x03, 0xC3, 0xE7, 0xE1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x7C, 0x7C,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x18, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70,
  0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xEC, 0x01, 0xC0, 0x3D, 0x80, 0x78,
  0x07, 0x30, 0x0F, 0x00, 0xE6, 0x03, 0xE0, 0x38, 0xC0, 0x7C, 0x07, 0x18,
  0x0D, 0x81, 0xE3, 0x83, 0xB8, 0x38, 0x70, 0x67, 0x07, 0x0E, 0x1C, 0xE1,
  0xC1, 0xC3, 0x1C, 0x38, 0x38, 0xE3, 0x8E, 0x07, 0x1C, 0x71, 0xC0, 0xE7,
  0x0E, 0x30, 0x1C, 0xE1, 0xCE, 0x03, 0x98, 0x39, 0xC0, 0x77, 0x07, 0x70,
  0x0E, 0xC0, 0xEE, 0x01, 0xF8, 0x1D, 0x80, 0x37, 0x03, 0xF0, 0x06, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x38,
  0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x9E, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0x9C,
  0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x00, 0xE0, 0x0F,
  0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x70, 0x70,
  0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xC3, 0x8E, 0x38, 0xE3, 0x86,
  0x18, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0x61,
  0xC7, 0x1C, 0x03, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18,
  0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0x03, 0xE3, 0x83, 0xF9,
  0x83, 0xEF, 0xC3, 0xC3, 0xE1, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xE3, 0x80, 0xF0, 0xE0, 0xF0, 0x79, 0xD8, 0x3F, 0xDC, 0x0F, 0xCE,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x7C, 0x1D, 0xFE, 0x1F, 0xDE, 0x1F,
  0x0F, 0x1E, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xF8,
  0x38, 0xF8, 0xF8, 0xCF, 0xF0, 0xC7, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0xFB,
  0x87, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x60, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03,
  0xE3, 0x81, 0xFD, 0xC0, 0xFB, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x0E, 0x03,
  0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC3,
  0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x07, 0xC1, 0xC1, 0xE0, 0x79,
  0xF8, 0x1F, 0xEE, 0x03, 0xF3, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0xF3, 0xC7,
  0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x83, 0xDC, 0x1E, 0x7F, 0xF1, 0xFF, 0x8F,
  0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x70,
  0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF1, 0xC0, 0xFE, 0x60, 0x7D, 0xF8, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x01,
  0xC1, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE1,
  0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xE0, 0xE0, 0xF0, 0x3C,
  0xFC, 0x0F, 0xF7, 0x01, 0xF9, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x82, 0x01, 0xC0, 0xE1, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x7C, 0x1D, 0xFE, 0x1F, 0xDE, 0x1F, 0x0E,
  0x1E, 0x07, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0x02, 0x07, 0x0F, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x00, 0x10, 0x01, 0xC0,
  0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x0F, 0x1C, 0x1E,
  0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x3B, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x79, 0xC0, 0x71, 0xC0, 0x71, 0xE0,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0x0C, 0x78, 0x3E, 0x0E, 0xFE, 0x3F, 0x87, 0xFF, 0xBB, 0xC3, 0xE1,
  0xF0, 0xF1, 0xE0, 0xF0, 0x39, 0xE0, 0x78, 0x1C, 0xF0, 0x38, 0x1C, 0x70,
  0x1C, 0x0E, 0x38, 0x1C, 0x07, 0x1C, 0x0E, 0x03, 0x9C, 0x07, 0x01, 0xCE,
  0x03, 0x81, 0xC7, 0x01, 0xC0, 0xE3, 0x81, 0xC0, 0x71, 0xC0, 0xE0, 0x39,
  0xC0, 0x70, 0x1C, 0xE0, 0x38, 0x1C, 0x70, 0x1C, 0x0E, 0x38, 0x1C, 0x07,
  0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F, 0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C,
  0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0x01, 0xF0, 0x0F, 0xF0, 0x3E, 0xF0, 0xF0, 0xF3, 0xC0,
  0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xDC, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x78, 0xF0, 0x7F,
  0xC0, 0x7F, 0x00, 0x03, 0x1F, 0x01, 0xDF, 0xE0, 0x77, 0x78, 0x1F, 0x0F,
  0x07, 0x81, 0xC3, 0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0xF0, 0x38, 0x3E, 0x3E, 0x0E, 0xFF, 0x03, 0x9F, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xE3, 0x83, 0xF9, 0x83, 0xEF, 0xC3, 0xC3,
  0xE1, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x81, 0xF0,
  0xE0, 0xF0, 0x79, 0xF8, 0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x78, 0xEF, 0x87, 0xFC, 0x3E, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x7F,
  0xC7, 0x9E, 0x78, 0x13, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x90, 0x1C, 0xC1,
  0xE7, 0xFE, 0x3F, 0xE0, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x7F, 0xFF, 0xEF,
  0xF8, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE2, 0x3F, 0x07, 0xC0, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38,
  0x3C, 0x70, 0x78, 0xE3, 0xF1, 0xFE, 0xE1, 0xF9, 0xC0, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1,
  0xC1, 0x87, 0x06, 0x38, 0x18, 0xE0, 0x67, 0x01, 0xDC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x1F, 0x81, 0xE0,
  0x7E, 0x07, 0x83, 0xB8, 0x3E, 0x0E, 0xE0, 0xD8, 0x3B, 0x87, 0x61, 0xCE,
  0x1B, 0x87, 0x38, 0xE6, 0x38, 0xE3, 0x18, 0xE3, 0x9C, 0x67, 0x0E, 0x71,
  0x9C, 0x39, 0x86, 0x70, 0xEE, 0x1B, 0x83, 0xB0, 0x6E, 0x0F, 0xC1, 0xB0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x87, 0x03, 0x81, 0x83, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x19,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x78, 0x38,
  0x38, 0x1C, 0x38, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x00, 0xC1, 0xC0, 0x18, 0x38,
  0x03, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x78,
  0x0F, 0xC0, 0x7C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x00,
  0x78, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0xC0, 0x1E, 0x01, 0xF8, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xFC,
  0x03, 0xE0, 0x08, 0x00, 0x00, 0x18, 0x02, 0xFE, 0x07, 0xFF, 0xFE, 0x1F,
  0xF8, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 25, 9, 1, -25 },
  { 26, 10, 9, 13, 4, -25 },
  { 38, 19, 25, 20, 1, -25 },
  { 98, 16, 29, 17, 1, -27 },
  { 156, 22, 25, 26, 2, -25 },
  { 225, 19, 25, 20, 1, -25 },
  { 285, 4, 9, 7, 4, -25 },
  { 290, 11, 31, 10, 1, -25 },
  { 333, 11, 31, 10, -3, -25 },
  { 376, 14, 15, 17, 4, -27 },
  { 403, 15, 17, 18, 2, -21 },
  { 435, 7, 9, 8, -2, -4 },
  { 443, 8, 3, 10, 1, -11 },
  { 446, 4, 4, 8, 1, -4 },
  { 448, 17, 25, 12, -2, -25 },
  { 502, 15, 25, 17, 2, -25 },
  { 549, 9, 25, 17, 5, -25 },
  { 578, 17, 25, 17, 0, -25 },
  { 632, 17, 25, 17, 0, -25 },
  { 686, 17, 25, 17, 0, -25 },
  { 740, 16, 25, 17, 1, -25 },
  { 790, 15, 25, 17, 2, -25 },
  { 837, 16, 25, 17, 2, -25 },
  { 887, 16, 25, 17, 1, -25 },
  { 937, 16, 25, 17, 1, -25 },
  { 987, 8, 19, 8, 0, -19 },
  { 1006, 10, 24, 8, -2, -19 },
  { 1036, 15, 17, 18, 2, -21 },
  { 1068, 15, 9, 18, 2, -17 },
  { 1085, 15, 17, 18, 2, -21 },
  { 1117, 12, 25, 13, 2, -25 },
  { 1155, 25, 28, 26, 1, -25 },
  { 1243, 18, 25, 18, -2, -25 },
  { 1300, 18, 25, 19, 1, -25 },
  { 1357, 18, 25, 18, 2, -25 },
  { 1414, 19, 25, 21, 1, -25 },
  { 1474, 17, 25, 16, 1, -25 },
  { 1528, 17, 25, 15, 1, -25 },
  { 1582, 19, 25, 21, 2, -25 },
  { 1642, 21, 25, 21, 1, -25 },
  { 1708, 14, 25, 11, -1, -25 },
  { 1752, 14, 32, 9, -5, -25 },
  { 1808, 20, 25, 18, 1, -25 },
  { 1871, 12, 25, 15, 1, -25 },
  { 1909, 26, 25, 27, 1, -25 },
  { 1991, 22, 25, 22, 1, -25 },
  { 2060, 19, 25, 22, 2, -25 },
  { 2120, 17, 25, 18, 1, -25 },
  { 2174, 19, 31, 22, 2, -25 },
  { 2248, 17, 25, 18, 1, -25 },
  { 2302, 17, 25, 16, 0, -25 },
  { 2356, 15, 25, 16, 3, -25 },
  { 2403, 20, 25, 21, 2, -25 },
  { 2466, 18, 25, 17, 3, -25 },
  { 2523, 27, 25, 27, 3, -25 },
  { 2608, 21, 25, 16, -2, -25 },
  { 2674, 16, 25, 16, 3, -25 },
  { 2724, 19, 25, 16, -1, -25 },
  { 2784, 14, 31, 10, -1, -25 },
  { 2839, 6, 25, 12, 4, -25 },
  { 2858, 13, 31, 10, -2, -25 },
  { 2909, 16, 15, 18, 1, -25 },
  { 2939, 13, 2, 13, -3, 3 },
  { 2943, 6, 6, 9, 5, -27 },
  { 2948, 17, 19, 18, 1, -19 },
  { 2989, 16, 27, 18, 1, -27 },
  { 3043, 14, 19, 14, 1, -19 },
  { 3077, 18, 27, 18, 1, -27 },
  { 3138, 14, 19, 16, 1, -19 },
  { 3172, 18, 35, 10, -4, -27 },
  { 3251, 18, 27, 18, 0, -19 },
  { 3312, 16, 27, 18, 1, -27 },
  { 3366, 8, 26, 8, 1, -26 },
  { 3392, 13, 34, 8, -4, -26 },
  { 3448, 16, 27, 16, 1, -27 },
  { 3502, 8, 27, 8, 1, -27 },
  { 3529, 25, 19, 27, 1, -19 },
  { 3589, 16, 19, 18, 1, -19 },
  { 3627, 15, 19, 18, 1, -19 },
  { 3663, 18, 27, 18, -1, -19 },
  { 3724, 17, 27, 18, 1, -19 },
  { 3782, 13, 19, 12, 1, -19 },
  { 3813, 13, 19, 14, 0, -19 },
  { 3844, 10, 23, 10, 2, -23 },
  { 3873, 15, 19, 18, 2, -19 },
  { 3909, 14, 19, 15, 2, -19 },
  { 3943, 22, 19, 23, 2, -19 },
  { 3996, 17, 19, 15, -1, -19 },
  { 4037, 19, 27, 15, -3, -19 },
  { 4102, 15, 19, 14, -1, -19 },
  { 4138, 13, 31, 12, 1, -25 },
  { 4189, 2, 35, 17, 8, -27 },
  { 4198, 14, 31, 12, -2, -25 },
  { 4253, 15, 5, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Italic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC35PT7B_H_
