#ifndef _NOTOSANS_SEMICONDENSED_ITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x80, 0x7F, 0xE0, 0x2D, 0x3C, 0xDB, 0x77, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0xF8, 0x7C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40, 0x76,
  0xE0, 0xF0, 0x65, 0x60, 0x6C, 0xE0, 0x2A, 0xA0, 0x68, 0xE0, 0x7A, 0xF0,
  0x69, 0x40, 0x6A, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F,
  0x00, 0x5A, 0x7F, 0xF8, 0x60, 0x4B, 0xD0, 0x7E, 0xF0, 0x72, 0x70, 0x76,
  0xF0, 0x7E, 0x60, 0x7E, 0x40, 0x78, 0xAE, 0x5D, 0xAA, 0x5A, 0x29, 0x2C,
  0x74, 0xCA, 0x6B, 0x5A, 0xAD, 0x60, 0x5D, 0xAA, 0x79, 0x9E, 0x77, 0x40,
  0x79, 0x9E, 0x20, 0x77, 0x50, 0xE8, 0xE0, 0xEA, 0x59, 0xAE, 0xFA, 0x40,
  0xDD, 0xAA, 0x6B, 0x50, 0xEA, 0x69, 0x60, 0x6A, 0x80, 0xF0, 0x56, 0x80,
  0x54, 0xE0, 0x80, 0xF7, 0x00, 0x4A, 0xDE, 0xF3, 0x00, 0x2E, 0xDC, 0xFB,
  0x80, 0x25, 0x25, 0x80, 0xF7, 0x60, 0x4A, 0xDA, 0x6A, 0x29, 0x2C, 0x4B,
  0xEC, 0x5A, 0x80, 0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x00, 0x77, 0xC0, 0xF7,
  0x20, 0xE8, 0xDC, 0x6A, 0xB7, 0x00, 0xBA, 0x00, 0xBE, 0xA0, 0xEB, 0x00,
  0x52, 0x2C, 0x5C, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 3, 3, 3, 0, -4 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 4, 5, 5, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 3, 5, 1, -1, -4 },
  { 72, 4, 4, 3, 0, -4 },
  { 74, 2, 4, 3, 0, -4 },
  { 75, 5, 4, 5, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 4, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 2, 4, 3, 1, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 3, 4, 3, 1, -4 },
  { 96, 4, 4, 5, 1, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 2, 4, 3, 1, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 1, 4, 2, 1, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 3, 2, 3, 0, -4 },
  { 109, 3, 1, 2, -1, 0 },
  { 110, 1, 1, 2, 1, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 3, 3, 2, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 6, 2, -1, -5 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 2, 4, 1, 0, -4 },
  { 129, 3, 5, 1, -1, -4 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 2, 5, 1, 0, -5 },
  { 135, 4, 3, 5, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 3, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 3, 4, 3, 0, -3 },
  { 145, 2, 3, 2, 0, -3 },
  { 146, 2, 3, 2, 0, -3 },
  { 147, 2, 4, 2, 0, -4 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 4, 3, 4, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 4, 4, 3, -1, -3 },
  { 158, 2, 3, 2, 0, -3 },
  { 159, 2, 5, 2, 0, -4 },
  { 161, 1, 6, 3, 1, -5 },
  { 162, 2, 5, 2, 0, -4 },
  { 164, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Italic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC6PT7B_H_
