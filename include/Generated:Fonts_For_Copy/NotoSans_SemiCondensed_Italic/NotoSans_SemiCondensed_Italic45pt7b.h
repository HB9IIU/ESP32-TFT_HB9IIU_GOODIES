#ifndef _NOTOSANS_SEMICONDENSED_ITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x60, 0x00, 0x7C,
  0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x1C,
  0xE0, 0xE7, 0x0E, 0x38, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xF9, 0x8E, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03,
  0x86, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x9C, 0x00, 0x3E, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x06, 0xF8, 0x00, 0x33, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78,
  0x00, 0xC3, 0xC0, 0x06, 0x1E, 0x00, 0x71, 0xE1, 0x83, 0x9F, 0x0F, 0xDF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x0F, 0xF0, 0x03, 0x81, 0xE7, 0x80,
  0x78, 0x3C, 0x38, 0x07, 0x03, 0x83, 0x80, 0xE0, 0x78, 0x38, 0x1E, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x03, 0x87, 0x80, 0xF0, 0x70,
  0x70, 0x0E, 0x07, 0x0E, 0x00, 0xE0, 0x71, 0xE0, 0x0E, 0x07, 0x1C, 0x30,
  0xE0, 0xE3, 0x8F, 0xEE, 0x0E, 0x79, 0xFE, 0xE1, 0xC7, 0x3C, 0xFF, 0x3C,
  0xE7, 0x87, 0x7F, 0x9E, 0x70, 0x73, 0xF1, 0xCF, 0x07, 0x08, 0x38, 0xE0,
  0x70, 0x07, 0x8E, 0x07, 0x00, 0x70, 0xE0, 0x70, 0x0E, 0x1E, 0x0E, 0x01,
  0xE1, 0xC0, 0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x1C, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x1E, 0x38, 0x1E, 0x00, 0xF7, 0x81,
  0xC0, 0x0F, 0xF0, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFB, 0xE0, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC1,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xCF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x3C, 0x0F, 0x3E, 0x3C, 0x0F, 0x7C, 0x1E, 0x1E, 0x78, 0x1E,
  0x1E, 0xF0, 0x0F, 0x3C, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF8, 0xF0, 0x03,
  0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F, 0xF0, 0xF8, 0x1F,
  0xF0, 0x7F, 0xFE, 0xF8, 0x3F, 0xFC, 0x78, 0x1F, 0xF0, 0x3C, 0x7D, 0xE7,
  0x9E, 0x71, 0xC7, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x40, 0xE0, 0x3C, 0x30, 0x0F, 0xCC, 0x01, 0xFF, 0x3F,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0x04, 0x3F, 0x80, 0x1E, 0x70, 0x0F,
  0x1C, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x10, 0x3C, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x30, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0x78, 0x1E, 0x07, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x81, 0xFC, 0x1F, 0xE1, 0xFF, 0x3F, 0x73,
  0xE7, 0x9E, 0x3C, 0x61, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x06, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3C, 0x0F, 0x80, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x88, 0x00, 0x78, 0x70, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00,
  0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3C,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x70,
  0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x78,
  0x07, 0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE7, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xE7, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE1, 0x00, 0x1F, 0x0E, 0x03, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0xE0, 0x39, 0xFF, 0x07, 0xBF, 0xF8,
  0x7F, 0x07, 0x87, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x78, 0xF0, 0x07, 0x87, 0x00, 0xF8, 0x78, 0x0F, 0x07, 0xC3, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x7C,
  0x1E, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xE3, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x7C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xC1, 0xE0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x03,
  0xF1, 0xF0, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xDE, 0x03, 0xF1, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x08, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x07, 0x83, 0xE3, 0xF1, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x20, 0x00, 0x00,
  0x40, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x18, 0x1F, 0x10,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x07, 0xFC, 0x1C,
  0x70, 0x1F, 0xF8, 0x39, 0xE0, 0xF8, 0xF0, 0x73, 0x81, 0xC1, 0xE0, 0xEF,
  0x07, 0x03, 0x81, 0xDC, 0x1E, 0x07, 0x03, 0xB8, 0x38, 0x0E, 0x07, 0x70,
  0xF0, 0x3C, 0x1D, 0xC1, 0xC0, 0x70, 0x3B, 0x83, 0x80, 0xE0, 0x77, 0x07,
  0x03, 0xC0, 0xEE, 0x0E, 0x07, 0x83, 0x9C, 0x1C, 0x0E, 0x07, 0x38, 0x38,
  0x3C, 0x1C, 0x70, 0x70, 0xFC, 0x78, 0xE0, 0xFF, 0xBF, 0xE1, 0xC0, 0xFE,
  0x3F, 0x83, 0xC0, 0xF8, 0x7C, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x04,
  0x00, 0x1F, 0x80, 0x38, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xEE, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78,
  0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xE0, 0x07, 0x03,
  0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x07,
  0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x0F, 0x81, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0x81, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x01, 0x80,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x60, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x78, 0x3F, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF8, 0x0E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x1C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x01, 0xFC, 0x07,
  0x8F, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x0E, 0x07,
  0xE0, 0x02, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0xF0,
  0x07, 0xFC, 0xF0, 0x07, 0xFC, 0xF0, 0x08, 0x3C, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x70, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x3F,
  0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xC0, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x38, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3B, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3B, 0x80, 0x07, 0x78, 0x1E,
  0xE0, 0x03, 0xDE, 0x07, 0xB8, 0x00, 0xE7, 0x01, 0xEE, 0x00, 0x7B, 0xC0,
  0x73, 0x80, 0x1C, 0xF0, 0x3C, 0xE0, 0x0F, 0x3C, 0x0F, 0x38, 0x03, 0x8E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x07, 0x87, 0x07, 0x87, 0x01, 0xE1, 0xC1,
  0xC3, 0xC0, 0x70, 0x70, 0xF0, 0xF0, 0x1C, 0x1C, 0x38, 0x3C, 0x0F, 0x07,
  0x1E, 0x0F, 0x03, 0xC1, 0xC7, 0x07, 0x80, 0xF0, 0x73, 0xC1, 0xE0, 0x38,
  0x1E, 0xE0, 0x78, 0x1E, 0x07, 0xF8, 0x1E, 0x07, 0x81, 0xFC, 0x07, 0x81,
  0xE0, 0x3F, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1C, 0x03, 0xE0, 0x3C,
  0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0E, 0x03,
  0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x7B, 0x80,
  0x1E, 0x07, 0xBC, 0x01, 0xC0, 0x73, 0xC0, 0x3C, 0x07, 0x1C, 0x03, 0xC0,
  0xF1, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0x80, 0xF0, 0xE0, 0x38, 0x0F, 0x0F,
  0x07, 0x80, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x70,
  0x1E, 0x07, 0x8F, 0x01, 0xC0, 0x78, 0xF0, 0x1C, 0x03, 0x8F, 0x03, 0xC0,
  0x3C, 0xF0, 0x3C, 0x03, 0xCE, 0x03, 0xC0, 0x1C, 0xE0, 0x38, 0x01, 0xFE,
  0x07, 0x80, 0x1F, 0xE0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x0F, 0xC0, 0x78,
  0x00, 0xFC, 0x07, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xF0, 0x7E, 0x03, 0xC0, 0x7C, 0x0F,
  0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0,
  0xF0, 0x1F, 0x03, 0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF0, 0x7E, 0x03, 0xC0, 0x7C,
  0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE0, 0xF0, 0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0x40, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x80, 0x0F, 0x83, 0xC0, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0,
  0x07, 0xC7, 0x00, 0x1E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00,
  0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x3E, 0x00, 0x79, 0xC0, 0x07,
  0xC0, 0x0F, 0x38, 0x01, 0xF8, 0x03, 0xC7, 0x00, 0x3F, 0x00, 0x78, 0xE0,
  0x0F, 0xE0, 0x0F, 0x1C, 0x01, 0xDC, 0x03, 0xC3, 0x80, 0x7B, 0x80, 0x78,
  0x70, 0x0E, 0x70, 0x1E, 0x0E, 0x01, 0xCE, 0x03, 0xC1, 0xC0, 0x79, 0xC0,
  0xF0, 0x38, 0x0E, 0x38, 0x1E, 0x07, 0x03, 0xC7, 0x03, 0xC0, 0xE0, 0x70,
  0xE0, 0xF0, 0x1C, 0x1E, 0x1C, 0x1E, 0x03, 0x83, 0x83, 0x87, 0x80, 0x70,
  0x70, 0x70, 0xF0, 0x0E, 0x1E, 0x0E, 0x1C, 0x01, 0xC3, 0x81, 0xC7, 0x80,
  0x38, 0xF0, 0x38, 0xE0, 0x07, 0x1C, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0xE7,
  0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x9C, 0x03, 0xBC, 0x00, 0x77, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xFF,
  0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x00, 0x38,
  0x3C, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE1, 0xE1, 0xC3,
  0xC3, 0x83, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xE3, 0xC0, 0xFF, 0x9C, 0x0F,
  0xFE, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0x03, 0xF0, 0x7C, 0x3B,
  0x81, 0xFF, 0x9C, 0x0F, 0xF8, 0xE0, 0x3F, 0x8F, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x10, 0x01,
  0xE7, 0xF0, 0x0E, 0x7F, 0xC0, 0xF7, 0xFF, 0x07, 0xF0, 0x78, 0x3F, 0x03,
  0xC1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0x87, 0xC0,
  0x3C, 0x3E, 0x03, 0xC3, 0xF8, 0x3E, 0x1E, 0xFF, 0xE0, 0xE7, 0xFE, 0x07,
  0x1F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF8, 0x10, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x41, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x60, 0xF0, 0x07, 0xF1, 0xC0, 0x3F, 0xF3, 0x80, 0xFF, 0xFF, 0x01, 0xF0,
  0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xF8, 0x1E, 0x07, 0xE0, 0x3E,
  0x1D, 0xC0, 0x3F, 0xF3, 0x80, 0x7F, 0xC7, 0x00, 0x7F, 0x1E, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xF0, 0x78, 0xF0, 0x1C,
  0xF0, 0x0E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x0F, 0xDF, 0xFF,
  0xCF, 0xFF, 0x87, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x61, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFE, 0x70,
  0x1F, 0xFE, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x1E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3F,
  0x03, 0xC0, 0xFC, 0x07, 0xC3, 0xB8, 0x07, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0,
  0x0F, 0xE3, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x60, 0x0F, 0x00, 0xFD,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x30,
  0x07, 0x1F, 0xC0, 0x73, 0xFE, 0x0F, 0x7F, 0xF0, 0xFE, 0x0F, 0x0F, 0xC0,
  0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x38, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xDF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x41, 0xE0, 0x3C, 0x0E, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0xE0, 0x1E, 0x3E,
  0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x01, 0xDF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x07, 0x1F, 0xC1, 0xFC, 0x07, 0x3F, 0xE3, 0xFE, 0x0F, 0x7F, 0xE7,
  0xFF, 0x0F, 0xE1, 0xEE, 0x0F, 0x0F, 0xC0, 0xFC, 0x0F, 0x0F, 0x80, 0xF8,
  0x0F, 0x1F, 0x00, 0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0,
  0x0F, 0x1E, 0x01, 0xE0, 0x0E, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x01, 0xE0,
  0x1E, 0x3C, 0x01, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x1E, 0x3C, 0x03, 0xC0,
  0x3C, 0x38, 0x03, 0xC0, 0x3C, 0x78, 0x03, 0xC0, 0x3C, 0x78, 0x03, 0x80,
  0x3C, 0x78, 0x07, 0x80, 0x38, 0x78, 0x07, 0x80, 0x78, 0xF0, 0x07, 0x80,
  0x78, 0xF0, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x71, 0xFE, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0x0F,
  0xE0, 0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x07,
  0xC3, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x3C, 0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xC0, 0x03, 0x8F, 0xE0, 0x07, 0x3F, 0xE0, 0x1E, 0xFF,
  0xE0, 0x3F, 0x83, 0xC0, 0x7E, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0,
  0x1E, 0x03, 0xF0, 0x7C, 0x0F, 0x7F, 0xF0, 0x1E, 0xFF, 0xC0, 0x3C, 0xFE,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xE3, 0xC0, 0xFF, 0x9C, 0x0F, 0xFE, 0xE0, 0xF8, 0x3F, 0x0F, 0x81,
  0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xE0,
  0x3F, 0x0F, 0x03, 0xF0, 0x7C, 0x3B, 0x81, 0xFF, 0xBC, 0x0F, 0xF9, 0xE0,
  0x3F, 0x8F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x83, 0x8F,
  0x81, 0xCF, 0xC1, 0xEF, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0,
  0x10, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC8, 0x03, 0xC6, 0x03,
  0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x71,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8,
  0x77, 0x0F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0xE0, 0xF0, 0x01, 0xFE,
  0x00, 0x79, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xCF, 0x00, 0x39,
  0xE0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0xFE, 0x01, 0xF0,
  0x0F, 0xE0, 0x1F, 0x01, 0xEE, 0x03, 0xF0, 0x1E, 0xE0, 0x3F, 0x01, 0xCE,
  0x07, 0xF0, 0x3C, 0xE0, 0x77, 0x03, 0xCE, 0x0F, 0x70, 0x78, 0xE0, 0xE7,
  0x07, 0x8E, 0x0E, 0x70, 0xF0, 0xE1, 0xC7, 0x0F, 0x0E, 0x1C, 0x70, 0xE0,
  0xE3, 0xC7, 0x1E, 0x0E, 0x38, 0x71, 0xC0, 0xE7, 0x87, 0x3C, 0x0E, 0x70,
  0x73, 0xC0, 0xE7, 0x07, 0x38, 0x0E, 0xE0, 0x77, 0x80, 0xEE, 0x07, 0x70,
  0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1C, 0x7C, 0x00,
  0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x7B, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xC3,
  0xFB, 0xFF, 0xF8, 0x0F, 0xFD, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 33, 11, 1, -32 },
  { 47, 13, 11, 17, 5, -32 },
  { 65, 25, 32, 25, 1, -32 },
  { 165, 21, 37, 22, 1, -34 },
  { 263, 28, 33, 33, 3, -33 },
  { 379, 24, 33, 26, 1, -33 },
  { 478, 6, 11, 9, 5, -32 },
  { 487, 15, 39, 13, 1, -32 },
  { 561, 14, 39, 13, -3, -32 },
  { 630, 18, 18, 22, 5, -34 },
  { 671, 19, 22, 23, 3, -27 },
  { 724, 9, 11, 11, -2, -5 },
  { 737, 11, 4, 13, 1, -14 },
  { 743, 5, 6, 11, 1, -5 },
  { 747, 21, 32, 16, -2, -32 },
  { 831, 20, 33, 22, 2, -33 },
  { 914, 13, 32, 22, 6, -32 },
  { 966, 22, 33, 22, 0, -33 },
  { 1057, 21, 33, 22, 0, -33 },
  { 1144, 22, 32, 22, 0, -32 },
  { 1232, 21, 32, 22, 1, -32 },
  { 1316, 20, 33, 22, 2, -33 },
  { 1399, 20, 32, 22, 3, -32 },
  { 1479, 21, 33, 22, 1, -33 },
  { 1566, 20, 33, 22, 1, -33 },
  { 1649, 9, 26, 11, 1, -25 },
  { 1679, 12, 31, 11, -2, -25 },
  { 1726, 19, 22, 23, 3, -27 },
  { 1779, 19, 12, 23, 3, -22 },
  { 1808, 19, 22, 23, 3, -27 },
  { 1861, 16, 34, 17, 2, -33 },
  { 1929, 31, 36, 34, 2, -32 },
  { 2069, 23, 32, 23, -3, -32 },
  { 2161, 23, 32, 24, 1, -32 },
  { 2253, 23, 33, 23, 3, -33 },
  { 2348, 25, 32, 27, 1, -32 },
  { 2448, 22, 32, 21, 1, -32 },
  { 2536, 22, 32, 19, 1, -32 },
  { 2624, 24, 33, 27, 3, -33 },
  { 2723, 27, 32, 27, 1, -32 },
  { 2831, 17, 32, 14, -1, -32 },
  { 2899, 19, 41, 11, -7, -32 },
  { 2997, 26, 32, 23, 1, -32 },
  { 3101, 15, 32, 19, 1, -32 },
  { 3161, 34, 32, 35, 1, -32 },
  { 3297, 28, 32, 29, 1, -32 },
  { 3409, 25, 33, 29, 3, -33 },
  { 3513, 22, 32, 23, 1, -32 },
  { 3601, 25, 41, 29, 3, -33 },
  { 3730, 22, 32, 23, 1, -32 },
  { 3818, 22, 33, 21, 0, -33 },
  { 3909, 20, 32, 20, 4, -32 },
  { 3989, 25, 32, 27, 3, -32 },
  { 4089, 22, 32, 22, 4, -32 },
  { 4177, 35, 32, 35, 4, -32 },
  { 4317, 27, 32, 21, -2, -32 },
  { 4425, 20, 32, 20, 4, -32 },
  { 4505, 24, 32, 21, -1, -32 },
  { 4601, 17, 39, 13, -1, -32 },
  { 4684, 8, 32, 16, 5, -32 },
  { 4716, 17, 39, 13, -3, -32 },
  { 4799, 21, 19, 23, 1, -32 },
  { 4849, 17, 3, 16, -4, 4 },
  { 4856, 7, 7, 12, 7, -34 },
  { 4863, 21, 25, 23, 2, -25 },
  { 4929, 21, 34, 23, 1, -34 },
  { 5019, 17, 25, 18, 2, -25 },
  { 5073, 23, 34, 23, 2, -34 },
  { 5171, 17, 25, 21, 2, -25 },
  { 5225, 23, 45, 13, -5, -34 },
  { 5355, 23, 36, 23, 0, -25 },
  { 5459, 20, 34, 23, 1, -34 },
  { 5544, 10, 33, 11, 1, -33 },
  { 5586, 17, 44, 11, -6, -33 },
  { 5680, 21, 34, 20, 1, -34 },
  { 5770, 11, 34, 10, 1, -34 },
  { 5817, 32, 25, 35, 1, -25 },
  { 5917, 20, 25, 23, 1, -25 },
  { 5980, 19, 24, 23, 2, -24 },
  { 6037, 23, 36, 23, -1, -25 },
  { 6141, 21, 36, 23, 2, -25 },
  { 6236, 17, 25, 16, 1, -25 },
  { 6290, 17, 25, 18, 0, -25 },
  { 6344, 13, 30, 13, 2, -30 },
  { 6393, 20, 24, 23, 2, -24 },
  { 6453, 19, 24, 19, 2, -24 },
  { 6510, 28, 24, 30, 3, -24 },
  { 6594, 23, 24, 19, -2, -24 },
  { 6663, 25, 35, 19, -4, -24 },
  { 6773, 19, 24, 17, -1, -24 },
  { 6830, 17, 39, 15, 1, -32 },
  { 6913, 3, 45, 22, 10, -34 },
  { 6930, 17, 39, 15, -2, -32 },
  { 7013, 19, 6, 23, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_Italic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC45PT7B_H_
