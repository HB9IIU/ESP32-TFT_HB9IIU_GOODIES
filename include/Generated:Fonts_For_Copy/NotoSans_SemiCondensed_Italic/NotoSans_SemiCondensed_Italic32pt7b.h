#ifndef _NOTOSANS_SEMICONDENSED_ITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0xE0,
  0x39, 0xDC, 0x67, 0x39, 0xCE, 0x63, 0x98, 0xC6, 0x33, 0x0C, 0x00, 0xC3,
  0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC3, 0x00,
  0x30, 0xC4, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0x86, 0x00, 0x61, 0x80, 0x38,
  0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x0F, 0xFF, 0xF3, 0xFF, 0xF8, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x70, 0x06,
  0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x01, 0xFF, 0x0F, 0xFC, 0x73,
  0x11, 0x88, 0x0E, 0x60, 0x39, 0x80, 0x66, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x37, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x67, 0x21,
  0xBC, 0xFF, 0xE3, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x0F, 0x00, 0xE1, 0xF8, 0x0C, 0x31, 0x81, 0x87, 0x18, 0x38, 0x61, 0x83,
  0x06, 0x18, 0x60, 0x61, 0x8E, 0x0E, 0x18, 0xC0, 0xC3, 0x98, 0x0C, 0x33,
  0x9E, 0xC3, 0x37, 0xEE, 0x66, 0x67, 0x7E, 0xEE, 0x37, 0xCC, 0xC3, 0x01,
  0x8C, 0x30, 0x39, 0xC3, 0x03, 0x18, 0x70, 0x61, 0x86, 0x0E, 0x18, 0x60,
  0xC1, 0x8E, 0x18, 0x18, 0xC3, 0x81, 0xFC, 0x70, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xFC, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x3B, 0x8E, 0x19, 0x83, 0x9D, 0xC1, 0xCC, 0xC0, 0x7E, 0x60, 0x3E,
  0x30, 0x0E, 0x1C, 0x0F, 0x0F, 0x1F, 0xC3, 0xFE, 0x70, 0xFC, 0x3C, 0x3B,
  0x9C, 0xE6, 0x31, 0x9C, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x06,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0xC6, 0x0F, 0xB0, 0x1F, 0xFC,
  0x1F, 0xE1, 0xE0, 0x1D, 0x81, 0xCC, 0x1C, 0x70, 0x41, 0x80, 0x08, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x1C, 0xE3, 0x9C, 0x71, 0x8E, 0x30, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0xF3, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x33, 0x80,
  0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1D, 0x80,
  0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xC6, 0x07, 0x1C, 0x38, 0x71,
  0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x03, 0x83, 0xC7, 0xE7, 0xE7, 0xB7, 0x39,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x3C,
  0x78, 0x20, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xFF,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x3C, 0x78, 0x20, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x1F, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xCC, 0x0F, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x06, 0xC0, 0x1D, 0x80, 0x77,
  0x00, 0xCE, 0x03, 0x1C, 0x0E, 0x30, 0x38, 0xE0, 0xE1, 0xC1, 0x83, 0x87,
  0x07, 0x1C, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x87, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x8C, 0x1E, 0x1F, 0xF8,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x78, 0x43, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x9F, 0x8E, 0xFE, 0x3E, 0x1C,
  0xF0, 0x73, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0xCC, 0x06,
  0x38, 0x38, 0xF1, 0xC1, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3C, 0x70, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x0E, 0x0E, 0x0E, 0x38, 0x1E, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xEE, 0x0F, 0x0E, 0x1C, 0x0C, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0x8F, 0x0F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xE3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0xDC, 0x07, 0x70,
  0x1D, 0xC0, 0x73, 0x03, 0xCE, 0x1F, 0x3F, 0xD8, 0x7E, 0xE0, 0x23, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x83, 0xC3, 0xFE, 0x0F,
  0xE0, 0x00, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x1C, 0x78, 0x70, 0x03, 0x83, 0xC1, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x38, 0x38,
  0x1C, 0x0C, 0x0C, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x03, 0x80,
  0x08, 0x00, 0x00, 0x1F, 0x8F, 0xF9, 0xC7, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x1C, 0x30, 0x00, 0x31, 0xC0, 0xE0, 0xCE, 0x0F, 0xE3, 0x30, 0xF3, 0x8C,
  0xC3, 0x0C, 0x36, 0x18, 0x30, 0xD8, 0x60, 0xC3, 0x63, 0x07, 0x0D, 0x8C,
  0x18, 0x3E, 0x30, 0x61, 0xB8, 0xC3, 0x86, 0xE3, 0x0E, 0x33, 0x8E, 0xFD,
  0xC6, 0x1F, 0x3E, 0x18, 0x10, 0x60, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x81, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x66, 0x00,
  0xE6, 0x00, 0xC6, 0x01, 0xC6, 0x01, 0xC6, 0x03, 0x86, 0x03, 0x86, 0x07,
  0x07, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1C, 0x07, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x18, 0x1C, 0x3F, 0xF8, 0x3F, 0xF0, 0x38, 0x38, 0x38,
  0x1C, 0x30, 0x1C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60,
  0x38, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xC6, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x30, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xC1, 0xE0, 0xE0, 0x78, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03,
  0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x0C, 0x0F, 0x0E,
  0x3F, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xFF, 0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0x11, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xEE,
  0x07, 0xF7, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0x0E, 0x03, 0x87, 0xC1, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x06,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x18,
  0x03, 0x87, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00,
  0xC1, 0xC0, 0x18, 0x38, 0x07, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x27, 0x81, 0xFC, 0x0F, 0x80, 0x00, 0x06, 0x03, 0xC3, 0x81,
  0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x0E, 0x01, 0xC7, 0x00,
  0x73, 0xC0, 0x1D, 0xE0, 0x06, 0x70, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3D,
  0xC0, 0x0E, 0x70, 0x03, 0x0C, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x18,
  0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x80,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0x80, 0x0F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1D,
  0x80, 0x7E, 0x1D, 0x80, 0x6E, 0x1D, 0x80, 0xEC, 0x19, 0x81, 0xDC, 0x19,
  0x81, 0xDC, 0x39, 0x83, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC7, 0x18, 0x31,
  0xC6, 0x38, 0x31, 0xCE, 0x38, 0x71, 0xCC, 0x38, 0x70, 0xDC, 0x38, 0x70,
  0xD8, 0x30, 0x60, 0xF8, 0x70, 0x60, 0xF0, 0x70, 0xE0, 0xF0, 0x70, 0xE0,
  0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0x07, 0x00, 0x70, 0xF0, 0x06, 0x0F, 0x00,
  0x60, 0xF8, 0x0E, 0x0F, 0x80, 0xE1, 0xD8, 0x0E, 0x1D, 0xC0, 0xC1, 0xDC,
  0x0C, 0x18, 0xC1, 0xC1, 0x8C, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x18, 0x38,
  0x63, 0x83, 0x07, 0x38, 0x30, 0x73, 0x87, 0x03, 0x30, 0x70, 0x3B, 0x07,
  0x03, 0xF0, 0x60, 0x1F, 0x06, 0x01, 0xF0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0xF0, 0x78, 0x1E,
  0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70,
  0x78, 0x78, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x70, 0x70, 0xE0, 0xE1, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x1C, 0x0E,
  0x30, 0x1C, 0xE0, 0x71, 0xC7, 0xC3, 0xFF, 0x07, 0xF8, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0xF0, 0x78, 0x1E,
  0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70,
  0x78, 0x78, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0x70, 0xE0, 0xE1, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x30,
  0x3C, 0xE0, 0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x0C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3E, 0x78, 0x70, 0x11, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x8E, 0x1F, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x30, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE0,
  0x70, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0,
  0x70, 0x60, 0xE0, 0x60, 0xE0, 0x61, 0xC0, 0x61, 0xC0, 0x63, 0x80, 0x63,
  0x80, 0x77, 0x00, 0x77, 0x00, 0x76, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x1E, 0x03, 0xB8,
  0x0F, 0x01, 0xDC, 0x07, 0x81, 0xCE, 0x06, 0xC0, 0xE7, 0x03, 0x60, 0x63,
  0x83, 0xB0, 0x71, 0xC1, 0x98, 0x38, 0xE1, 0xCC, 0x38, 0x70, 0xC6, 0x1C,
  0x38, 0x63, 0x1C, 0x1C, 0x71, 0x8E, 0x0E, 0x30, 0xC6, 0x07, 0x38, 0x67,
  0x03, 0x98, 0x33, 0x81, 0xDC, 0x1B, 0x80, 0xEC, 0x0D, 0xC0, 0x76, 0x06,
  0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x0C,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x07, 0x18, 0x00,
  0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xE0,
  0xF0, 0x0E, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0x98, 0x1C, 0x60, 0x71,
  0xC3, 0x87, 0x0C, 0x1C, 0x70, 0x33, 0x80, 0xCE, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xE1, 0x86, 0x18, 0x61, 0xC7,
  0x1C, 0x30, 0xC3, 0x0C, 0x38, 0xE3, 0x86, 0x18, 0x61, 0x87, 0x1C, 0x71,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x3C,
  0x01, 0xB0, 0x06, 0xC0, 0x31, 0x80, 0xC6, 0x06, 0x1C, 0x18, 0x30, 0xC0,
  0xE3, 0x01, 0x98, 0x06, 0xE0, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE7,
  0x18, 0xE3, 0x0C, 0x07, 0xE6, 0x1F, 0xFC, 0x78, 0xF9, 0xE0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xE7,
  0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x1C, 0x6C, 0x3F, 0xB8, 0x3E, 0x70, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x7E, 0x1B, 0xFC, 0x7C, 0x73, 0xC1, 0xCF, 0x03, 0x38, 0x0C, 0xE0, 0x33,
  0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0xBC, 0x0E, 0xF0, 0x73,
  0xE3, 0xCD, 0xFE, 0x33, 0xE0, 0x07, 0xF0, 0xFF, 0x1E, 0x13, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x47, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x0F, 0xDC,
  0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0x60, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C,
  0x0E, 0x0E, 0x0F, 0x03, 0x8F, 0x81, 0xFD, 0xC0, 0x7C, 0xE0, 0x07, 0xF0,
  0x7F, 0x87, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x39, 0xC3, 0xCF, 0xFC, 0xFF,
  0x87, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC1, 0x8F, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF3,
  0x07, 0xFF, 0x0E, 0x1F, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0C, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38,
  0x70, 0x78, 0x38, 0xF8, 0x3F, 0xB8, 0x1F, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x80, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x1E, 0x00,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x7E, 0x1B, 0xFC, 0x78, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0,
  0x73, 0x01, 0x9C, 0x06, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0x98, 0x0C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x30, 0x1C, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x00,
  0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E,
  0x1C, 0x38, 0x60, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x0F, 0xC0,
  0xF8, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x07, 0x1C, 0x38, 0x61, 0xC3, 0x8E, 0x0E, 0x70,
  0x3B, 0x80, 0xDC, 0x03, 0xF0, 0x1F, 0xC0, 0x7B, 0x81, 0xCE, 0x06, 0x18,
  0x38, 0x70, 0xE1, 0xC3, 0x83, 0x8E, 0x0E, 0x30, 0x38, 0x06, 0x1C, 0x38,
  0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70,
  0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x19, 0xF8, 0xF8, 0x6F, 0xE7, 0xF1,
  0xE1, 0xF1, 0xCF, 0x07, 0x83, 0x3C, 0x1C, 0x0C, 0xE0, 0x70, 0x33, 0x81,
  0x81, 0xCC, 0x0E, 0x07, 0x70, 0x38, 0x1D, 0xC0, 0xE0, 0x67, 0x03, 0x03,
  0x98, 0x0C, 0x0E, 0xE0, 0x70, 0x3B, 0x81, 0xC0, 0xEE, 0x07, 0x03, 0x38,
  0x18, 0x1C, 0xC0, 0xE0, 0x70, 0x00, 0x10, 0x19, 0xF8, 0x37, 0xF8, 0x7C,
  0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xC0, 0x70, 0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1D,
  0xC0, 0x77, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0E,
  0xE0, 0x31, 0x81, 0xC7, 0x0E, 0x0F, 0xF0, 0x1F, 0x80, 0x06, 0x7E, 0x06,
  0xFF, 0x07, 0xC7, 0x0F, 0x07, 0x0F, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C,
  0x1C, 0x3E, 0x3C, 0x3F, 0xF8, 0x33, 0xE0, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07,
  0xE6, 0x1F, 0xFC, 0x70, 0xF9, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C,
  0x1E, 0x1C, 0x7C, 0x3F, 0xB8, 0x3E, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x19, 0xE3,
  0x7C, 0x7C, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0xF1,
  0xFF, 0x38, 0x23, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x83, 0xCF, 0xF8, 0xFF, 0x00,
  0x06, 0x03, 0x00, 0xC0, 0x71, 0x7F, 0xBF, 0xE1, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x01,
  0xF8, 0x7E, 0x00, 0x1C, 0x0E, 0x30, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3C, 0x7C, 0x3F, 0xB8, 0x3E, 0x60, 0xC0,
  0x3E, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70,
  0xE3, 0x87, 0x38, 0x39, 0xC0, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE1, 0xF0, 0xEE, 0x1F,
  0x0E, 0xE1, 0xF0, 0xCE, 0x37, 0x1C, 0xE3, 0x71, 0x8E, 0x67, 0x38, 0xE6,
  0x73, 0x8E, 0xE7, 0x70, 0xEC, 0x77, 0x0F, 0xC3, 0x60, 0xF8, 0x3E, 0x0D,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x00, 0x1C, 0x0F,
  0x0E, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x70, 0x07, 0x70, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x38, 0x60, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x38, 0x06, 0x01, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x0C, 0x70, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03,
  0x70, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x38, 0x07, 0x80, 0x78, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x13,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x7E,
  0x07, 0xFF, 0xF8, 0x3F, 0xA0, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 23, 8, 1, -23 },
  { 24, 10, 8, 12, 3, -23 },
  { 34, 18, 23, 18, 1, -23 },
  { 86, 14, 26, 16, 1, -24 },
  { 132, 20, 23, 23, 2, -23 },
  { 190, 17, 23, 19, 1, -23 },
  { 239, 5, 8, 7, 3, -23 },
  { 244, 10, 28, 9, 1, -23 },
  { 279, 10, 28, 9, -2, -23 },
  { 314, 13, 13, 15, 3, -24 },
  { 336, 14, 15, 17, 2, -19 },
  { 363, 6, 8, 8, -1, -4 },
  { 369, 7, 3, 9, 1, -10 },
  { 372, 3, 4, 8, 1, -4 },
  { 374, 16, 23, 11, -2, -23 },
  { 420, 14, 23, 16, 1, -23 },
  { 461, 9, 23, 16, 4, -23 },
  { 487, 15, 23, 16, 0, -23 },
  { 531, 15, 23, 16, 0, -23 },
  { 575, 15, 23, 16, 0, -23 },
  { 619, 15, 23, 16, 1, -23 },
  { 663, 14, 23, 16, 2, -23 },
  { 704, 14, 23, 16, 2, -23 },
  { 745, 15, 23, 16, 1, -23 },
  { 789, 14, 23, 16, 1, -23 },
  { 830, 7, 17, 8, 0, -17 },
  { 845, 9, 21, 8, -2, -17 },
  { 869, 14, 15, 17, 2, -19 },
  { 896, 14, 9, 17, 2, -16 },
  { 912, 14, 15, 17, 2, -19 },
  { 939, 11, 23, 12, 2, -23 },
  { 971, 22, 26, 24, 1, -23 },
  { 1043, 16, 23, 16, -2, -23 },
  { 1089, 16, 23, 17, 1, -23 },
  { 1135, 16, 23, 16, 2, -23 },
  { 1181, 17, 23, 19, 1, -23 },
  { 1230, 15, 23, 15, 1, -23 },
  { 1274, 15, 23, 14, 1, -23 },
  { 1318, 17, 23, 20, 2, -23 },
  { 1367, 19, 23, 19, 1, -23 },
  { 1422, 13, 23, 10, -1, -23 },
  { 1460, 13, 29, 8, -5, -23 },
  { 1508, 18, 23, 16, 1, -23 },
  { 1560, 11, 23, 14, 1, -23 },
  { 1592, 24, 23, 25, 1, -23 },
  { 1661, 20, 23, 20, 1, -23 },
  { 1719, 18, 23, 20, 2, -23 },
  { 1771, 15, 23, 16, 1, -23 },
  { 1815, 18, 28, 20, 2, -23 },
  { 1878, 15, 23, 17, 1, -23 },
  { 1922, 15, 23, 15, 0, -23 },
  { 1966, 14, 23, 14, 3, -23 },
  { 2007, 18, 23, 19, 2, -23 },
  { 2059, 16, 23, 16, 3, -23 },
  { 2105, 25, 23, 25, 3, -23 },
  { 2177, 20, 23, 15, -2, -23 },
  { 2235, 14, 23, 15, 3, -23 },
  { 2276, 17, 23, 15, -1, -23 },
  { 2325, 13, 28, 9, -1, -23 },
  { 2371, 6, 23, 11, 3, -23 },
  { 2389, 12, 28, 9, -2, -23 },
  { 2431, 14, 14, 16, 1, -23 },
  { 2456, 12, 2, 12, -3, 3 },
  { 2459, 5, 6, 9, 5, -25 },
  { 2463, 15, 17, 16, 1, -17 },
  { 2495, 14, 24, 17, 1, -24 },
  { 2537, 12, 17, 13, 1, -17 },
  { 2563, 17, 24, 17, 1, -24 },
  { 2614, 13, 17, 15, 1, -17 },
  { 2642, 17, 32, 9, -4, -24 },
  { 2710, 16, 25, 17, 0, -17 },
  { 2760, 14, 24, 17, 1, -24 },
  { 2802, 7, 24, 7, 1, -24 },
  { 2823, 12, 32, 7, -4, -24 },
  { 2871, 14, 24, 14, 1, -24 },
  { 2913, 7, 24, 7, 1, -24 },
  { 2934, 22, 17, 25, 1, -17 },
  { 2981, 15, 18, 17, 0, -18 },
  { 3015, 14, 17, 16, 1, -17 },
  { 3045, 16, 25, 17, -1, -17 },
  { 3095, 15, 25, 17, 1, -17 },
  { 3142, 11, 17, 11, 1, -17 },
  { 3166, 12, 17, 12, 0, -17 },
  { 3192, 10, 21, 10, 1, -21 },
  { 3219, 15, 17, 17, 1, -17 },
  { 3251, 13, 17, 13, 2, -17 },
  { 3279, 20, 17, 21, 2, -17 },
  { 3322, 16, 17, 14, -1, -17 },
  { 3356, 18, 25, 13, -3, -17 },
  { 3413, 14, 17, 12, -1, -17 },
  { 3443, 13, 28, 11, 0, -23 },
  { 3489, 2, 32, 15, 7, -24 },
  { 3497, 12, 28, 11, -1, -23 },
  { 3539, 14, 4, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_Italic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC32PT7B_H_
