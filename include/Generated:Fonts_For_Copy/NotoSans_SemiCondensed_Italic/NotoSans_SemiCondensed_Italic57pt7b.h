#ifndef _NOTOSANS_SEMICONDENSED_ITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0xC0, 0x00, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xE3,
  0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFC, 0x70, 0xE0, 0x3E, 0x1C, 0x08, 0x0F, 0x0F, 0x00, 0x07, 0xC3,
  0x80, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xF9, 0xC0, 0x00, 0x3F, 0x70, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x70, 0xF8, 0x00, 0x1C, 0x3E, 0x00, 0x07, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xE0, 0xF8, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1F, 0x0C, 0x03, 0x8F,
  0xC3, 0xE1, 0xEF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0xFF, 0xC0, 0x01, 0xE0, 0x3F, 0xF8,
  0x00, 0x7C, 0x07, 0xCF, 0x80, 0x0F, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x3C,
  0x1E, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0x3C, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C,
  0x1E, 0x00, 0x3C, 0x07, 0x87, 0xC0, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0xF0,
  0x1E, 0x3C, 0x1F, 0x1E, 0x07, 0x87, 0x8F, 0xF3, 0xC0, 0xF1, 0xE3, 0xFF,
  0x78, 0x3C, 0x78, 0xFF, 0xFF, 0x0F, 0x8F, 0x3E, 0x1F, 0xF3, 0xE3, 0xC7,
  0x83, 0xDF, 0xF8, 0xF1, 0xE0, 0x79, 0xFE, 0x1E, 0x3C, 0x0F, 0x1F, 0x87,
  0x8F, 0x01, 0xE0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x3C, 0x3C, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0,
  0x0F, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0x3E, 0x3C, 0x03,
  0xC0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x0F, 0x8F, 0xC3,
  0xE0, 0x3E, 0x1F, 0x07, 0xE0, 0x7C, 0x7C, 0x07, 0xC0, 0xF1, 0xF0, 0x07,
  0xC3, 0xE3, 0xE0, 0x0F, 0x8F, 0x87, 0x80, 0x0F, 0x9F, 0x1F, 0x00, 0x1F,
  0xFC, 0x3E, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xF1, 0xF8,
  0x0F, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x0C, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7F, 0x1C, 0x00, 0xFF,
  0xB8, 0x00, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xBF, 0xE0, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x07, 0xCF, 0x00, 0x1F, 0x1E,
  0x00, 0x7E, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0x80, 0x78,
  0x01, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF8, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x1F, 0xFE, 0x3F, 0xBE, 0xFF, 0x3E, 0x7C, 0x3C, 0x38, 0x7C, 0x30, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0x20, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0F, 0xC0, 0x10, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x60, 0x00, 0x7E, 0x0F,
  0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x30,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x40, 0x00, 0xFC, 0x0E, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xF0, 0x08, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x0E, 0x00, 0x3E, 0x3F, 0xE0, 0x1E, 0x7F, 0xF8, 0x1F, 0x7F, 0xFE,
  0x0F, 0xFE, 0xFF, 0x07, 0xF8, 0x0F, 0xC3, 0xF8, 0x03, 0xE3, 0xF8, 0x01,
  0xF1, 0xF8, 0x00, 0x78, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0,
  0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC3, 0xE0, 0x0F, 0xE1, 0xF8,
  0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0x7C, 0x0F, 0xFF, 0x3C, 0x03,
  0xFF, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x08, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x03, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x07, 0xF1, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3F, 0xF8, 0x1E, 0x0F, 0x00, 0x7F, 0xFC,
  0x0F, 0x0F, 0x00, 0xFF, 0xFC, 0x0F, 0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x3C, 0x0F, 0x80,
  0x78, 0x0F, 0x3C, 0x0F, 0x00, 0xF0, 0x0E, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x78, 0x1E,
  0x01, 0xE0, 0x1E, 0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x78, 0x3C, 0x03, 0xE0,
  0x3C, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0xF0,
  0x3C, 0x07, 0xC0, 0x78, 0xF0, 0x3C, 0x0F, 0xC0, 0xF0, 0xF0, 0x3E, 0x1F,
  0xE1, 0xE0, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0x78, 0x1F, 0xF8, 0xFF, 0xC0,
  0x78, 0x0F, 0xF0, 0x7F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xDF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0x00, 0x7F, 0x00,
  0x18, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x80,
  0xF8, 0x01, 0xFE, 0x01, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7E, 0x00,
  0xFE, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x7F, 0xF8, 0xFC,
  0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x03, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x3F,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xDF,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x1E, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xF7,
  0xC0, 0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x01, 0xF7, 0xC0, 0x3E, 0x78, 0x00, 0x3C, 0xF8, 0x07, 0xCF,
  0x00, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x00,
  0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x00,
  0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xE0,
  0xF0, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x07, 0x81,
  0xF0, 0x0F, 0x81, 0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x3C, 0x07, 0xC0,
  0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x07, 0x80, 0xF9, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFE, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x7E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x03,
  0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x78,
  0x00, 0x7C, 0x01, 0xE7, 0x80, 0x07, 0xC0, 0x1E, 0x7C, 0x00, 0x7C, 0x03,
  0xE7, 0xC0, 0x07, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x80, 0x3C, 0x3E, 0x00, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x7C, 0x1F,
  0x00, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x07,
  0x80, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x00, 0x3E, 0x7C, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x00, 0x1E, 0x78,
  0x03, 0xE0, 0x01, 0xF7, 0x80, 0x3E, 0x00, 0x1F, 0x78, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x07, 0x80, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xF0, 0x7C, 0x03, 0xF0, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x60, 0x00, 0xFC, 0x0F,
  0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x07,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xBC, 0x00, 0xF8, 0x7C,
  0x01, 0xE7, 0x80, 0x1F, 0x0F, 0x80, 0x3C, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x9E, 0x00, 0xF8, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x78,
  0x07, 0xC0, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE1, 0xE0, 0x3E,
  0x03, 0xE0, 0x78, 0x3C, 0x07, 0x80, 0x7C, 0x0F, 0x07, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0xF0, 0x3E, 0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x3E, 0x1F,
  0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x00, 0xF8, 0xF8, 0x0F,
  0x0F, 0x80, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x03, 0xE3, 0xC0, 0x3C, 0x7C,
  0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x01,
  0xF7, 0xC0, 0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x07, 0xDE,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00,
  0xF8, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xE0,
  0x0F, 0xFC, 0x78, 0x03, 0xFF, 0xCF, 0x00, 0xFF, 0xF9, 0xE0, 0x3F, 0x87,
  0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x01,
  0xF8, 0x3D, 0xE0, 0x3F, 0xFF, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0x3F, 0xF1,
  0xF0, 0x03, 0xFC, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0x0F, 0x3F, 0xFE,
  0x03, 0xDE, 0x1F, 0xC1, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xC0,
  0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x07,
  0xF8, 0x1F, 0x81, 0xEF, 0xFF, 0xE0, 0xF9, 0xFF, 0xF0, 0x3C, 0x7F, 0xF8,
  0x0F, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x38, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x18, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x3F,
  0xF1, 0xE0, 0x07, 0xFF, 0xCF, 0x00, 0x7F, 0xFE, 0xF8, 0x03, 0xF0, 0x7F,
  0xC0, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x3F,
  0xC0, 0x3E, 0x03, 0xFC, 0x01, 0xF8, 0x3D, 0xE0, 0x0F, 0xFF, 0xCF, 0x00,
  0x3F, 0xFC, 0xF8, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x3C, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x07, 0x83, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x3F, 0x8F, 0x87, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x41, 0xF8, 0x03, 0x81, 0xFF, 0x7F, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x78, 0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xFF, 0x3C,
  0x01, 0xFF, 0xF9, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0xF7, 0x80, 0x3F, 0xFF, 0x7C, 0x00, 0xFF, 0xF3, 0xE0, 0x03, 0xFF,
  0x1E, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x18, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x0F, 0xC0, 0x1C, 0x00,
  0xFC, 0x00, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0x0F, 0x3F,
  0xFE, 0x03, 0xDE, 0x0F, 0xC1, 0xFF, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F,
  0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x37, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x7E,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xE1,
  0xFF, 0x03, 0xFF, 0x00, 0xF1, 0xFF, 0xC3, 0xFF, 0xC0, 0x79, 0xFF, 0xE3,
  0xFF, 0xE0, 0x3D, 0xE1, 0xFB, 0xE1, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0x7C,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE1, 0xFE, 0x00,
  0xF0, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8, 0x0F, 0x3F, 0xFE, 0x07, 0xDF, 0x1F,
  0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xC0, 0x1F, 0x07, 0xE0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x1F, 0x80, 0x03, 0xC3, 0xFF,
  0x00, 0x1E, 0x3F, 0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x07, 0xBC, 0x1F, 0x80,
  0x7F, 0xC0, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1E, 0xFF, 0xFE, 0x00, 0xF3,
  0xFF, 0xE0, 0x0F, 0x9F, 0xFE, 0x00, 0x7C, 0x3F, 0xC0, 0x03, 0xE0, 0x20,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xE0, 0x0F, 0xFC, 0x78, 0x03, 0xFF, 0xCF, 0x01,
  0xFF, 0xF9, 0xE0, 0x3F, 0x07, 0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x03,
  0xFC, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x3D, 0xE0, 0x3F, 0xFF, 0x7C, 0x03,
  0xFF, 0xCF, 0x80, 0x3F, 0xF1, 0xE0, 0x03, 0xFC, 0x7C, 0x00, 0x18, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC1, 0xF8,
  0x1E, 0x1F, 0xC0, 0xF1, 0xFE, 0x07, 0x9F, 0xE0, 0x3D, 0xFB, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xE0, 0x78, 0x3E, 0x00, 0x40,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC2, 0x00, 0x1F, 0x0C, 0x00, 0xFC, 0x3F, 0xBF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0C, 0x00, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x0F, 0xC3, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xF0, 0x07, 0xF0, 0x7C,
  0x07, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0x9E, 0x03,
  0xFF, 0x8F, 0x00, 0xFF, 0x87, 0x80, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0x03,
  0xEF, 0x80, 0x3F, 0x80, 0x3E, 0x7C, 0x01, 0xFC, 0x01, 0xF3, 0xE0, 0x1F,
  0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x78, 0x0F, 0x78, 0x0F, 0x83,
  0xC0, 0x7B, 0xC0, 0x7C, 0x1E, 0x07, 0x9E, 0x03, 0xC0, 0xF0, 0x3C, 0xF0,
  0x3E, 0x07, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0x1E, 0x3C, 0x1F, 0x01, 0xE0,
  0xF1, 0xE0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x78, 0x7C,
  0x03, 0xC7, 0x83, 0xC3, 0xC0, 0x1E, 0x3C, 0x1E, 0x3E, 0x00, 0xF3, 0xE0,
  0xF1, 0xE0, 0x07, 0x9E, 0x03, 0x9F, 0x00, 0x3C, 0xF0, 0x1C, 0xF8, 0x01,
  0xEF, 0x00, 0xE7, 0x80, 0x0F, 0x78, 0x07, 0x7C, 0x00, 0x7F, 0x80, 0x3B,
  0xC0, 0x03, 0xFC, 0x01, 0xDE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x81, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x8F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x4F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x9F, 0xF8, 0x00,
  0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFA, 0x00, 0x0F, 0xF9, 0x00, 0x00, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 17, 15, 21, 6, -41 },
  { 107, 32, 41, 32, 1, -41 },
  { 271, 26, 46, 28, 1, -43 },
  { 421, 35, 42, 42, 4, -41 },
  { 605, 31, 42, 33, 1, -41 },
  { 768, 7, 15, 12, 6, -41 },
  { 782, 18, 50, 16, 2, -41 },
  { 895, 18, 50, 16, -4, -41 },
  { 1008, 23, 23, 27, 6, -43 },
  { 1075, 25, 28, 30, 3, -34 },
  { 1163, 11, 14, 13, -3, -7 },
  { 1183, 14, 5, 17, 1, -18 },
  { 1192, 7, 8, 13, 1, -7 },
  { 1199, 27, 41, 20, -3, -41 },
  { 1338, 24, 42, 28, 3, -41 },
  { 1464, 16, 41, 28, 7, -41 },
  { 1546, 28, 41, 28, -1, -41 },
  { 1690, 27, 42, 28, 0, -41 },
  { 1832, 27, 41, 28, 0, -41 },
  { 1971, 27, 42, 28, 1, -41 },
  { 2113, 25, 42, 28, 3, -41 },
  { 2245, 25, 41, 28, 4, -41 },
  { 2374, 27, 42, 28, 1, -41 },
  { 2516, 25, 42, 28, 2, -41 },
  { 2648, 11, 32, 14, 1, -31 },
  { 2692, 15, 38, 14, -3, -31 },
  { 2764, 25, 27, 30, 3, -34 },
  { 2849, 24, 16, 30, 4, -28 },
  { 2897, 25, 27, 30, 3, -34 },
  { 2982, 20, 42, 22, 3, -41 },
  { 3087, 40, 46, 43, 2, -41 },
  { 3317, 29, 41, 29, -3, -41 },
  { 3466, 29, 41, 31, 1, -41 },
  { 3615, 29, 42, 29, 3, -41 },
  { 3768, 31, 41, 34, 1, -41 },
  { 3927, 28, 41, 26, 1, -41 },
  { 4071, 28, 41, 24, 1, -41 },
  { 4215, 32, 42, 35, 3, -41 },
  { 4383, 33, 41, 35, 2, -41 },
  { 4553, 23, 41, 17, -2, -41 },
  { 4671, 24, 52, 14, -9, -41 },
  { 4827, 33, 41, 29, 1, -41 },
  { 4997, 20, 41, 24, 1, -41 },
  { 5100, 43, 41, 44, 1, -41 },
  { 5321, 36, 41, 36, 1, -41 },
  { 5506, 32, 42, 36, 3, -41 },
  { 5674, 28, 41, 29, 1, -41 },
  { 5818, 32, 51, 36, 3, -41 },
  { 6022, 28, 41, 29, 1, -41 },
  { 6166, 27, 42, 26, 0, -41 },
  { 6308, 25, 41, 25, 5, -41 },
  { 6437, 31, 42, 34, 4, -41 },
  { 6600, 28, 41, 28, 5, -41 },
  { 6744, 43, 41, 45, 6, -41 },
  { 6965, 34, 41, 27, -3, -41 },
  { 7140, 26, 41, 26, 5, -41 },
  { 7274, 30, 41, 26, -1, -41 },
  { 7428, 22, 50, 16, -1, -41 },
  { 7566, 10, 41, 20, 6, -41 },
  { 7618, 22, 50, 16, -4, -41 },
  { 7756, 26, 24, 29, 2, -41 },
  { 7834, 21, 4, 21, -5, 5 },
  { 7845, 9, 9, 15, 8, -44 },
  { 7856, 27, 32, 29, 2, -31 },
  { 7964, 26, 44, 30, 1, -43 },
  { 8107, 22, 32, 23, 2, -31 },
  { 8195, 29, 44, 30, 2, -43 },
  { 8355, 23, 32, 26, 2, -31 },
  { 8447, 30, 58, 16, -7, -44 },
  { 8665, 29, 45, 30, 0, -31 },
  { 8829, 26, 43, 29, 1, -43 },
  { 8969, 14, 42, 13, 1, -42 },
  { 9043, 22, 56, 13, -7, -42 },
  { 9197, 26, 43, 25, 1, -43 },
  { 9337, 14, 43, 13, 1, -43 },
  { 9413, 41, 31, 44, 1, -31 },
  { 9572, 26, 31, 29, 1, -31 },
  { 9673, 25, 32, 29, 2, -31 },
  { 9773, 29, 45, 30, -2, -31 },
  { 9937, 27, 45, 30, 2, -31 },
  { 10089, 21, 31, 20, 1, -31 },
  { 10171, 22, 32, 22, 0, -31 },
  { 10259, 16, 39, 17, 3, -38 },
  { 10337, 25, 32, 30, 3, -31 },
  { 10437, 24, 31, 24, 3, -31 },
  { 10530, 37, 31, 37, 3, -31 },
  { 10674, 28, 31, 25, -2, -31 },
  { 10783, 32, 45, 24, -5, -31 },
  { 10963, 23, 31, 22, -1, -31 },
  { 11053, 22, 50, 20, 1, -41 },
  { 11191, 4, 57, 28, 12, -43 },
  { 11220, 22, 50, 20, -3, -41 },
  { 11358, 25, 8, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Italic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC57PT7B_H_
