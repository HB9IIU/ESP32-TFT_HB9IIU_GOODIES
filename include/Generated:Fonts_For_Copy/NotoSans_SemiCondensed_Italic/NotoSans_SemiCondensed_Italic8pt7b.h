#ifndef _NOTOSANS_SEMICONDENSED_ITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x31, 0x96, 0xAE, 0x50, 0x27, 0x42, 0x6C, 0xD6,
  0xBD, 0xD6, 0xD8, 0x25, 0x67, 0xBF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92,
  0xB0, 0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25,
  0x99, 0x96, 0x75, 0x60, 0x61, 0x12, 0x4E, 0x61, 0x16, 0x2E, 0x13, 0x5A,
  0xF2, 0x74, 0x61, 0x1E, 0x34, 0x69, 0x96, 0x71, 0x22, 0x4C, 0x35, 0x56,
  0x9E, 0x25, 0x97, 0x2E, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C,
  0x64, 0xA1, 0x00, 0x39, 0x1B, 0xED, 0xBA, 0x07, 0x00, 0x22, 0x67, 0x99,
  0x75, 0x57, 0x9E, 0x3A, 0x11, 0x08, 0x30, 0x72, 0x52, 0x99, 0x70, 0x74,
  0x46, 0x8E, 0x74, 0x46, 0x88, 0x3A, 0x11, 0x39, 0x38, 0x4A, 0x52, 0xE9,
  0x48, 0x69, 0x25, 0x80, 0x24, 0x94, 0x94, 0x4A, 0x98, 0xCA, 0x48, 0x49,
  0x29, 0xC0, 0x45, 0x16, 0xDD, 0xB6, 0xA0, 0x4B, 0x5A, 0xD9, 0x48, 0x32,
  0x53, 0x18, 0xB8, 0x75, 0x56, 0x88, 0x32, 0x53, 0x18, 0xB8, 0xC0, 0x75,
  0x56, 0xA9, 0x74, 0x42, 0x2E, 0xE9, 0x49, 0x00, 0x4A, 0x52, 0xA9, 0x38,
  0x9A, 0xAC, 0xC8, 0xA6, 0x9E, 0xBA, 0x92, 0x40, 0x55, 0x26, 0xAA, 0xB7,
  0x49, 0x00, 0x71, 0x24, 0x8E, 0x69, 0x49, 0x30, 0xFC, 0x24, 0x92, 0x70,
  0x26, 0x59, 0xE0, 0x80, 0x79, 0x9E, 0x46, 0x55, 0x9E, 0x72, 0x30, 0x13,
  0x59, 0x9E, 0x7E, 0x30, 0x33, 0x62, 0x44, 0x48, 0x79, 0x9E, 0x2C, 0x46,
  0x55, 0x9A, 0x46, 0xA0, 0x20, 0x94, 0x94, 0x45, 0x64, 0xAA, 0x55, 0xA0,
  0x7D, 0x5A, 0x6A, 0x75, 0x9A, 0x79, 0x96, 0x75, 0x9E, 0x88, 0x79, 0x9E,
  0x22, 0x6A, 0x40, 0xE8, 0xE0, 0x79, 0x4C, 0x59, 0x9E, 0xBA, 0xC4, 0xAE,
  0xA5, 0x14, 0x74, 0x4A, 0x4A, 0x88, 0x44, 0x60, 0x69, 0x60, 0x29, 0x64,
  0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 6, 1, -6 },
  { 15, 4, 6, 5, 0, -6 },
  { 18, 1, 2, 2, 1, -6 },
  { 19, 3, 7, 2, 0, -6 },
  { 22, 3, 7, 2, -1, -6 },
  { 25, 3, 3, 4, 1, -6 },
  { 27, 4, 4, 4, 0, -5 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -3 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 2, 6, 4, 1, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 4, 2, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 6, 7, 6, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 5, 6, 4, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 3, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 3, 6, 2, 0, -6 },
  { 112, 3, 8, 2, -1, -6 },
  { 115, 5, 6, 4, 0, -6 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 6, 6, 6, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 5, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 5, 7, 5, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 3, 6, 4, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 4, 6, 4, 1, -6 },
  { 159, 6, 6, 6, 1, -6 },
  { 164, 4, 6, 4, 0, -6 },
  { 167, 3, 6, 4, 1, -6 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 3, 7, 2, 0, -6 },
  { 176, 1, 6, 3, 1, -6 },
  { 177, 3, 7, 2, -1, -6 },
  { 180, 4, 4, 4, 0, -6 },
  { 182, 3, 1, 3, -1, 0 },
  { 183, 1, 1, 2, 1, -6 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 4, 6, 4, 0, -6 },
  { 194, 3, 4, 4, 0, -4 },
  { 196, 4, 8, 2, -1, -6 },
  { 200, 4, 6, 4, 0, -4 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 2, 6, 2, 0, -6 },
  { 208, 3, 8, 2, -1, -6 },
  { 211, 4, 6, 4, 0, -6 },
  { 214, 2, 6, 2, 0, -6 },
  { 216, 6, 4, 6, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 5, 2, 0, -5 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 4, 3, 0, -4 },
  { 239, 6, 4, 5, 0, -4 },
  { 242, 4, 4, 3, 0, -4 },
  { 244, 5, 6, 3, -1, -4 },
  { 248, 3, 4, 3, 0, -4 },
  { 250, 3, 7, 3, 0, -6 },
  { 253, 1, 8, 4, 2, -6 },
  { 254, 3, 7, 3, 0, -6 },
  { 257, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Italic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC8PT7B_H_
