#ifndef _NOTOSANS_SEMICONDENSED_ITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x79, 0xEE, 0x39, 0xC7, 0x38,
  0xE6, 0x19, 0xC7, 0x38, 0xE6, 0x1C, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x06,
  0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00, 0xE1, 0xC0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x3F, 0xF8,
  0x7F, 0xF8, 0x39, 0x84, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x30,
  0x03, 0xD8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0xE2,
  0x0C, 0xF1, 0xF7, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x07, 0x00, 0x08, 0x3F, 0x00, 0x60, 0xFF,
  0x01, 0xC3, 0x8E, 0x07, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x38, 0x38, 0x70,
  0xE0, 0x70, 0xE1, 0x80, 0xC1, 0xC7, 0x01, 0x83, 0x1C, 0x03, 0x06, 0x38,
  0x06, 0x1C, 0xE7, 0xCC, 0x33, 0x9F, 0xD8, 0xE7, 0x73, 0xBF, 0x9C, 0xC3,
  0x7E, 0x73, 0x87, 0x38, 0xE6, 0x0C, 0x03, 0x8C, 0x18, 0x0E, 0x38, 0x30,
  0x1C, 0x70, 0xE0, 0x70, 0xE1, 0xC0, 0xC1, 0x83, 0x03, 0x83, 0x06, 0x0E,
  0x07, 0x1C, 0x18, 0x0E, 0x70, 0x70, 0x1F, 0xC1, 0xC0, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x73, 0xCE, 0x0E, 0x78, 0xF0, 0xE7, 0x07, 0x9C, 0xE0, 0x39, 0xCE, 0x03,
  0xF8, 0xE0, 0x1F, 0x8E, 0x01, 0xF0, 0xE0, 0x1E, 0x0F, 0x03, 0xF0, 0xF9,
  0xFF, 0x87, 0xFE, 0x38, 0x3F, 0xC3, 0xC0, 0x7B, 0x9C, 0xE6, 0x73, 0x9C,
  0xC0, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x04, 0x0C, 0x0E, 0x18, 0x1F, 0x60,
  0x0F, 0xFF, 0x83, 0xFF, 0x07, 0x8E, 0x3B, 0x00, 0xF7, 0x03, 0xC6, 0x07,
  0x0E, 0x04, 0x1C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C,
  0x38, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0x1E, 0x1E, 0x0E, 0x1C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF0, 0xF0, 0x7B, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x03, 0xC1, 0xF1, 0xFC, 0xFE, 0xFB, 0xBC, 0xE4, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1E, 0x1E, 0x02, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x1E, 0x04, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE2, 0x00, 0xF0, 0xF9, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80,
  0x0E, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38,
  0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x70, 0x1C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0x01, 0xCF, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE2, 0x01, 0xE1,
  0xE3, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0xC0, 0x73, 0xF8, 0x7F, 0xFC, 0x7C, 0x3C, 0xF8,
  0x1C, 0xF0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0x7D, 0xF0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x81, 0xC3, 0x80, 0xF7, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x7C, 0x78, 0x78, 0x1C, 0x38, 0x0F, 0x3C,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xE0, 0x78,
  0x7C, 0x7C, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0F,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xE0,
  0xF8, 0x7D, 0xDC, 0x3F, 0xFC, 0x0F, 0xCE, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0xE7, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8,
  0x70, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x03, 0x81, 0xFF, 0x9F, 0xFC, 0x60, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x78, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x70, 0x3F, 0x87, 0x38, 0x3F,
  0xE3, 0xB8, 0x38, 0x60, 0xDC, 0x38, 0x70, 0x6C, 0x38, 0x38, 0x7E, 0x1C,
  0x1C, 0x3F, 0x1C, 0x0C, 0x1F, 0x0E, 0x0E, 0x0D, 0x87, 0x07, 0x06, 0xC3,
  0x03, 0x87, 0x61, 0x83, 0x83, 0x30, 0xE1, 0xC3, 0x98, 0x73, 0xF3, 0x8C,
  0x1F, 0x9F, 0x87, 0x07, 0x87, 0x83, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0xF3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x1C, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x78,
  0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1C,
  0x1F, 0x03, 0x80, 0xE0, 0xF0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70,
  0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x3E, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0x03, 0xC1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00,
  0x70, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x07,
  0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xF0, 0x60, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0x1F, 0xC0, 0x70, 0x3E, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x03,
  0xC7, 0x80, 0x78, 0x70, 0x07, 0x87, 0x01, 0xF0, 0x70, 0x3E, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x20, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xC0, 0xE0, 0x78, 0x01, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x0F, 0xF3, 0xC0, 0x7F, 0x9E, 0x03, 0xF8, 0xF0, 0x01,
  0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x80, 0xF0, 0x3F, 0xBF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0xF0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x1C, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0x80, 0xF8, 0x38, 0x0F,
  0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x78, 0x07, 0x07, 0x80, 0x38,
  0x78, 0x01, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0x38, 0x00,
  0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x8E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x07,
  0x03, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x0E, 0xC0, 0x0F, 0xE0, 0xEE, 0x00, 0xEE, 0x0E, 0xE0, 0x1D, 0xC0,
  0xEE, 0x01, 0xDC, 0x0E, 0xE0, 0x39, 0xC1, 0xCE, 0x03, 0x9C, 0x1C, 0xE0,
  0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x81, 0xCE, 0x0E, 0x38,
  0x38, 0x61, 0xC3, 0x83, 0x86, 0x1C, 0x78, 0x38, 0x63, 0x87, 0x03, 0x87,
  0x38, 0x70, 0x78, 0x77, 0x07, 0x07, 0x07, 0x70, 0xF0, 0x70, 0x7E, 0x0E,
  0x07, 0x07, 0xE0, 0xE0, 0x70, 0x7C, 0x0E, 0x0E, 0x07, 0xC0, 0xE0, 0xE0,
  0x78, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0x07, 0x80, 0x0E, 0x0F, 0x80, 0x3C,
  0x1F, 0x00, 0x70, 0x3E, 0x00, 0xE0, 0xFC, 0x01, 0xC1, 0xDC, 0x03, 0x83,
  0xB8, 0x0E, 0x07, 0x70, 0x1C, 0x0E, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x71,
  0xC0, 0xE0, 0xE1, 0xC3, 0x81, 0xC3, 0x87, 0x03, 0x87, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x0E, 0x78, 0x38, 0x1C, 0xE0, 0x70, 0x39, 0xC1, 0xE0, 0x3B,
  0x83, 0x80, 0x77, 0x07, 0x00, 0xEE, 0x0E, 0x00, 0xF8, 0x1C, 0x01, 0xF0,
  0x70, 0x03, 0xE0, 0xE0, 0x07, 0xC1, 0xC0, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x07, 0x00,
  0x38, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3B, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0,
  0x03, 0xCF, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x71, 0xF8, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x38, 0x70, 0x1E, 0x1C,
  0x1F, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00,
  0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xCF,
  0x00, 0x1C, 0x38, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x70, 0xF8, 0x1C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78, 0x70,
  0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xE1, 0xC0, 0x38, 0x78,
  0x0E, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xF0, 0x70, 0x3C, 0x1C, 0x07, 0x07,
  0x01, 0xC3, 0xC0, 0x78, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC2, 0x00, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00,
  0x70, 0x78, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0xFE, 0x01, 0xE0, 0x0E,
  0xE0, 0x1E, 0x01, 0xEE, 0x01, 0xE0, 0x1C, 0xE0, 0x3F, 0x01, 0xCE, 0x03,
  0x70, 0x38, 0xE0, 0x77, 0x03, 0x8E, 0x07, 0x70, 0x78, 0xE0, 0xE7, 0x07,
  0x0E, 0x0E, 0x70, 0x70, 0xE1, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0xE0, 0xE1,
  0x87, 0x1C, 0x0E, 0x38, 0x71, 0xC0, 0xE3, 0x87, 0x3C, 0x0E, 0x70, 0x73,
  0x80, 0xE7, 0x07, 0x38, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x0E,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0x77,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDE, 0x00, 0x0E,
  0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0F, 0x00, 0x78, 0x1C,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC1, 0xC1,
  0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x06, 0x70, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xE3, 0x8E, 0x38,
  0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87,
  0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1B, 0x80, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x07, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xF1, 0xC3, 0x8E, 0x1C, 0x30, 0x01, 0xF1,
  0xC1, 0xFE, 0x60, 0xFF, 0xF8, 0x78, 0x3E, 0x1C, 0x07, 0x8F, 0x01, 0xC3,
  0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x7C,
  0x1E, 0x37, 0x03, 0xFD, 0xC0, 0x7C, 0x70, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x7C, 0x07, 0x7F, 0x87, 0x7F, 0xC3, 0xE0, 0xE1, 0xF0, 0x78, 0xF0,
  0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xCF,
  0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF8, 0x3C,
  0x7E, 0x3C, 0x3B, 0xFC, 0x18, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF8, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x01, 0xF3, 0xC0, 0xFF, 0x70, 0x3F, 0xFE, 0x0F,
  0x07, 0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x78,
  0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0x70, 0x7C, 0x0F, 0x3B, 0x80, 0xFE,
  0x70, 0x0F, 0x8C, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3E, 0xF8, 0xF0, 0x71,
  0xC0, 0xE7, 0x81, 0xCE, 0x07, 0xBC, 0x1E, 0x71, 0xF8, 0xFF, 0xE1, 0xFF,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x08,
  0xF8, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x79, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0xE0, 0x7F, 0x98, 0x1F, 0xFF, 0x07, 0x83, 0xE0, 0xE0, 0x3C, 0x3C, 0x07,
  0x07, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C,
  0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0,
  0x38, 0x3E, 0x07, 0x9D, 0xC0, 0x7F, 0x38, 0x0F, 0xCF, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x18, 0x1E, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x7E, 0x0E, 0xFF, 0x1D, 0xFF, 0x1F, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0x07, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7,
  0x80, 0xE7, 0x80, 0xF3, 0x80, 0x73, 0x80, 0x3B, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xB8, 0x07, 0x9E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xE0,
  0xF0, 0x70, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x00, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0C, 0x7C, 0x1F, 0x03, 0x3F, 0x8F, 0xE1,
  0xDF, 0xF7, 0xFC, 0x7C, 0x1F, 0x07, 0x1E, 0x07, 0x81, 0xC7, 0x81, 0xE0,
  0x73, 0xC0, 0x70, 0x1C, 0xF0, 0x3C, 0x07, 0x38, 0x0E, 0x03, 0xCE, 0x03,
  0x80, 0xE3, 0x80, 0xE0, 0x39, 0xE0, 0x38, 0x0E, 0x70, 0x1E, 0x03, 0x9C,
  0x07, 0x01, 0xC7, 0x01, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0xF0, 0x1C, 0x07,
  0x38, 0x0E, 0x03, 0xCE, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0x0C, 0x7E,
  0x0E, 0x7F, 0x87, 0x7F, 0xC3, 0xF0, 0xE1, 0xF0, 0x78, 0xF0, 0x38, 0xF0,
  0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E,
  0x38, 0x0F, 0x1C, 0x07, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E,
  0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0x1F, 0x80,
  0x67, 0xF8, 0x1D, 0xDF, 0x03, 0xE0, 0xE0, 0x7C, 0x1E, 0x0F, 0x01, 0xC1,
  0xC0, 0x38, 0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x3E,
  0x0F, 0x07, 0xE3, 0xC0, 0xEF, 0xF0, 0x1C, 0xFC, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF1, 0xC1, 0xFE, 0x60, 0xFF,
  0xF8, 0x78, 0x3E, 0x1C, 0x07, 0x8F, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0x70, 0x7C, 0x1E, 0x77, 0x03, 0xF9,
  0xC0, 0xFC, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x0C, 0x78, 0x67, 0xC7, 0x7E, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xF1, 0xF7, 0xC7, 0x02, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x80, 0xF3, 0x8F, 0x8F, 0xFC, 0x3F, 0xE0, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x3F, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x8F,
  0xE1, 0xF8, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xF0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF8,
  0xF3, 0xB8, 0xFF, 0x38, 0x7E, 0x30, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77,
  0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x78, 0x70, 0xE0, 0xE3,
  0xC1, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3B, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0xE0,
  0x3C, 0x0E, 0xE0, 0x7C, 0x0E, 0xE0, 0x7C, 0x1C, 0xE0, 0xFC, 0x1C, 0xE0,
  0xDC, 0x3C, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE1, 0x9C, 0x70, 0xE3,
  0x9C, 0x70, 0xE3, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE6, 0x1D, 0xC0, 0xEE,
  0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0xC3, 0xC0,
  0xE0, 0x70, 0x70, 0x1C, 0x3C, 0x07, 0x1E, 0x00, 0xE7, 0x00, 0x3B, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0x70, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x3C, 0x38, 0x1E, 0x0E,
  0x07, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x00,
  0xE0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x38,
  0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x0F, 0xC0,
  0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0xFC, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x03, 0xF0,
  0x0F, 0xC0, 0x38, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xE3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 11, 9, 14, 4, -26 },
  { 44, 20, 26, 21, 1, -26 },
  { 109, 17, 30, 18, 1, -28 },
  { 173, 23, 27, 27, 3, -27 },
  { 251, 20, 27, 22, 1, -27 },
  { 319, 5, 9, 8, 4, -26 },
  { 325, 12, 32, 10, 1, -26 },
  { 373, 12, 32, 10, -3, -26 },
  { 421, 15, 15, 18, 4, -28 },
  { 450, 16, 18, 19, 2, -22 },
  { 486, 7, 9, 9, -2, -4 },
  { 494, 9, 3, 11, 1, -11 },
  { 498, 4, 4, 9, 1, -4 },
  { 500, 18, 26, 13, -2, -26 },
  { 559, 16, 27, 18, 2, -27 },
  { 613, 10, 26, 18, 5, -26 },
  { 646, 18, 27, 18, 0, -27 },
  { 707, 18, 27, 18, 0, -27 },
  { 768, 18, 26, 18, 0, -26 },
  { 827, 17, 26, 18, 1, -26 },
  { 883, 16, 27, 18, 2, -27 },
  { 937, 17, 26, 18, 2, -26 },
  { 993, 17, 27, 18, 1, -27 },
  { 1051, 17, 27, 18, 1, -27 },
  { 1109, 8, 20, 9, 0, -20 },
  { 1129, 10, 25, 9, -2, -20 },
  { 1161, 16, 17, 19, 2, -22 },
  { 1195, 16, 10, 19, 2, -18 },
  { 1215, 16, 17, 19, 2, -22 },
  { 1249, 13, 27, 14, 2, -27 },
  { 1293, 25, 29, 28, 2, -26 },
  { 1384, 19, 26, 19, -2, -26 },
  { 1446, 19, 26, 20, 1, -26 },
  { 1508, 19, 27, 19, 2, -27 },
  { 1573, 20, 26, 22, 1, -26 },
  { 1638, 18, 26, 17, 1, -26 },
  { 1697, 18, 26, 16, 1, -26 },
  { 1756, 21, 27, 23, 2, -27 },
  { 1827, 22, 26, 23, 1, -26 },
  { 1899, 14, 26, 11, -1, -26 },
  { 1945, 16, 33, 9, -6, -26 },
  { 2011, 21, 26, 19, 1, -26 },
  { 2080, 13, 26, 16, 1, -26 },
  { 2123, 28, 26, 28, 1, -26 },
  { 2214, 23, 26, 24, 1, -26 },
  { 2289, 21, 27, 24, 2, -27 },
  { 2360, 18, 26, 19, 1, -26 },
  { 2419, 21, 33, 24, 2, -27 },
  { 2506, 18, 26, 19, 1, -26 },
  { 2565, 18, 27, 17, 0, -27 },
  { 2626, 17, 26, 16, 3, -26 },
  { 2682, 21, 26, 22, 2, -26 },
  { 2751, 19, 26, 18, 3, -26 },
  { 2813, 28, 26, 29, 4, -26 },
  { 2904, 22, 26, 17, -2, -26 },
  { 2976, 17, 26, 17, 3, -26 },
  { 3032, 20, 26, 17, -1, -26 },
  { 3097, 14, 32, 11, -1, -26 },
  { 3153, 6, 26, 13, 4, -26 },
  { 3173, 14, 32, 11, -3, -26 },
  { 3229, 17, 16, 19, 1, -27 },
  { 3263, 14, 3, 13, -3, 3 },
  { 3269, 6, 6, 10, 5, -28 },
  { 3274, 18, 20, 19, 1, -20 },
  { 3319, 17, 28, 19, 1, -28 },
  { 3379, 15, 20, 15, 1, -20 },
  { 3417, 19, 28, 19, 1, -28 },
  { 3484, 15, 20, 17, 1, -20 },
  { 3522, 19, 37, 11, -4, -28 },
  { 3610, 19, 29, 19, 0, -20 },
  { 3679, 16, 28, 19, 1, -28 },
  { 3735, 8, 27, 9, 1, -27 },
  { 3762, 14, 36, 9, -5, -27 },
  { 3825, 17, 28, 17, 1, -28 },
  { 3885, 9, 28, 9, 1, -28 },
  { 3917, 26, 20, 29, 1, -20 },
  { 3982, 17, 20, 19, 1, -20 },
  { 4025, 16, 20, 19, 1, -20 },
  { 4065, 19, 29, 19, -1, -20 },
  { 4134, 18, 29, 19, 1, -20 },
  { 4200, 13, 20, 13, 1, -20 },
  { 4233, 14, 20, 14, 0, -20 },
  { 4268, 10, 24, 11, 2, -24 },
  { 4298, 16, 20, 19, 2, -20 },
  { 4338, 15, 20, 16, 2, -20 },
  { 4376, 24, 20, 24, 2, -20 },
  { 4436, 18, 20, 16, -1, -20 },
  { 4481, 20, 29, 16, -3, -20 },
  { 4554, 16, 20, 14, -1, -20 },
  { 4594, 14, 32, 13, 1, -26 },
  { 4650, 3, 37, 18, 8, -28 },
  { 4664, 14, 32, 13, -2, -26 },
  { 4720, 16, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Italic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC37PT7B_H_
