#ifndef _NOTOSANS_SEMICONDENSED_ITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x0C, 0x00, 0x3E, 0x1F, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0x01, 0xF1, 0xC1, 0x81, 0xF0, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xF7, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1D, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0xC0, 0x01, 0xC3, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0xE1, 0xF0, 0x80, 0x70, 0xF8, 0x70, 0x39, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xFC, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x0F, 0x03, 0xE7, 0xC0, 0x0F, 0x01,
  0xE1, 0xE0, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x03, 0xC0,
  0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC1, 0xE0,
  0x07, 0x81, 0xE0, 0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xC0, 0x78, 0xF0,
  0x60, 0xE0, 0x38, 0x78, 0xFE, 0x70, 0x3C, 0x78, 0xFF, 0xB8, 0x1C, 0x78,
  0xFF, 0xFE, 0x1E, 0x3C, 0xF0, 0xFF, 0xBE, 0x3C, 0xF0, 0x7B, 0xFF, 0x3C,
  0x78, 0x3D, 0xFE, 0x1E, 0x38, 0x1E, 0x3E, 0x1E, 0x3C, 0x0F, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x0F, 0x0E, 0x03, 0xC0, 0x0F, 0x0F, 0x01, 0xE0, 0x0F,
  0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x78, 0x07,
  0x80, 0xF0, 0x3C, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x1E, 0x03,
  0xC0, 0x1C, 0x0F, 0x01, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x07, 0x8F, 0x81,
  0xE0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x0F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x7C,
  0x7E, 0x3E, 0x03, 0xE7, 0xE0, 0xF8, 0x1E, 0x3E, 0x07, 0xC1, 0xF3, 0xE0,
  0x1F, 0x0F, 0x1E, 0x00, 0xFC, 0xF9, 0xF0, 0x03, 0xEF, 0x8F, 0x80, 0x0F,
  0xF8, 0x7C, 0x00, 0x7F, 0xC3, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0x00, 0xFF, 0xC0, 0xFE,
  0x3F, 0xDF, 0x03, 0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0x3F, 0xF0,
  0x1F, 0x80, 0x30, 0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C,
  0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x80, 0xF0, 0x07, 0x83,
  0xC0, 0x1F, 0x8E, 0x00, 0xFF, 0xB8, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xF8, 0x3C, 0x0F, 0x70, 0x00, 0x7D, 0xC0, 0x03,
  0xE7, 0x80, 0x1F, 0x0E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0x01,
  0xE0, 0x08, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x3F, 0xBE, 0xFE, 0x78, 0xF0, 0xF1, 0xC3,
  0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xE0, 0x0F, 0x80, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x30,
  0x03, 0xE0, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x20, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x03,
  0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x40, 0x01, 0xF8, 0x38, 0x01, 0xFC,
  0x1F, 0xCF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x02, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x3F, 0x80, 0x7C, 0xFF, 0xE0, 0x7D, 0xFF, 0xE0, 0x7B, 0xFF,
  0xF0, 0x7F, 0x81, 0xF0, 0xFE, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x80,
  0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0xFE, 0x1F, 0x01, 0xFE, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xBC, 0x0F, 0xFF,
  0x7C, 0x03, 0xFE, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xFB, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x0F,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xE0, 0x7E, 0x20, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0x80, 0xF0,
  0xF0, 0x0F, 0xFF, 0x03, 0x87, 0x80, 0xFF, 0xF8, 0x1C, 0x78, 0x0F, 0x83,
  0xC0, 0xE3, 0xC0, 0xF8, 0x1E, 0x07, 0x3C, 0x0F, 0x81, 0xE0, 0x39, 0xE0,
  0x78, 0x0F, 0x01, 0xCE, 0x07, 0x80, 0x78, 0x0E, 0xF0, 0x3C, 0x03, 0xC0,
  0xF7, 0x83, 0xC0, 0x3C, 0x07, 0xBC, 0x1E, 0x01, 0xE0, 0x3D, 0xC0, 0xF0,
  0x0F, 0x01, 0xCE, 0x07, 0x00, 0xF0, 0x1E, 0xF0, 0x38, 0x07, 0x80, 0xF7,
  0x81, 0xC0, 0x3C, 0x07, 0x3C, 0x1E, 0x03, 0xE0, 0x79, 0xE0, 0x70, 0x1F,
  0x03, 0x8F, 0x03, 0xC1, 0xF8, 0x3C, 0x78, 0x1F, 0x1D, 0xE7, 0xC3, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0E, 0x03, 0xFC, 0x3F, 0xC0, 0x78, 0x0F, 0xC0, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F,
  0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x7F, 0xE0, 0x1F, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x03,
  0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0x01, 0xC0, 0x1F, 0xC0, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x01, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0xF0, 0x07, 0xF8,
  0x07, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x1F, 0x00, 0x3F,
  0xF8, 0x78, 0x00, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xFE,
  0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x7E,
  0x00, 0x00, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0xDE, 0x00, 0x07, 0xFE, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x80, 0x7D, 0xE0, 0x01,
  0xF7, 0xC0, 0x3C, 0xF0, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x00, 0xF9, 0xE0,
  0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0x7C, 0xF8, 0x07, 0xCF,
  0x00, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x0F, 0x80,
  0x78, 0x3C, 0x0F, 0x87, 0xC0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x0F, 0x83, 0xC3, 0xE0,
  0xF8, 0x07, 0x81, 0xE1, 0xE0, 0x7C, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x78, 0x0F, 0x80, 0x78, 0x07, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xFC, 0x03,
  0xC0, 0x3E, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x0F,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xC0, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x00,
  0x1E, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xE0,
  0x00, 0xF8, 0x07, 0xFC, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x0F, 0x00, 0x7B,
  0xC0, 0x03, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0x0F, 0x1E, 0x00, 0x7C, 0x03,
  0xC7, 0x80, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x80, 0x3C, 0x7C, 0x01, 0xE0,
  0x1F, 0x0F, 0x00, 0xF8, 0x07, 0xC3, 0xC0, 0x3E, 0x01, 0xE0, 0xF8, 0x0F,
  0x00, 0x78, 0x1E, 0x03, 0xC0, 0x3E, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x7C, 0x03, 0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x03,
  0xC1, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x1E, 0x3E, 0x01, 0xE0,
  0x07, 0x8F, 0x00, 0x78, 0x01, 0xF3, 0xC0, 0x1E, 0x00, 0x3C, 0xF0, 0x0F,
  0x80, 0x0F, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x3C, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x01, 0xFE,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFE, 0x0F, 0x80, 0xFC, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x20,
  0x00, 0x7C, 0x0E, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00,
  0xFB, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xE0, 0x03, 0xE1, 0xE0, 0x03,
  0xF8, 0x00, 0xF8, 0x78, 0x01, 0xEE, 0x00, 0x7C, 0x1E, 0x00, 0x7B, 0x80,
  0x1F, 0x07, 0x80, 0x3C, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x3C, 0x03, 0xE0,
  0x78, 0x07, 0xCF, 0x00, 0xF8, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x0F,
  0x03, 0xE0, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0xF0, 0x7C,
  0x01, 0xE0, 0xF8, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x0F, 0x0F, 0x80, 0x1E,
  0x0F, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x03, 0xCF,
  0x80, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xE7,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x00, 0x7F, 0x87, 0x80, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0,
  0x7F, 0x7D, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x0E, 0xF0, 0x3F, 0x9F, 0x78, 0x0F,
  0xFF, 0x3C, 0x07, 0xFF, 0x1C, 0x01, 0xFE, 0x1E, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x3F, 0xC0, 0x1E, 0x3F, 0xF0, 0x0F, 0x3F, 0xF8, 0x0F,
  0xBE, 0xFE, 0x07, 0xB8, 0x1F, 0x03, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE1,
  0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xF0, 0x1F, 0x03, 0xDE, 0x3F, 0x83, 0xCF,
  0xFF, 0x81, 0xE3, 0xFF, 0x80, 0xF0, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFB, 0xE0, 0x7E,
  0x01, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0x03, 0xF8, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0x87, 0x80, 0x0F, 0xFC, 0xF8, 0x03, 0xFF, 0xEF, 0x80,
  0x7F, 0xBE, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7F,
  0x00, 0x7C, 0x0E, 0xF0, 0x07, 0xF3, 0xCF, 0x00, 0x3F, 0xFC, 0xF0, 0x03,
  0xFF, 0x1E, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xE3, 0xF0, 0x7C, 0x0F, 0x87,
  0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0xC7, 0xC7, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x81, 0xFC, 0x3C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE1, 0xE0, 0x07, 0xFE, 0x3C, 0x03, 0xFF, 0xE7,
  0x80, 0x7F, 0x7D, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07,
  0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xE0, 0x1F,
  0x03, 0xBC, 0x03, 0xF9, 0xFF, 0x80, 0x7F, 0xFD, 0xF0, 0x07, 0xFF, 0x3C,
  0x00, 0x7F, 0x87, 0x80, 0x00, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x0C, 0x00, 0x7E, 0x01, 0xE0, 0x3F, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC3, 0xFC, 0x03, 0xC7, 0xFE, 0x03, 0xDF, 0xFF, 0x07, 0xDF, 0x7F,
  0x07, 0xB8, 0x1F, 0x07, 0xF0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F,
  0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x1E, 0x01, 0xF8,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0xF8,
  0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF9, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xC3, 0xF8, 0x0F,
  0xF0, 0x07, 0x9F, 0xF8, 0x3F, 0xF0, 0x0E, 0x7F, 0xF8, 0xFF, 0xF0, 0x3D,
  0xFF, 0xF3, 0xFF, 0xE0, 0x7B, 0x81, 0xEF, 0x07, 0xE0, 0xFE, 0x03, 0xFC,
  0x07, 0xC1, 0xF8, 0x07, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE1, 0xFE,
  0x00, 0xF3, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x7B, 0xFF, 0xF0, 0x3D, 0xE0,
  0xF8, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xE0, 0x0F, 0x87, 0xE0,
  0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xDF, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x7F, 0x80, 0x07, 0x8F, 0xFC, 0x00,
  0x79, 0xFF, 0xC0, 0x0F, 0x3C, 0xFE, 0x00, 0xF7, 0x03, 0xE0, 0x0F, 0xE0,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xF7, 0x8F, 0xE0, 0x1F,
  0x7F, 0xFC, 0x01, 0xF3, 0xFF, 0x80, 0x1F, 0x1F, 0xE0, 0x01, 0xE0, 0x20,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x87, 0x80, 0x7F,
  0xE3, 0xC0, 0xFF, 0xF9, 0xE0, 0x7F, 0x7D, 0xE0, 0x7E, 0x07, 0xF0, 0x7E,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0x1F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x0E,
  0xF0, 0x3F, 0x9F, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x3C, 0x01, 0xFE,
  0x1E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xF0, 0x3C, 0xFF,
  0x03, 0x9F, 0xE0, 0x79, 0xFE, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xE3, 0xE0, 0xF8, 0x02, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xC0,
  0x1F, 0x87, 0xC3, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x02, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x60, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x02, 0x00, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x0E, 0xF0, 0x3F,
  0x3E, 0xF0, 0x1F, 0xFE, 0x78, 0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x1E, 0x00,
  0x10, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0,
  0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78,
  0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3C, 0x00, 0x7C, 0xF0,
  0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F,
  0x7C, 0x03, 0xF8, 0x03, 0xCF, 0x80, 0x7F, 0x00, 0xF9, 0xF0, 0x1F, 0xE0,
  0x1E, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x77, 0x80, 0xF0, 0xF8, 0x1E,
  0xF0, 0x3E, 0x1F, 0x03, 0xDE, 0x07, 0xC3, 0xE0, 0xF3, 0xC0, 0xF0, 0x7C,
  0x1E, 0x78, 0x3E, 0x0F, 0x87, 0x8F, 0x07, 0x81, 0xF0, 0xF1, 0xE1, 0xF0,
  0x3E, 0x3C, 0x3C, 0x3C, 0x07, 0xC7, 0x87, 0x8F, 0x80, 0xF8, 0xF0, 0xF1,
  0xF0, 0x0F, 0x3C, 0x1E, 0x3C, 0x01, 0xE7, 0x83, 0xCF, 0x80, 0x3D, 0xE0,
  0x79, 0xE0, 0x07, 0xBC, 0x0F, 0x7C, 0x00, 0xF7, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x3D, 0xE0, 0x03, 0xB8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x3C, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x01,
  0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xF8, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 40, 14, 1, -39 },
  { 66, 16, 14, 20, 6, -39 },
  { 94, 30, 39, 30, 1, -39 },
  { 241, 25, 44, 27, 1, -41 },
  { 379, 33, 40, 39, 4, -39 },
  { 544, 29, 40, 31, 1, -39 },
  { 689, 7, 14, 11, 6, -39 },
  { 702, 17, 48, 15, 2, -39 },
  { 804, 17, 48, 15, -4, -39 },
  { 906, 22, 22, 26, 5, -41 },
  { 967, 24, 26, 28, 3, -32 },
  { 1045, 10, 13, 13, -2, -6 },
  { 1062, 13, 5, 16, 1, -17 },
  { 1071, 6, 7, 13, 1, -6 },
  { 1077, 26, 39, 19, -3, -39 },
  { 1204, 24, 40, 27, 2, -39 },
  { 1324, 15, 39, 27, 7, -39 },
  { 1398, 27, 39, 27, -1, -39 },
  { 1530, 26, 40, 27, 0, -39 },
  { 1660, 26, 39, 27, 0, -39 },
  { 1787, 25, 40, 27, 1, -39 },
  { 1912, 24, 40, 27, 3, -39 },
  { 2032, 25, 39, 27, 3, -39 },
  { 2154, 26, 40, 27, 1, -39 },
  { 2284, 24, 40, 27, 2, -39 },
  { 2404, 11, 30, 13, 1, -29 },
  { 2446, 15, 36, 13, -3, -29 },
  { 2514, 24, 25, 28, 3, -32 },
  { 2589, 23, 14, 28, 3, -26 },
  { 2630, 24, 25, 28, 3, -32 },
  { 2705, 19, 40, 20, 3, -39 },
  { 2800, 37, 44, 41, 2, -39 },
  { 3004, 27, 39, 27, -3, -39 },
  { 3136, 28, 39, 29, 1, -39 },
  { 3273, 28, 40, 28, 3, -39 },
  { 3413, 30, 39, 32, 1, -39 },
  { 3560, 26, 39, 25, 1, -39 },
  { 3687, 26, 39, 23, 1, -39 },
  { 3814, 30, 40, 33, 3, -39 },
  { 3964, 32, 39, 33, 1, -39 },
  { 4120, 22, 39, 16, -2, -39 },
  { 4228, 22, 49, 13, -8, -39 },
  { 4363, 31, 39, 27, 1, -39 },
  { 4515, 19, 39, 23, 1, -39 },
  { 4608, 41, 39, 42, 1, -39 },
  { 4808, 34, 39, 34, 1, -39 },
  { 4974, 30, 40, 35, 3, -39 },
  { 5124, 27, 39, 27, 1, -39 },
  { 5256, 30, 48, 35, 3, -39 },
  { 5436, 27, 39, 28, 1, -39 },
  { 5568, 26, 40, 25, 0, -39 },
  { 5698, 23, 39, 24, 5, -39 },
  { 5811, 30, 40, 33, 3, -39 },
  { 5961, 27, 39, 27, 5, -39 },
  { 6093, 42, 39, 42, 5, -39 },
  { 6298, 33, 39, 25, -3, -39 },
  { 6459, 24, 39, 24, 5, -39 },
  { 6576, 28, 39, 25, -1, -39 },
  { 6713, 21, 48, 16, -1, -39 },
  { 6839, 9, 39, 19, 6, -39 },
  { 6883, 21, 48, 16, -4, -39 },
  { 7009, 24, 23, 27, 2, -39 },
  { 7078, 21, 3, 20, -5, 5 },
  { 7086, 8, 8, 14, 8, -41 },
  { 7094, 25, 30, 28, 2, -29 },
  { 7188, 25, 42, 28, 1, -41 },
  { 7320, 21, 30, 22, 2, -29 },
  { 7399, 28, 42, 28, 2, -41 },
  { 7546, 21, 30, 25, 2, -29 },
  { 7625, 28, 54, 15, -6, -41 },
  { 7814, 27, 42, 28, 0, -29 },
  { 7956, 24, 41, 28, 1, -41 },
  { 8079, 13, 40, 13, 1, -40 },
  { 8144, 21, 53, 13, -7, -40 },
  { 8284, 25, 41, 24, 1, -41 },
  { 8413, 13, 41, 13, 1, -41 },
  { 8480, 39, 29, 42, 1, -29 },
  { 8622, 25, 30, 28, 1, -30 },
  { 8716, 23, 29, 27, 2, -29 },
  { 8800, 28, 42, 28, -2, -29 },
  { 8947, 25, 42, 28, 2, -29 },
  { 9079, 20, 29, 19, 1, -29 },
  { 9152, 21, 30, 21, 0, -29 },
  { 9231, 16, 37, 16, 2, -36 },
  { 9305, 25, 30, 28, 2, -29 },
  { 9399, 22, 29, 23, 3, -29 },
  { 9479, 35, 29, 35, 3, -29 },
  { 9606, 27, 29, 23, -2, -29 },
  { 9704, 30, 42, 23, -5, -29 },
  { 9862, 22, 29, 21, -1, -29 },
  { 9942, 20, 48, 18, 1, -39 },
  { 10062, 4, 54, 26, 12, -41 },
  { 10089, 20, 48, 18, -2, -39 },
  { 10209, 24, 8, 28, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Italic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC54PT7B_H_
