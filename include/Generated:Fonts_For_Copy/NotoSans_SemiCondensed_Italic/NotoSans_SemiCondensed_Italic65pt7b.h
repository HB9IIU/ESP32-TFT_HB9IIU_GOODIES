#ifndef _NOTOSANS_SEMICONDENSED_ITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x3F,
  0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0xFC,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE7, 0x87, 0x80, 0x7E, 0x1E, 0x04, 0x01, 0xF0, 0x70, 0x00, 0x0F,
  0xC1, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xFC, 0x78,
  0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xF7, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1E, 0xFE, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x78, 0x3F, 0x08, 0x01, 0xE1, 0xF8,
  0x18, 0x07, 0x8F, 0xE0, 0x7C, 0x1C, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x01,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0xF8, 0x7F, 0x8F,
  0x80, 0xF8, 0xF8, 0x7F, 0xE7, 0xC0, 0x78, 0x78, 0x7F, 0xF9, 0xE0, 0x7C,
  0x7C, 0x7F, 0xFC, 0xF0, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E, 0x3C,
  0x0F, 0xBF, 0xFE, 0x3E, 0x3E, 0x07, 0xCF, 0xFE, 0x3E, 0x1E, 0x03, 0xE3,
  0xFE, 0x1F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x0F, 0x00, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x1F,
  0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x7C, 0x1F, 0x87, 0xE0, 0x1F, 0x87, 0xE0, 0xFC,
  0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C, 0x7E, 0x01, 0xF8, 0x1F, 0x8F, 0x80,
  0x1F, 0x83, 0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x7C, 0x00, 0x3F, 0x3F, 0x0F,
  0x80, 0x07, 0xFF, 0xC3, 0xF0, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x07, 0xFE,
  0x0F, 0xC0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFE, 0x07, 0xFB, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0x01,
  0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x04, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3F, 0x87, 0x80, 0x0F, 0xFD, 0xE0, 0x03, 0xFF, 0xF8, 0x3F,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF8,
  0x7F, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x3F,
  0x1E, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x0C, 0x03, 0xF0, 0x02, 0x00, 0x7C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x0C,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x38, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x8F,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0x7C, 0x7F, 0x9F, 0x9F, 0xE3, 0xF1, 0xF8, 0x7C, 0x1C, 0x0F, 0x81,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x80,
  0x00, 0x7F, 0x03, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x40, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0xFF, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x03,
  0xF7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x80, 0xFB, 0xF3, 0xFE, 0x0F, 0xFC,
  0x03, 0xF0, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0E, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0xC1, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xDF, 0x01, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xCF, 0xC0, 0x1F, 0xFC,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x38, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x3F, 0x03, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC3, 0xE0, 0x3F, 0x86, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x78, 0x1E,
  0x00, 0x3F, 0xFF, 0x03, 0xC1, 0xF0, 0x03, 0xFF, 0xF0, 0x1E, 0x0F, 0x00,
  0x7F, 0xFF, 0x80, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x07, 0x87, 0x80, 0x7E,
  0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x79, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xCF, 0x81, 0xF0, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x80, 0x3E, 0x01,
  0xF7, 0xC0, 0x78, 0x01, 0xF0, 0x0F, 0xBE, 0x07, 0xC0, 0x0F, 0x80, 0x79,
  0xF0, 0x3E, 0x00, 0x78, 0x03, 0xCF, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x78,
  0x0F, 0x00, 0x3E, 0x01, 0xF3, 0xC0, 0x78, 0x03, 0xF0, 0x0F, 0x1E, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0xF0, 0x1E, 0x01, 0xF8, 0x07, 0x87, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x3C, 0x07, 0xC0, 0xEF, 0x07, 0xC1, 0xE0, 0x3F, 0x0F,
  0x78, 0x7C, 0x0F, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x0F,
  0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0x7C, 0x00,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF0,
  0x03, 0xFE, 0x00, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0x80, 0x07, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x2E, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xFE, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xF0, 0x00,
  0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0xFC, 0x00,
  0x3F, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x7D, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x0F,
  0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x03,
  0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xF0, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xC0,
  0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x78, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x00, 0x7C, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x00,
  0xFC, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0x03,
  0xF3, 0xF0, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x0F, 0xC0,
  0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x3F, 0x00,
  0x0F, 0x8F, 0x80, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x3E, 0x00, 0x07, 0xDF,
  0x80, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC3, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFE, 0x01, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x7F, 0x80, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0xC0, 0x00, 0x7F, 0x81, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0xBC, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xC1, 0xF0,
  0x01, 0xF3, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x8F, 0x00, 0x3F, 0x01,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0x83, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0xF0, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x7C,
  0x01, 0xFF, 0xE1, 0xE0, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xFF, 0x3E, 0x03,
  0xFC, 0x3E, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x0F, 0x78,
  0x07, 0xF0, 0xFB, 0xE0, 0x1F, 0xFF, 0xCF, 0x80, 0x3F, 0xFE, 0x3E, 0x00,
  0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x7E, 0x3F, 0xF8, 0x01,
  0xF1, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0x7C, 0x3F, 0x80, 0xFF,
  0xC0, 0x7F, 0x03, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xC1, 0xFE, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x7C, 0x1F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x7D, 0xE0, 0xFF, 0x01,
  0xF7, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xC0, 0x3E, 0x1F, 0xFE, 0x00, 0xF8,
  0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x1E, 0x07, 0xF0,
  0x02, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x7F, 0x81, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFF, 0xF1,
  0xF0, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0x0F,
  0xBE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0xFB, 0xE0,
  0x03, 0xFF, 0xF9, 0xF0, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xF8, 0x7C,
  0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x81, 0xFE, 0x03, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x3F, 0xFF, 0x3E, 0x00, 0x7F, 0xFF, 0x3E,
  0x00, 0xFF, 0x0F, 0xBE, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x3F, 0xC0,
  0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x3F, 0xC3, 0xEF, 0x80,
  0x1F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0x1F, 0x80,
  0x03, 0xFE, 0x1F, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x80, 0x01, 0xFC, 0x00, 0xC0, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x83, 0xFC, 0x00, 0x7E, 0x3F, 0xF8, 0x01, 0xF1, 0xFF, 0xF0,
  0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0x7E, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x03,
  0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x21, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xDF, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xE1, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x8F,
  0xFF, 0xE0, 0x1E, 0x7C, 0x7F, 0x3F, 0x1F, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8,
  0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x81, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC1, 0xFF, 0x00,
  0x1F, 0x0F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0xF8, 0x0F,
  0xDF, 0xDF, 0xE0, 0x3E, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0x03, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xF8, 0x00, 0x1F, 0x0F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x07, 0xCF,
  0xFF, 0xE0, 0x03, 0xEF, 0x87, 0xF0, 0x03, 0xEF, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x07, 0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x3F,
  0x80, 0x3E, 0xF0, 0x7F, 0x80, 0x1F, 0x7F, 0xFF, 0x80, 0x0F, 0x9F, 0xFF,
  0x80, 0x0F, 0xC7, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0x00, 0x03, 0xF0, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0xE1, 0xE0, 0x0F, 0xFF, 0xCF, 0x80,
  0x7F, 0xFF, 0x3E, 0x03, 0xFC, 0x3E, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFE,
  0x00, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xFC, 0x0F, 0x80, 0x0F, 0xF0, 0x3E, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFF,
  0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0xFB, 0xE0, 0x1F, 0xFF, 0xCF, 0x80,
  0x3F, 0xFE, 0x7E, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0x87, 0xC0, 0x00,
  0x60, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x7F, 0x01, 0xF1, 0xFF, 0x01, 0xF3, 0xFF, 0x01, 0xF3, 0xFE,
  0x01, 0xE7, 0xFE, 0x03, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x83,
  0xF0, 0x3F, 0x00, 0x30, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x08, 0x00, 0x1F, 0x86, 0x00, 0x1F, 0x83, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0xC1, 0xF0, 0x01, 0xFE, 0x0F, 0xC0,
  0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x03, 0xF8, 0x3E, 0xF8, 0x0F, 0xFF, 0xE7,
  0xC0, 0x7F, 0xFE, 0x3C, 0x01, 0xFF, 0xE1, 0xE0, 0x07, 0xFC, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x7E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xF8, 0x03, 0xF3, 0xE0, 0x07,
  0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xDF, 0x00,
  0xFC, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x3E, 0x01, 0xF7, 0xC0, 0x7E, 0x1F,
  0x01, 0xF3, 0xE0, 0x3E, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x07, 0xC0, 0x78,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x0F,
  0xC0, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x0F, 0x87, 0x81,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x7C, 0xFC,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x03,
  0xEF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x41, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 47, 16, 1, -46 },
  { 95, 19, 16, 24, 7, -46 },
  { 133, 37, 46, 37, 1, -46 },
  { 346, 30, 53, 32, 1, -49 },
  { 545, 41, 48, 47, 4, -47 },
  { 791, 35, 48, 38, 1, -47 },
  { 1001, 8, 16, 14, 7, -46 },
  { 1017, 21, 57, 18, 2, -47 },
  { 1167, 21, 57, 18, -5, -47 },
  { 1317, 26, 27, 31, 7, -50 },
  { 1405, 28, 31, 34, 4, -38 },
  { 1514, 12, 15, 15, -3, -7 },
  { 1537, 16, 5, 19, 1, -20 },
  { 1547, 8, 9, 15, 1, -8 },
  { 1556, 31, 46, 23, -3, -46 },
  { 1735, 28, 48, 32, 3, -47 },
  { 1903, 19, 46, 32, 8, -46 },
  { 2013, 32, 47, 32, -1, -47 },
  { 2201, 30, 48, 32, 1, -47 },
  { 2381, 31, 47, 32, 0, -47 },
  { 2564, 31, 47, 32, 1, -46 },
  { 2747, 29, 48, 32, 3, -47 },
  { 2921, 29, 46, 32, 4, -46 },
  { 3088, 30, 48, 32, 2, -47 },
  { 3268, 29, 48, 32, 2, -47 },
  { 3442, 13, 36, 15, 1, -35 },
  { 3501, 17, 43, 15, -3, -35 },
  { 3593, 28, 31, 34, 4, -39 },
  { 3702, 28, 18, 34, 4, -32 },
  { 3765, 28, 31, 34, 4, -39 },
  { 3874, 23, 48, 25, 4, -47 },
  { 4012, 45, 53, 49, 3, -47 },
  { 4311, 33, 46, 33, -4, -46 },
  { 4501, 33, 46, 35, 2, -46 },
  { 4691, 33, 48, 33, 4, -47 },
  { 4889, 35, 46, 39, 2, -46 },
  { 5091, 31, 46, 30, 2, -46 },
  { 5270, 31, 46, 28, 2, -46 },
  { 5449, 36, 48, 40, 4, -47 },
  { 5665, 38, 46, 40, 2, -46 },
  { 5884, 26, 46, 20, -2, -46 },
  { 6034, 27, 58, 16, -10, -46 },
  { 6230, 36, 46, 33, 2, -46 },
  { 6437, 22, 46, 28, 2, -46 },
  { 6564, 49, 46, 50, 2, -46 },
  { 6846, 40, 46, 41, 2, -46 },
  { 7076, 36, 48, 42, 4, -47 },
  { 7292, 31, 46, 33, 2, -46 },
  { 7471, 36, 58, 42, 4, -47 },
  { 7732, 31, 46, 34, 2, -46 },
  { 7911, 31, 48, 30, 0, -47 },
  { 8097, 28, 46, 29, 6, -46 },
  { 8258, 36, 47, 39, 4, -46 },
  { 8470, 32, 46, 32, 6, -46 },
  { 8654, 50, 46, 51, 6, -46 },
  { 8942, 40, 46, 31, -4, -46 },
  { 9172, 29, 46, 29, 6, -46 },
  { 9339, 34, 46, 30, -1, -46 },
  { 9535, 25, 57, 19, -1, -47 },
  { 9714, 11, 46, 23, 7, -46 },
  { 9778, 25, 57, 19, -5, -47 },
  { 9957, 29, 28, 33, 2, -47 },
  { 10059, 25, 4, 23, -6, 6 },
  { 10072, 11, 11, 17, 9, -50 },
  { 10088, 30, 36, 33, 3, -35 },
  { 10223, 30, 50, 34, 1, -49 },
  { 10411, 24, 36, 26, 3, -35 },
  { 10519, 33, 50, 34, 3, -49 },
  { 10726, 25, 36, 30, 3, -35 },
  { 10839, 34, 66, 19, -8, -50 },
  { 11120, 32, 51, 34, 1, -35 },
  { 11324, 30, 49, 34, 1, -49 },
  { 11508, 16, 48, 15, 1, -48 },
  { 11604, 25, 64, 15, -8, -48 },
  { 11804, 30, 49, 29, 1, -49 },
  { 11988, 16, 49, 15, 1, -49 },
  { 12086, 47, 35, 51, 1, -35 },
  { 12292, 30, 36, 34, 1, -36 },
  { 12427, 27, 36, 33, 3, -35 },
  { 12549, 33, 50, 34, -2, -35 },
  { 12756, 30, 51, 34, 3, -35 },
  { 12948, 24, 35, 23, 1, -35 },
  { 13053, 25, 36, 25, 0, -35 },
  { 13166, 18, 44, 19, 3, -43 },
  { 13265, 29, 36, 34, 3, -35 },
  { 13396, 27, 35, 27, 3, -35 },
  { 13515, 41, 35, 43, 4, -35 },
  { 13695, 33, 35, 28, -3, -35 },
  { 13840, 37, 51, 27, -6, -35 },
  { 14076, 28, 35, 25, -2, -35 },
  { 14199, 25, 56, 22, 1, -46 },
  { 14374, 5, 65, 31, 14, -49 },
  { 14415, 24, 56, 22, -3, -46 },
  { 14583, 28, 8, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_Italic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC65PT7B_H_
