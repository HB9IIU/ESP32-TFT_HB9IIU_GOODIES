#ifndef _NOTOSANS_SEMICONDENSED_ITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0x80, 0x00,
  0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xF8, 0xE1, 0xE0, 0x3F, 0x0E, 0x04, 0x03, 0xE1, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3F, 0x38,
  0x00, 0x03, 0xFB, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE3, 0xF0,
  0x00, 0x0E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x01,
  0xC1, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x80, 0x3C, 0x3E,
  0x0E, 0x03, 0x8F, 0xE0, 0xFE, 0x3B, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0xF8, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xBF, 0x00,
  0x1F, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F,
  0x03, 0xE0, 0x07, 0x80, 0x78, 0x3E, 0x00, 0x7C, 0x07, 0xC1, 0xE0, 0x03,
  0xE0, 0x3C, 0x1F, 0x00, 0x1E, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0x0F, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0xF8, 0x7E, 0x3C, 0x07, 0x8F, 0x8F, 0xFD, 0xE0,
  0x7C, 0x78, 0xFF, 0xEF, 0x03, 0xC7, 0xCF, 0xDF, 0xFC, 0x3E, 0x7C, 0x78,
  0x3D, 0xF7, 0xE3, 0xC7, 0x81, 0xEF, 0xFE, 0x3E, 0x3C, 0x0F, 0x3F, 0xE1,
  0xE3, 0xC0, 0x78, 0xFE, 0x1E, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0xF0, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x0F, 0x83,
  0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x07, 0x81, 0xE0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xF0, 0x00, 0xF9, 0xF0,
  0x0F, 0x00, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x07, 0xE7,
  0xE0, 0x1F, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE3, 0xE0, 0x07, 0xC3, 0xE1, 0xF0,
  0x03, 0xF3, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0x7C,
  0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xFF, 0x80,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC,
  0x07, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x7E, 0x1E, 0x00, 0xFF, 0x9C,
  0x00, 0x7F, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFE, 0x03, 0x01, 0xEE, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF,
  0x00, 0x1F, 0x8F, 0x80, 0x3F, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x0C, 0x03, 0xE0, 0x04, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF7, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0x7C, 0xFF, 0x3E, 0x7F, 0x1F, 0x1E,
  0x1F, 0x0E, 0x0F, 0x82, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x60, 0x00, 0x7F, 0x03, 0xE0, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x30, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x80, 0x00, 0x7E, 0x0C, 0x00, 0x1F, 0xC0, 0xF0, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x04, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC7, 0xFE, 0x00, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xDF, 0x1F, 0xE0, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0x83,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xF1, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x3F, 0xC7,
  0xE0, 0x1F, 0xE0, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xCF,
  0x80, 0xFF, 0xE7, 0xC0, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x08, 0x03, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0x03, 0xF8, 0x30, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x01, 0xFF, 0x80, 0xF0, 0x78,
  0x01, 0xFF, 0xF0, 0x3C, 0x7C, 0x03, 0xFF, 0xF0, 0x1E, 0x3C, 0x03, 0xF8,
  0xF8, 0x0F, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x9E, 0x03, 0xE0, 0x3E, 0x03,
  0xCF, 0x01, 0xE0, 0x1E, 0x01, 0xEF, 0x01, 0xF0, 0x0F, 0x00, 0xF7, 0x80,
  0xF0, 0x07, 0x80, 0x7B, 0xC0, 0xF8, 0x07, 0xC0, 0x7B, 0xE0, 0x78, 0x03,
  0xC0, 0x3D, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0xF0, 0x3C, 0x00, 0xF0, 0x0F,
  0x78, 0x1E, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0x00, 0x78, 0x07, 0x9E, 0x07,
  0x80, 0x7C, 0x03, 0xCF, 0x03, 0xC0, 0x3E, 0x03, 0xC7, 0x81, 0xE0, 0x3F,
  0x01, 0xE3, 0xC0, 0xF0, 0x1F, 0x81, 0xE1, 0xE0, 0x7C, 0x1F, 0xC1, 0xF0,
  0xF0, 0x3F, 0x1E, 0xF1, 0xF0, 0x78, 0x0F, 0xFE, 0x7F, 0xF0, 0x3C, 0x07,
  0xFE, 0x3F, 0xF0, 0x1E, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x3F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xF8, 0x03, 0xF8,
  0x00, 0x40, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x10, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xFC,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0,
  0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x70, 0x07, 0xF0, 0x00, 0x08, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC7, 0xE0, 0x03, 0xFF,
  0xE3, 0xE0, 0x01, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x7F,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x41,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x00, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x1E, 0x3C,
  0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xC0,
  0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x80, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x03, 0xE0, 0x78, 0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xE1, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0x87, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xDF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x03, 0xFE, 0x00,
  0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0xF7, 0xC0, 0x01, 0xF0, 0x03, 0xDF, 0x00, 0x07, 0xC0, 0x1F, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x01, 0xF1, 0xE0,
  0x07, 0xC0, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0xF8, 0x00,
  0x3E, 0xF8, 0x03, 0xE0, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0x00,
  0x3E, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0xF8,
  0x03, 0xFC, 0x07, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0x80, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x30, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x08, 0x00,
  0x07, 0xE0, 0x70, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x3C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x03, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x3C, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0,
  0x03, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x01,
  0xEF, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0x80, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFE, 0x0F, 0x00, 0x7F, 0xF0, 0xF0, 0x0F, 0xFF, 0x9F, 0x01, 0xFF,
  0xFD, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7E, 0x07,
  0xBC, 0x03, 0xFF, 0xF3, 0xC0, 0x3F, 0xFE, 0x3C, 0x01, 0xFF, 0xC7, 0xC0,
  0x0F, 0xF0, 0x78, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0xFF, 0x00,
  0x3E, 0x3F, 0xF8, 0x03, 0xE7, 0xFF, 0xC0, 0x3E, 0xFF, 0xFE, 0x03, 0xFE,
  0x07, 0xE0, 0x3F, 0xC0, 0x3E, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07,
  0xF0, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7B, 0xFF,
  0xFC, 0x07, 0x9F, 0xFF, 0x80, 0xF8, 0xFF, 0xE0, 0x0F, 0x07, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01,
  0x03, 0xF0, 0x0C, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x3F, 0xF8, 0xF8, 0x01, 0xFF, 0xF9, 0xF0,
  0x07, 0xFF, 0xFB, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0x78,
  0x00, 0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0xF3, 0xE0, 0x01, 0xFF, 0xC7, 0xC0,
  0x01, 0xFE, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x01, 0xFC, 0x7E, 0x1F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x3F, 0x00, 0x70,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0xF0, 0x01, 0xFF, 0xE3, 0xC0, 0x1F, 0xFF, 0x9F, 0x00,
  0x7F, 0xFF, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF0, 0x07,
  0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0x7C,
  0x00, 0xFF, 0xF9, 0xF0, 0x01, 0xFF, 0xC7, 0xC0, 0x03, 0xFC, 0x3E, 0x00,
  0x01, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x1F, 0xFE, 0x03,
  0xE7, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0x81, 0xFE, 0x01,
  0xF0, 0x7F, 0x80, 0x3E, 0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0xF8,
  0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0x8F, 0xFE, 0x0F, 0xFF, 0x01, 0xF3, 0xFF,
  0xE3, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xBC, 0x0F, 0xBC,
  0x0F, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x3F, 0xF0, 0x0F, 0x8F,
  0xFF, 0x01, 0xF3, 0xFF, 0xF0, 0x3E, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xC1,
  0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x1F, 0x07, 0xF0, 0x03, 0xE0, 0xFE, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0xF1, 0xFF, 0xC0, 0x03, 0xE7,
  0xFF, 0xC0, 0x07, 0xDF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xE0,
  0x1F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFF,
  0x81, 0xF8, 0x01, 0xF7, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xC0, 0x0F, 0x8F,
  0xFF, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x3E, 0x03, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x7F, 0xF8, 0xF0,
  0x1F, 0xFF, 0x9F, 0x01, 0xFF, 0xFD, 0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7C, 0x01, 0xFE, 0x07,
  0xC0, 0x3F, 0xE0, 0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xF7, 0xC0, 0x3F, 0xFE,
  0x7C, 0x01, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0xF8, 0x00, 0x1C, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0x87, 0xF0, 0x3E, 0x3F, 0xC0, 0xF9, 0xFF, 0x03, 0xEF, 0xF8,
  0x0F, 0x7C, 0x00, 0x3D, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x03, 0x83, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x84, 0x00,
  0x3F, 0x0E, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x0F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x03,
  0xE0, 0x1F, 0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0xFF, 0xEF, 0x80, 0xFF, 0xF9,
  0xF0, 0x1F, 0xFE, 0x3C, 0x00, 0xFF, 0x07, 0x80, 0x03, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07,
  0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0x80, 0x0F, 0xBC, 0x00, 0xFE, 0x00, 0x7C, 0xF0,
  0x03, 0xF8, 0x01, 0xF3, 0xC0, 0x1E, 0xE0, 0x0F, 0x8F, 0x00, 0x7B, 0x80,
  0x3E, 0x3E, 0x03, 0xFE, 0x01, 0xF8, 0xF8, 0x0F, 0x7C, 0x07, 0xC3, 0xE0,
  0x3D, 0xF0, 0x1F, 0x0F, 0x81, 0xE7, 0xC0, 0xF8, 0x3E, 0x07, 0x9F, 0x03,
  0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x03, 0xE0, 0xF1, 0xF0, 0x7C, 0x0F, 0x87,
  0xC7, 0xC3, 0xF0, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0xF8, 0xF8, 0x3C, 0x3E,
  0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3E, 0x78,
  0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0xF3, 0xC0,
  0x0F, 0xBC, 0x03, 0xDF, 0x00, 0x3D, 0xF0, 0x0F, 0x7C, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE8, 0x00, 0x7F,
  0xE2, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 44, 15, 1, -43 },
  { 84, 18, 16, 22, 6, -43 },
  { 120, 34, 43, 34, 1, -43 },
  { 303, 28, 49, 30, 1, -46 },
  { 475, 37, 44, 44, 4, -43 },
  { 679, 33, 45, 35, 1, -44 },
  { 865, 8, 16, 12, 6, -43 },
  { 881, 19, 52, 17, 2, -43 },
  { 1005, 20, 52, 17, -5, -43 },
  { 1135, 24, 25, 29, 6, -46 },
  { 1210, 26, 29, 31, 4, -36 },
  { 1305, 12, 15, 14, -3, -7 },
  { 1328, 15, 4, 18, 1, -18 },
  { 1336, 7, 8, 14, 1, -7 },
  { 1343, 29, 43, 21, -3, -43 },
  { 1499, 26, 45, 30, 3, -44 },
  { 1646, 17, 43, 30, 8, -43 },
  { 1738, 30, 43, 30, -1, -43 },
  { 1900, 29, 44, 30, 0, -43 },
  { 2060, 29, 43, 30, 0, -43 },
  { 2216, 28, 44, 30, 1, -43 },
  { 2370, 27, 44, 30, 3, -43 },
  { 2519, 27, 43, 30, 4, -43 },
  { 2665, 28, 45, 30, 2, -44 },
  { 2823, 26, 44, 30, 2, -43 },
  { 2966, 12, 34, 14, 1, -33 },
  { 3017, 16, 41, 14, -3, -33 },
  { 3099, 26, 29, 31, 4, -36 },
  { 3194, 25, 16, 31, 4, -29 },
  { 3244, 26, 29, 31, 4, -36 },
  { 3339, 22, 44, 23, 3, -43 },
  { 3460, 41, 48, 45, 3, -43 },
  { 3706, 31, 43, 30, -4, -43 },
  { 3873, 30, 43, 32, 2, -43 },
  { 4035, 30, 44, 31, 4, -43 },
  { 4200, 32, 43, 36, 2, -43 },
  { 4372, 28, 43, 28, 2, -43 },
  { 4523, 28, 43, 26, 2, -43 },
  { 4674, 33, 44, 37, 4, -43 },
  { 4856, 35, 43, 36, 2, -43 },
  { 5045, 24, 43, 18, -2, -43 },
  { 5174, 25, 54, 15, -9, -43 },
  { 5343, 33, 43, 30, 2, -43 },
  { 5521, 20, 43, 26, 2, -43 },
  { 5629, 46, 43, 46, 1, -43 },
  { 5877, 38, 43, 38, 1, -43 },
  { 6082, 34, 45, 38, 3, -44 },
  { 6274, 29, 43, 30, 2, -43 },
  { 6430, 34, 54, 38, 3, -44 },
  { 6660, 29, 43, 31, 2, -43 },
  { 6816, 29, 44, 27, 0, -43 },
  { 6976, 27, 43, 27, 5, -43 },
  { 7122, 33, 44, 36, 4, -43 },
  { 7304, 30, 43, 30, 5, -43 },
  { 7466, 46, 43, 47, 6, -43 },
  { 7714, 36, 43, 28, -3, -43 },
  { 7908, 28, 43, 27, 5, -43 },
  { 8059, 31, 43, 28, -1, -43 },
  { 8226, 23, 53, 17, -1, -43 },
  { 8379, 11, 43, 21, 6, -43 },
  { 8439, 22, 53, 17, -4, -43 },
  { 8585, 27, 26, 30, 2, -43 },
  { 8673, 22, 4, 22, -5, 5 },
  { 8684, 9, 10, 16, 9, -46 },
  { 8696, 28, 34, 31, 2, -33 },
  { 8815, 28, 47, 31, 1, -46 },
  { 8980, 23, 34, 24, 2, -33 },
  { 9078, 31, 47, 31, 2, -46 },
  { 9261, 24, 34, 27, 2, -33 },
  { 9363, 31, 60, 17, -7, -46 },
  { 9596, 30, 47, 31, 0, -33 },
  { 9773, 27, 46, 31, 1, -46 },
  { 9929, 14, 44, 14, 1, -44 },
  { 10006, 23, 58, 14, -8, -44 },
  { 10173, 28, 46, 27, 1, -46 },
  { 10334, 15, 46, 14, 1, -46 },
  { 10421, 43, 33, 47, 1, -33 },
  { 10599, 27, 33, 31, 1, -33 },
  { 10711, 26, 34, 30, 2, -33 },
  { 10822, 31, 47, 31, -2, -33 },
  { 11005, 28, 47, 31, 2, -33 },
  { 11170, 22, 33, 21, 1, -33 },
  { 11261, 23, 34, 23, 0, -33 },
  { 11359, 17, 40, 18, 3, -39 },
  { 11444, 27, 33, 31, 3, -32 },
  { 11556, 25, 32, 25, 3, -32 },
  { 11656, 38, 32, 39, 4, -32 },
  { 11808, 30, 32, 26, -2, -32 },
  { 11928, 34, 46, 25, -6, -32 },
  { 12124, 25, 32, 23, -1, -32 },
  { 12224, 23, 52, 21, 1, -43 },
  { 12374, 4, 60, 29, 13, -46 },
  { 12404, 23, 52, 21, -3, -43 },
  { 12554, 26, 8, 31, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_Italic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC60PT7B_H_
