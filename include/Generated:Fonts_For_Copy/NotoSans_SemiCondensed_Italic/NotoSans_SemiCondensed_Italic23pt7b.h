#ifndef _NOTOSANS_SEMICONDENSED_ITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0x92, 0x64, 0xD9, 0x80, 0x03, 0x30, 0x11, 0x81, 0x88,
  0x0C, 0x43, 0xFF, 0x9F, 0xFC, 0x31, 0x01, 0x18, 0x08, 0xC0, 0xC4, 0x3F,
  0xFC, 0x23, 0x03, 0x10, 0x18, 0x80, 0x8C, 0x0C, 0x40, 0x01, 0x80, 0x20,
  0x3F, 0x8D, 0xB1, 0x20, 0x64, 0x06, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x16,
  0x02, 0x60, 0xCD, 0x1B, 0x1F, 0xC5, 0xF0, 0x08, 0x03, 0x00, 0x18, 0x09,
  0xF0, 0x44, 0xC3, 0x31, 0x18, 0xCC, 0x42, 0x33, 0x08, 0xD8, 0x22, 0x4E,
  0x9B, 0x6F, 0xDB, 0x36, 0x48, 0xC3, 0x23, 0x19, 0x8C, 0x46, 0x23, 0x19,
  0x98, 0x64, 0xC0, 0xF0, 0x03, 0x80, 0x3E, 0x03, 0x18, 0x18, 0xC0, 0x86,
  0x04, 0x60, 0x36, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0xDC, 0xCC, 0xC7, 0x6C,
  0x1E, 0x60, 0x63, 0x87, 0x0E, 0xEC, 0x3E, 0x70, 0x6D, 0xA5, 0x80, 0x0E,
  0x18, 0x61, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x81, 0x03, 0x00, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0xC0, 0x08, 0x01, 0x80, 0x41, 0x90, 0xFF, 0xC3, 0xF1, 0x40, 0xD8, 0x66,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xFF, 0xFC, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x33, 0x66, 0x4C, 0x7F, 0xF0, 0x7F, 0x80, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x07, 0x03, 0xE1,
  0x9C, 0xC3, 0x30, 0xD8, 0x36, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x1B, 0x06,
  0xC1, 0xB0, 0xCC, 0x31, 0xF8, 0x7C, 0x00, 0x1C, 0xF6, 0xF3, 0x18, 0x61,
  0x86, 0x18, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x03, 0x01, 0xF8, 0x63, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0x03, 0xF8, 0x63, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x1C, 0x0E, 0x02, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x67, 0x38, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x05, 0x01,
  0xE0, 0x6C, 0x19, 0x86, 0x30, 0xCC, 0x31, 0x8C, 0x33, 0x06, 0x7F, 0xF0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0xE1, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0F, 0xC1, 0xFC, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1D, 0x03,
  0x39, 0xC3, 0xF0, 0x01, 0xC1, 0xF0, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0xBC, 0x73, 0xB8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x31, 0xDC, 0x3E,
  0x00, 0x7F, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0x07,
  0x07, 0xF3, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0x7C, 0x1E, 0x0D, 0xC6,
  0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0x9C, 0x7E, 0x00, 0x06, 0x07, 0xE3,
  0x19, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x87, 0x61, 0xDF, 0xE3, 0xD8, 0x06,
  0x03, 0x00, 0xC0, 0x62, 0x70, 0xF8, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x19, 0xCE, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x61, 0x84, 0x30, 0x00, 0x40, 0x30, 0x38, 0x38, 0x38, 0x38, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x1C, 0x1C,
  0x3C, 0x3C, 0x0C, 0x00, 0x1C, 0x7F, 0x23, 0x03, 0x03, 0x03, 0x06, 0x0E,
  0x1C, 0x30, 0x30, 0x20, 0x40, 0x00, 0x60, 0xE0, 0xE0, 0x03, 0xF8, 0x0E,
  0x0C, 0x18, 0x06, 0x30, 0x02, 0x21, 0xF3, 0x63, 0x33, 0x46, 0x23, 0xC4,
  0x23, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x46, 0xCC, 0xC4, 0xCF, 0x78, 0xC2,
  0x10, 0x40, 0x00, 0x60, 0x00, 0x38, 0xE0, 0x0F, 0xC0, 0x01, 0xC0, 0x38,
  0x0D, 0x01, 0xA0, 0x64, 0x0C, 0x83, 0x18, 0x63, 0x18, 0x63, 0xFC, 0xFF,
  0x98, 0x36, 0x06, 0xC0, 0xF8, 0x1E, 0x03, 0x1F, 0xC3, 0x1C, 0xC1, 0x98,
  0x33, 0x06, 0x61, 0xCC, 0x73, 0xF8, 0x61, 0x8C, 0x19, 0x83, 0x30, 0x6C,
  0x0D, 0x83, 0x3F, 0xE7, 0xF0, 0x01, 0xC0, 0x7F, 0x0E, 0x21, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0x8E, 0x30, 0x73,
  0x03, 0x30, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x06, 0x60, 0x66,
  0x0E, 0xC0, 0xCC, 0x38, 0xFF, 0x0F, 0xC0, 0x1F, 0xE3, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE3, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0xFC, 0x7F, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0x84, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x61, 0xF7, 0x0F, 0xB0, 0x0D, 0x80, 0xCE, 0x06,
  0x30, 0x31, 0x81, 0x87, 0xF8, 0x1F, 0xC0, 0x18, 0x18, 0xC0, 0xCC, 0x06,
  0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xCF, 0xFE, 0x60, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xCC, 0x04, 0x60, 0x63, 0x03, 0x18, 0x18, 0x0F, 0x83, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC1, 0xF8, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x09, 0xC3, 0xE0, 0x18, 0x78, 0xC3, 0x0C, 0x30, 0x63, 0x03, 0x30,
  0x1B, 0x00, 0xF8, 0x0F, 0x80, 0x76, 0x03, 0x30, 0x19, 0x80, 0xC6, 0x0C,
  0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C,
  0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x3F, 0xFF, 0x1C, 0x07, 0x8E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0x41, 0xB1, 0xA0, 0xD8, 0x90, 0xC8, 0xCC,
  0x6C, 0x66, 0x66, 0x33, 0x33, 0x19, 0xB1, 0x88, 0xD9, 0x8C, 0x78, 0xC6,
  0x3C, 0x63, 0x1C, 0x31, 0x86, 0x18, 0x1C, 0x0C, 0x70, 0x23, 0xC1, 0x8D,
  0x06, 0x36, 0x18, 0xD8, 0x62, 0x61, 0x18, 0xCC, 0x63, 0x31, 0x8C, 0xC6,
  0x13, 0x10, 0x68, 0xC1, 0xE3, 0x03, 0x8C, 0x0E, 0x30, 0x38, 0x01, 0xC0,
  0x7F, 0x07, 0x0C, 0x30, 0x73, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x03, 0x30, 0x31, 0x83, 0x8F, 0xF8,
  0x1F, 0x00, 0x1F, 0xC3, 0x38, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x33,
  0x0E, 0x7F, 0x0F, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x01, 0xC0, 0x7F, 0x07, 0x0C, 0x30, 0x73, 0x01, 0xB8, 0x0D, 0x80, 0x6C,
  0x03, 0x60, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x03, 0x30, 0x31, 0x83,
  0x8F, 0xF8, 0x1F, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x1F,
  0xC3, 0x38, 0xC1, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x33, 0xFC, 0x7F, 0x0C,
  0xC1, 0x8C, 0x31, 0x8C, 0x31, 0x87, 0x30, 0x66, 0x0C, 0x03, 0x81, 0xFC,
  0x71, 0x1C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x20, 0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xC3, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x63,
  0x03, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x18, 0x19, 0x80,
  0xCC, 0x0C, 0x30, 0x61, 0xFE, 0x07, 0xE0, 0xC0, 0x78, 0x1F, 0x03, 0x60,
  0xEC, 0x19, 0x87, 0x10, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xC0, 0xC1, 0xF0, 0x70, 0x6C, 0x1C, 0x1B,
  0x0F, 0x0C, 0xC3, 0xC3, 0x30, 0x91, 0x8C, 0x64, 0x63, 0x11, 0x10, 0xCC,
  0x4C, 0x33, 0x13, 0x0D, 0x85, 0x81, 0x61, 0x60, 0x50, 0x50, 0x1C, 0x1C,
  0x06, 0x06, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x30, 0xC0, 0xC7, 0x01, 0x98,
  0x06, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x36, 0x00, 0xD8,
  0x06, 0x60, 0x31, 0x81, 0xC3, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xF0, 0x66,
  0x19, 0x8C, 0x66, 0x19, 0x86, 0xC0, 0xB0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x1F, 0xF0, 0x06, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xF0,
  0xF0, 0xC4, 0x66, 0x66, 0x62, 0x23, 0x33, 0x33, 0x11, 0x0F, 0x80, 0xC0,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E, 0x1F, 0x00, 0x0C, 0x03, 0x81, 0xE0,
  0x4C, 0x33, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0xFF, 0x80, 0xE6,
  0x63, 0x04, 0x23, 0xE8, 0xE7, 0x38, 0x66, 0x0D, 0xC1, 0xB0, 0x66, 0x0C,
  0xC1, 0x98, 0x73, 0x0C, 0x76, 0x87, 0xB0, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x88, 0x37, 0x85, 0x19, 0xC3, 0x38, 0x66, 0x0C, 0xC1, 0x90, 0x36,
  0x0C, 0xC1, 0x9C, 0x72, 0xDC, 0xDF, 0x00, 0x06, 0x0F, 0xCE, 0x4C, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0xC7, 0xE0, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x04, 0x61, 0xFC, 0x31, 0xC7, 0x0C, 0x60, 0xCE,
  0x0C, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x38, 0xC3, 0x0E, 0xD0, 0x7B, 0x00,
  0x06, 0x0F, 0x8C, 0x6C, 0x36, 0x1E, 0x3B, 0xF9, 0xE0, 0xC0, 0x60, 0x30,
  0x0C, 0xC7, 0xE0, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x18, 0x01, 0x00, 0x32,
  0x0F, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x80,
  0xF0, 0x04, 0x00, 0x02, 0x10, 0xFA, 0x18, 0xE3, 0x86, 0x30, 0x67, 0x06,
  0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x1C, 0x63, 0x87, 0x78, 0x3D, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x87, 0x0F, 0xE0, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x88, 0x37, 0x85, 0x19, 0xC3, 0x30, 0x66, 0x0C, 0xC3, 0x18,
  0x66, 0x0C, 0xC1, 0x98, 0x23, 0x0C, 0xC1, 0x80, 0x0C, 0x30, 0x80, 0x00,
  0x61, 0x8C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0xC0, 0x01, 0x80, 0xC0,
  0x40, 0x00, 0x00, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x07, 0x81, 0x00, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x82, 0x31, 0x86, 0x61, 0x98, 0x37, 0x06,
  0xC0, 0xF8, 0x1B, 0x06, 0x60, 0xC6, 0x18, 0xC3, 0x18, 0xC1, 0x80, 0x0C,
  0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0xC0,
  0x01, 0x82, 0x0F, 0xE7, 0x85, 0x34, 0x67, 0x0C, 0x33, 0x06, 0x19, 0x86,
  0x0C, 0xC3, 0x0C, 0x41, 0x86, 0x60, 0xC3, 0x30, 0xC1, 0x98, 0x60, 0x8C,
  0x30, 0xCC, 0x18, 0x60, 0x01, 0x83, 0xF8, 0x51, 0x9C, 0x33, 0x86, 0x60,
  0xCC, 0x31, 0x86, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xCC, 0x18, 0x04, 0x07,
  0xE3, 0x19, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x06, 0xC1, 0xB0, 0x6C, 0x31,
  0x9C, 0x7C, 0x00, 0x00, 0x40, 0xDE, 0x0A, 0x31, 0xC3, 0x1C, 0x31, 0x83,
  0x18, 0x31, 0x03, 0x30, 0x63, 0x06, 0x38, 0xE3, 0xDC, 0x27, 0x86, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x23, 0xE8, 0xC7, 0x38, 0x66,
  0x0D, 0xC1, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x1C, 0x77, 0x87, 0xB0,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x8F, 0xC5,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00,
  0x04, 0x1F, 0xCC, 0x4C, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x03, 0x01,
  0x99, 0xCF, 0xC0, 0x18, 0x20, 0xCF, 0xE3, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x19, 0x1C, 0x00, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x60, 0x98,
  0x6C, 0x1B, 0x06, 0xC3, 0xB1, 0xCE, 0xF1, 0xEC, 0xC1, 0xF0, 0x6C, 0x33,
  0x0C, 0x46, 0x11, 0x86, 0xC1, 0xB0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xC3,
  0x87, 0x87, 0x1B, 0x1E, 0x36, 0x3C, 0xCC, 0xD9, 0x99, 0xB3, 0x32, 0x6C,
  0x2C, 0xD8, 0x51, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x0E, 0x00, 0x18, 0x71,
  0x8C, 0x0D, 0x80, 0xD8, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xB0, 0x1B, 0x03,
  0x30, 0x61, 0x8E, 0x18, 0x18, 0x38, 0xC1, 0x82, 0x18, 0x10, 0xC0, 0xCC,
  0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x1F, 0xC0,
  0x60, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x07, 0xF3,
  0xFC, 0x03, 0x83, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x38, 0x70,
  0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x0E, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x06, 0x01, 0xC3, 0xC1, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x38, 0x18, 0x00, 0x30, 0x7F, 0x98, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 13, 16, 13, 0, -16 },
  { 45, 11, 18, 11, 0, -17 },
  { 70, 14, 17, 17, 2, -17 },
  { 100, 13, 17, 13, 0, -17 },
  { 128, 3, 6, 5, 2, -16 },
  { 131, 7, 20, 6, 1, -16 },
  { 149, 8, 20, 6, -2, -16 },
  { 169, 10, 10, 11, 2, -18 },
  { 182, 10, 11, 12, 1, -14 },
  { 196, 4, 6, 5, -1, -3 },
  { 199, 6, 2, 7, 0, -7 },
  { 201, 3, 3, 5, 0, -3 },
  { 203, 11, 16, 8, -1, -16 },
  { 225, 10, 17, 11, 1, -17 },
  { 247, 6, 16, 11, 3, -16 },
  { 259, 11, 17, 11, 0, -17 },
  { 283, 11, 17, 11, 0, -17 },
  { 307, 11, 16, 11, 0, -16 },
  { 329, 11, 16, 11, 0, -16 },
  { 351, 10, 17, 11, 1, -17 },
  { 373, 11, 16, 11, 1, -16 },
  { 395, 10, 17, 11, 1, -17 },
  { 417, 10, 17, 11, 1, -17 },
  { 439, 5, 13, 5, 0, -13 },
  { 448, 6, 16, 5, -1, -13 },
  { 460, 10, 11, 12, 1, -14 },
  { 474, 10, 6, 12, 1, -11 },
  { 482, 10, 11, 12, 1, -14 },
  { 496, 8, 17, 9, 1, -17 },
  { 513, 16, 18, 17, 1, -16 },
  { 549, 11, 16, 12, -1, -16 },
  { 571, 11, 16, 12, 1, -16 },
  { 593, 12, 17, 12, 1, -17 },
  { 619, 12, 16, 14, 1, -16 },
  { 643, 11, 16, 11, 1, -16 },
  { 665, 11, 16, 10, 1, -16 },
  { 687, 13, 17, 14, 1, -17 },
  { 715, 13, 16, 14, 1, -16 },
  { 741, 9, 16, 7, -1, -16 },
  { 759, 10, 20, 6, -4, -16 },
  { 784, 13, 16, 12, 1, -16 },
  { 810, 7, 16, 10, 1, -16 },
  { 824, 17, 16, 18, 1, -16 },
  { 858, 14, 16, 15, 1, -16 },
  { 886, 13, 17, 15, 1, -17 },
  { 914, 11, 16, 12, 1, -16 },
  { 936, 13, 21, 15, 1, -17 },
  { 971, 11, 16, 12, 1, -16 },
  { 993, 11, 17, 11, 0, -17 },
  { 1017, 10, 16, 10, 2, -16 },
  { 1037, 13, 16, 14, 1, -16 },
  { 1063, 11, 16, 11, 2, -16 },
  { 1085, 18, 16, 18, 2, -16 },
  { 1121, 14, 16, 11, -1, -16 },
  { 1149, 10, 16, 10, 2, -16 },
  { 1169, 12, 16, 11, 0, -16 },
  { 1193, 8, 20, 7, 0, -16 },
  { 1213, 4, 16, 8, 2, -16 },
  { 1221, 9, 20, 7, -2, -16 },
  { 1244, 10, 9, 12, 1, -16 },
  { 1256, 9, 2, 8, -2, 2 },
  { 1259, 4, 4, 6, 3, -18 },
  { 1261, 11, 13, 12, 1, -13 },
  { 1279, 11, 17, 12, 0, -17 },
  { 1303, 9, 13, 9, 1, -13 },
  { 1318, 12, 17, 12, 1, -17 },
  { 1344, 9, 13, 10, 1, -13 },
  { 1359, 12, 24, 7, -3, -18 },
  { 1395, 12, 19, 12, 0, -13 },
  { 1424, 11, 17, 12, 0, -17 },
  { 1448, 6, 17, 5, 0, -17 },
  { 1461, 9, 23, 5, -3, -17 },
  { 1487, 11, 17, 10, 0, -17 },
  { 1511, 6, 17, 5, 0, -17 },
  { 1524, 17, 13, 18, 0, -13 },
  { 1552, 11, 13, 12, 0, -13 },
  { 1570, 10, 13, 12, 1, -13 },
  { 1587, 12, 18, 12, -1, -13 },
  { 1614, 11, 19, 12, 1, -13 },
  { 1641, 9, 13, 8, 0, -13 },
  { 1656, 9, 13, 9, 0, -13 },
  { 1671, 7, 15, 7, 1, -15 },
  { 1685, 10, 12, 12, 1, -12 },
  { 1700, 10, 12, 10, 1, -12 },
  { 1715, 15, 12, 15, 1, -12 },
  { 1738, 12, 12, 10, -1, -12 },
  { 1756, 13, 18, 10, -2, -12 },
  { 1786, 10, 12, 9, -1, -12 },
  { 1801, 9, 20, 8, 0, -16 },
  { 1824, 2, 24, 11, 5, -18 },
  { 1830, 9, 20, 8, -1, -16 },
  { 1853, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Italic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC23PT7B_H_
