#ifndef _NOTOSANS_SEMICONDENSED_ITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73,
  0xB9, 0xDC, 0xEC, 0x66, 0x33, 0x1B, 0x0D, 0x8C, 0x01, 0xC6, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0xFF, 0xFE, 0x7F,
  0xFF, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x07,
  0xFF, 0xF3, 0xFF, 0xF8, 0x30, 0xC0, 0x18, 0xE0, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0xFC, 0x0F, 0xFC, 0x7A, 0x61, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xE6,
  0x01, 0xD0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x9C, 0x06,
  0x70, 0x19, 0xC0, 0x67, 0x21, 0x38, 0xFF, 0xC3, 0xFE, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x1F, 0x01, 0xC7, 0x70, 0x30, 0xC6, 0x0C,
  0x30, 0xC3, 0x86, 0x18, 0x60, 0xC3, 0x18, 0x38, 0xE7, 0x06, 0x18, 0xC0,
  0xC3, 0x30, 0x98, 0x6E, 0xFF, 0x19, 0x9B, 0xFF, 0x66, 0x37, 0xCC, 0xC6,
  0x03, 0x30, 0xC0, 0xE6, 0x18, 0x18, 0xC3, 0x06, 0x18, 0x61, 0xC7, 0x18,
  0x30, 0xE3, 0x0C, 0x0C, 0xE3, 0x81, 0xF8, 0xE0, 0x1E, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x0E, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x38,
  0x0E, 0x70, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x80, 0x79, 0x87,
  0x71, 0xC7, 0xE0, 0xEE, 0xC0, 0xEC, 0xC0, 0x7C, 0xC0, 0x78, 0xC0, 0x78,
  0xE1, 0xFC, 0xFF, 0xDC, 0x3F, 0x0E, 0x77, 0x76, 0x66, 0xCC, 0x01, 0xC0,
  0xE0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x18, 0x0C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x86,
  0x0F, 0x30, 0x7F, 0x0C, 0x7F, 0xE1, 0xEF, 0x1F, 0x01, 0xDC, 0x1C, 0x60,
  0x43, 0x80, 0x18, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0xE3, 0x9C, 0x71, 0x8E, 0x30, 0xFF, 0xFF, 0xF8,
  0x5F, 0xF0, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE3, 0x87, 0x07,
  0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01,
  0xD8, 0x06, 0x60, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x81,
  0x86, 0x0E, 0x1C, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x07, 0x87, 0x87, 0xCF,
  0xEF, 0x72, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x80, 0x03, 0xF8, 0x1F,
  0xF8, 0x38, 0x70, 0x20, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x38, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC6, 0x07, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0x60, 0x0F, 0xC0, 0x3B, 0x80, 0x66, 0x01, 0x8C,
  0x07, 0x38, 0x1C, 0x70, 0x30, 0xE0, 0xC1, 0x83, 0x83, 0x0E, 0x0E, 0x18,
  0x1C, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x3B, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x20, 0x78, 0xFF, 0xC3, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0xC3, 0xC0, 0x38,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x67, 0xC7, 0x7F, 0x3F, 0x39,
  0xE0, 0xEE, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x66, 0x07, 0x38,
  0x39, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0x3F, 0xFD, 0xFF, 0xF0, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0xE0, 0xE1, 0xC7, 0x07, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x0E,
  0x70, 0x1F, 0x80, 0x78, 0x07, 0xF8, 0x38, 0xE1, 0xC1, 0xCE, 0x03, 0x38,
  0x0C, 0xC0, 0x33, 0x80, 0xCE, 0x07, 0x3C, 0x38, 0x7F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x8E, 0x06, 0x38, 0x1C, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xE3, 0x07, 0x8F, 0x7E, 0x1F, 0xB8, 0x3C,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x20, 0xE0, 0xFF,
  0x03, 0xF8, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x1C, 0x78, 0xF0, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0C, 0x0C, 0x0E, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0x70, 0x02, 0x00, 0x00, 0x3F, 0x8F, 0xF9,
  0x87, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3C, 0x07,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x61, 0x83, 0xF1, 0xCC,
  0x1F, 0xC3, 0x30, 0xC3, 0x0D, 0x86, 0x1C, 0x36, 0x38, 0x61, 0xD8, 0xC1,
  0x86, 0x63, 0x06, 0x1B, 0x8C, 0x38, 0x6C, 0x30, 0xC3, 0x30, 0xC7, 0x0C,
  0xE3, 0xB6, 0x63, 0x8F, 0x9F, 0x06, 0x0C, 0x10, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x6E, 0x00,
  0xEE, 0x00, 0xCE, 0x01, 0xCE, 0x01, 0x8E, 0x03, 0x8E, 0x03, 0x8E, 0x07,
  0x06, 0x07, 0x06, 0x0F, 0xFE, 0x0F, 0xFE, 0x1C, 0x06, 0x1C, 0x06, 0x38,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0E, 0x1E, 0x0C, 0x0E, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C,
  0x0E, 0x18, 0x1C, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x30, 0x38, 0x30,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x38, 0xE0,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0x02, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x20, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0x87, 0x81, 0x81, 0xE1, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xC7, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x1C, 0x30, 0x1E, 0x18, 0x1E, 0x1C, 0x7E, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xC3, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x1F, 0xDC,
  0x0F, 0xCE, 0x07, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x0C,
  0x70, 0x0E, 0x1C, 0x07, 0x0F, 0x03, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x30, 0x06, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07,
  0x00, 0x07, 0xF0, 0xFE, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x06, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x0E, 0x03, 0x87, 0x03,
  0x83, 0x83, 0x81, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0xC0, 0x39,
  0xC0, 0x19, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0x9C, 0x01,
  0x8E, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x70, 0xE0, 0x30, 0x30, 0x18, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8,
  0x06, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x37, 0x0C, 0xC0, 0xEE, 0x19, 0x81,
  0x98, 0x73, 0x07, 0x30, 0xE6, 0x0C, 0xE1, 0xCC, 0x39, 0xC3, 0x18, 0x63,
  0x86, 0x31, 0xC6, 0x1C, 0x73, 0x1C, 0x38, 0xEE, 0x38, 0x61, 0xD8, 0x70,
  0xC3, 0xF0, 0xC1, 0x83, 0xC1, 0x87, 0x07, 0x87, 0x0E, 0x0E, 0x0E, 0x18,
  0x18, 0x1C, 0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80,
  0x61, 0xF8, 0x0C, 0x3B, 0x03, 0x87, 0x60, 0x70, 0xCE, 0x0C, 0x19, 0xC1,
  0x87, 0x18, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x06, 0x30, 0x60, 0xC6,
  0x1C, 0x1D, 0xC3, 0x81, 0xB8, 0x60, 0x37, 0x0C, 0x07, 0xC1, 0x80, 0xF8,
  0x70, 0x0F, 0x0E, 0x01, 0xE1, 0x80, 0x38, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xC3, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x37,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x3C, 0x0F,
  0x0F, 0x0F, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x38,
  0xF0, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0C,
  0x70, 0x38, 0xE1, 0xE1, 0xFF, 0x83, 0xFE, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0x80, 0x39,
  0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x0E, 0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x1F, 0xF8, 0x38, 0xF0, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x18, 0x1C, 0x70, 0x78, 0xE7, 0xE1, 0xFF, 0x83, 0xFC, 0x06,
  0x18, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xC1, 0x81, 0xC7, 0x03,
  0x8E, 0x03, 0x1C, 0x07, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x3C, 0x30, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC6, 0x0F, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38,
  0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01,
  0xC6, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x1C, 0x38, 0x0E, 0x1E, 0x1E, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xC0, 0x0F,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x70,
  0x30, 0xE0, 0xE1, 0xC1, 0x81, 0x87, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60,
  0x19, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x0E, 0xE0, 0x78,
  0x0E, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x1C, 0xE0, 0xF8, 0x18, 0xE0, 0xD8,
  0x38, 0xE1, 0xD8, 0x38, 0xE1, 0x98, 0x70, 0xE3, 0x98, 0x70, 0xE3, 0x18,
  0x60, 0xE3, 0x18, 0xE0, 0xE6, 0x18, 0xC0, 0xE6, 0x19, 0xC0, 0xEE, 0x1D,
  0xC0, 0xEC, 0x1D, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1B, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x39, 0xC0,
  0x0E, 0x38, 0x03, 0x83, 0x00, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC1,
  0xE0, 0x1C, 0x00, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x18, 0x1C, 0x60, 0xE1,
  0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x33, 0x00, 0xDC, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0xE0, 0xFE, 0x00, 0xE3, 0x86,
  0x18, 0x61, 0x87, 0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xE3, 0x8E, 0x18, 0x61,
  0x86, 0x1C, 0x70, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x81, 0x86, 0x06, 0x1C, 0x38, 0x30,
  0xC0, 0xC7, 0x01, 0x98, 0x06, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xCE, 0x67,
  0x30, 0x03, 0xCE, 0x1F, 0xD8, 0x79, 0xB0, 0xE1, 0xE3, 0x81, 0xCE, 0x03,
  0x9C, 0x06, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x1E, 0x1C, 0x7C, 0x3F, 0xB0, 0x3E, 0x60, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x3C, 0x1B,
  0xF8, 0x6C, 0xE3, 0xE1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0xDC,
  0x07, 0x70, 0x19, 0xC0, 0xE6, 0x03, 0xB8, 0x1C, 0xF0, 0x73, 0xC3, 0x8D,
  0xFC, 0x33, 0xE0, 0x03, 0xE0, 0xFF, 0x1E, 0x23, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x47, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0xCE, 0x0F, 0xEC, 0x1E,
  0x6C, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x18, 0x70, 0x18, 0x70, 0x38, 0x60,
  0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0x71,
  0xF0, 0x7F, 0x60, 0x3E, 0x60, 0x03, 0xC0, 0xFF, 0x1E, 0x73, 0x83, 0x38,
  0x37, 0x07, 0x70, 0xF6, 0x7E, 0xFF, 0x8F, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x47, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xE7, 0x07, 0xF6, 0x0F, 0x36, 0x1E, 0x1E, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x18, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x78, 0x38, 0xF8, 0x3F, 0xB0, 0x1F, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x81, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x3C, 0x1B, 0xF8, 0x7C, 0xE3, 0xE1, 0xCF, 0x07, 0x38, 0x18,
  0xE0, 0x63, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x1C,
  0xE0, 0x73, 0x81, 0xCC, 0x06, 0x30, 0x38, 0x06, 0x1C, 0x38, 0x20, 0x00,
  0x07, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x18, 0x30, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xFC, 0x0F,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x07, 0x18, 0x38, 0x61, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x80,
  0xDC, 0x03, 0x70, 0x1F, 0xC0, 0x7B, 0x01, 0xCE, 0x06, 0x38, 0x38, 0x60,
  0xE1, 0xC3, 0x87, 0x0C, 0x0C, 0x30, 0x38, 0x06, 0x1C, 0x38, 0x70, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x1C, 0x30, 0x60, 0x18, 0xF0, 0xF0, 0x6F, 0xE7, 0xE1, 0xF3, 0xBB,
  0xCF, 0x07, 0x87, 0x3C, 0x1C, 0x1C, 0xE0, 0xE0, 0x73, 0x83, 0x81, 0x8C,
  0x0E, 0x06, 0x70, 0x30, 0x39, 0xC0, 0xC0, 0xE7, 0x07, 0x03, 0x98, 0x1C,
  0x0C, 0xE0, 0x70, 0x33, 0x81, 0x81, 0xCE, 0x06, 0x07, 0x30, 0x38, 0x1C,
  0xC0, 0xE0, 0x60, 0x0C, 0x78, 0x1B, 0xF8, 0x3F, 0xF8, 0xF8, 0x71, 0xE0,
  0xE3, 0x81, 0xC7, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x61,
  0x80, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x18, 0xE0, 0x70, 0x03,
  0xC0, 0x7F, 0x87, 0x9E, 0x78, 0x73, 0x81, 0xB8, 0x0D, 0xC0, 0x6C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x70, 0x39, 0xC3, 0x8F,
  0xF8, 0x1F, 0x80, 0x06, 0x3C, 0x06, 0x7E, 0x06, 0xCE, 0x0F, 0x87, 0x0F,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C,
  0x0E, 0x18, 0x0E, 0x18, 0x0C, 0x3C, 0x1C, 0x3C, 0x38, 0x37, 0xF0, 0x33,
  0xE0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xCE, 0x1F, 0xD8, 0x79, 0xB1, 0xE1, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x1C, 0x7C, 0x3F, 0xB0, 0x3E, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x18, 0xE3, 0x7C, 0x7F, 0x9F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x00,
  0x07, 0xC1, 0xFF, 0x3C, 0x63, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x83, 0xCF, 0xF8,
  0xFF, 0x00, 0x0E, 0x06, 0x07, 0x07, 0xF7, 0xFC, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x1F, 0x0F,
  0x80, 0x1C, 0x0C, 0x60, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x63,
  0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x1C, 0xE0, 0x73,
  0x83, 0xCE, 0x1E, 0x1F, 0xD8, 0x3E, 0x60, 0xC0, 0x3E, 0x03, 0xB0, 0x19,
  0x81, 0xCC, 0x0C, 0x70, 0xE3, 0x86, 0x1C, 0x70, 0xE3, 0x07, 0x38, 0x39,
  0x81, 0xDC, 0x06, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0xC0,
  0xE0, 0x7C, 0x0E, 0x0E, 0xC1, 0xE0, 0xEC, 0x1E, 0x0C, 0xC3, 0xE1, 0xCC,
  0x36, 0x18, 0xC3, 0x63, 0x8C, 0x66, 0x38, 0xC6, 0x63, 0x0C, 0xC6, 0x70,
  0xCC, 0x66, 0x0D, 0xC6, 0xE0, 0xD8, 0x6C, 0x0D, 0x86, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x18, 0x1C, 0x38, 0x70,
  0x31, 0xC0, 0x67, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x76, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x18, 0x38, 0x38,
  0xE0, 0x70, 0x06, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0x38, 0x1C, 0x1C, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x03, 0x18, 0x00, 0xCE,
  0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0xF0, 0x1F, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x7C, 0x07, 0x00, 0xB8, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x00, 0xF0, 0x2E, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0xF8, 0x38, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x78, 0x1E,
  0x03, 0x80, 0x00, 0x7C, 0x0F, 0xF8, 0xF3, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 22, 8, 0, -22 },
  { 23, 9, 8, 12, 3, -22 },
  { 32, 17, 22, 17, 1, -22 },
  { 79, 14, 26, 15, 1, -24 },
  { 125, 19, 22, 23, 2, -22 },
  { 178, 16, 22, 18, 1, -22 },
  { 222, 4, 8, 6, 3, -22 },
  { 226, 10, 27, 9, 1, -22 },
  { 260, 10, 27, 9, -2, -22 },
  { 294, 13, 13, 15, 3, -24 },
  { 316, 13, 14, 16, 2, -18 },
  { 339, 6, 8, 7, -1, -4 },
  { 345, 7, 3, 9, 1, -10 },
  { 348, 3, 4, 7, 1, -4 },
  { 350, 14, 22, 11, -1, -22 },
  { 389, 14, 22, 15, 1, -22 },
  { 428, 9, 22, 15, 4, -22 },
  { 453, 15, 22, 15, 0, -22 },
  { 495, 15, 22, 15, 0, -22 },
  { 537, 15, 22, 15, 0, -22 },
  { 579, 14, 22, 15, 1, -22 },
  { 618, 13, 22, 15, 2, -22 },
  { 654, 14, 22, 15, 2, -22 },
  { 693, 14, 22, 15, 1, -22 },
  { 732, 14, 22, 15, 1, -22 },
  { 771, 7, 17, 7, 0, -17 },
  { 786, 9, 21, 7, -2, -17 },
  { 810, 13, 15, 16, 2, -19 },
  { 835, 13, 8, 16, 2, -15 },
  { 848, 13, 15, 16, 2, -19 },
  { 873, 11, 22, 12, 2, -22 },
  { 904, 22, 25, 23, 1, -22 },
  { 973, 16, 22, 16, -2, -22 },
  { 1017, 16, 22, 17, 1, -22 },
  { 1061, 16, 22, 16, 2, -22 },
  { 1105, 17, 22, 18, 1, -22 },
  { 1152, 15, 22, 14, 1, -22 },
  { 1194, 15, 22, 13, 1, -22 },
  { 1236, 17, 22, 19, 2, -22 },
  { 1283, 18, 22, 19, 1, -22 },
  { 1333, 12, 22, 9, -1, -22 },
  { 1366, 13, 28, 8, -5, -22 },
  { 1412, 17, 22, 16, 1, -22 },
  { 1459, 10, 22, 13, 1, -22 },
  { 1487, 23, 22, 24, 1, -22 },
  { 1551, 19, 22, 20, 1, -22 },
  { 1604, 17, 22, 20, 2, -22 },
  { 1651, 15, 22, 16, 1, -22 },
  { 1693, 17, 27, 20, 2, -22 },
  { 1751, 15, 22, 16, 1, -22 },
  { 1793, 15, 22, 14, 0, -22 },
  { 1835, 13, 22, 14, 3, -22 },
  { 1871, 17, 22, 19, 2, -22 },
  { 1918, 15, 22, 15, 3, -22 },
  { 1960, 24, 22, 24, 3, -22 },
  { 2026, 19, 22, 15, -2, -22 },
  { 2079, 14, 22, 14, 3, -22 },
  { 2118, 17, 22, 14, -1, -22 },
  { 2165, 12, 27, 9, -1, -22 },
  { 2206, 6, 22, 11, 3, -22 },
  { 2223, 12, 27, 9, -2, -22 },
  { 2264, 14, 13, 16, 1, -22 },
  { 2287, 12, 2, 11, -3, 3 },
  { 2290, 4, 5, 8, 5, -24 },
  { 2293, 15, 17, 16, 1, -17 },
  { 2325, 14, 24, 16, 1, -24 },
  { 2367, 12, 17, 13, 1, -17 },
  { 2393, 16, 24, 16, 1, -24 },
  { 2441, 12, 17, 14, 1, -17 },
  { 2467, 17, 31, 9, -4, -24 },
  { 2533, 16, 24, 16, 0, -17 },
  { 2581, 14, 24, 16, 1, -24 },
  { 2623, 7, 23, 7, 1, -23 },
  { 2644, 12, 30, 7, -4, -23 },
  { 2689, 14, 24, 14, 1, -24 },
  { 2731, 7, 24, 7, 1, -24 },
  { 2752, 22, 17, 24, 1, -17 },
  { 2799, 15, 17, 16, 0, -17 },
  { 2831, 13, 17, 16, 1, -17 },
  { 2859, 16, 24, 16, -1, -17 },
  { 2907, 15, 24, 16, 1, -17 },
  { 2952, 11, 17, 11, 1, -17 },
  { 2976, 12, 17, 12, 0, -17 },
  { 3002, 9, 20, 9, 1, -20 },
  { 3025, 14, 17, 16, 1, -17 },
  { 3055, 13, 17, 13, 2, -17 },
  { 3083, 20, 17, 20, 2, -17 },
  { 3126, 15, 17, 13, -1, -17 },
  { 3158, 18, 24, 13, -3, -17 },
  { 3212, 13, 17, 12, -1, -17 },
  { 3240, 12, 27, 11, 0, -22 },
  { 3281, 2, 31, 15, 7, -24 },
  { 3289, 11, 27, 11, -1, -22 },
  { 3327, 13, 4, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_Italic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC31PT7B_H_
