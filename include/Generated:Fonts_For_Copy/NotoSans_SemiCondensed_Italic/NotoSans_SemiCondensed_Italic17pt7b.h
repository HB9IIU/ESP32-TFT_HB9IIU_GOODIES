#ifndef _NOTOSANS_SEMICONDENSED_ITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x62, 0x10, 0x8C, 0x40, 0x11, 0x80, 0xDE, 0xA5, 0x20,
  0x0C, 0x82, 0x60, 0x90, 0xFF, 0x51, 0x04, 0x81, 0x23, 0xFE, 0x24, 0x09,
  0x02, 0x41, 0x30, 0x04, 0x04, 0x1F, 0x24, 0x28, 0x38, 0x18, 0x0E, 0x0A,
  0x12, 0x96, 0xFC, 0x10, 0x20, 0x38, 0xC9, 0x11, 0x24, 0x45, 0x89, 0xA1,
  0x2B, 0xBF, 0x48, 0x53, 0x12, 0x66, 0x48, 0x89, 0x21, 0xC0, 0x0E, 0x04,
  0xC1, 0x30, 0x48, 0x16, 0x06, 0x02, 0xCD, 0x12, 0xC7, 0x30, 0xCC, 0x71,
  0xE6, 0xFA, 0x19, 0x88, 0x84, 0x62, 0x10, 0x84, 0x21, 0x08, 0x41, 0x00,
  0x10, 0xC2, 0x10, 0x84, 0x23, 0x18, 0x8C, 0x46, 0x22, 0x00, 0x10, 0x23,
  0x41, 0xF7, 0x1B, 0x12, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0x2D, 0x60, 0xF8, 0x70, 0x01, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x40, 0xC0, 0x3C, 0x4D, 0x8A, 0x1C, 0x38, 0x61, 0xC3, 0x85,
  0x1B, 0x23, 0x80, 0x1B, 0xF4, 0x21, 0x18, 0xC4, 0x23, 0x18, 0xC0, 0x1E,
  0x23, 0x01, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x3E,
  0x23, 0x01, 0x03, 0x02, 0x1C, 0x2C, 0x06, 0x02, 0x06, 0x84, 0xF8, 0x03,
  0x05, 0x0F, 0x0A, 0x12, 0x32, 0x66, 0x46, 0xFF, 0x04, 0x0C, 0x0C, 0x1F,
  0x10, 0x30, 0x20, 0x20, 0x3E, 0x06, 0x02, 0x02, 0x02, 0x86, 0xF8, 0x1E,
  0x61, 0x82, 0x05, 0x9F, 0xB1, 0xC3, 0x85, 0x0B, 0x33, 0xC0, 0x7F, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0x1F, 0x31,
  0x31, 0x31, 0x12, 0x1C, 0x36, 0x42, 0x42, 0xC2, 0x46, 0x7C, 0x1E, 0x33,
  0x21, 0x61, 0x63, 0x63, 0x3F, 0x12, 0x02, 0x04, 0x0C, 0xF8, 0x32, 0x00,
  0x00, 0x0C, 0xC0, 0x18, 0x80, 0x00, 0x00, 0x04, 0x62, 0x30, 0x02, 0x1C,
  0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60,
  0x30, 0x67, 0x38, 0x40, 0x79, 0x30, 0x43, 0x18, 0xC6, 0x10, 0x40, 0x0C,
  0x30, 0x0F, 0xC2, 0x0C, 0x80, 0xA3, 0xD4, 0x93, 0x22, 0x64, 0x4C, 0x99,
  0x92, 0x53, 0xBA, 0x00, 0x20, 0x07, 0xF0, 0x10, 0x00, 0x03, 0x02, 0x81,
  0x41, 0xA0, 0x90, 0xC8, 0x44, 0x7E, 0x21, 0x30, 0x90, 0x78, 0x30, 0x1F,
  0x08, 0xCC, 0x26, 0x32, 0x11, 0xF0, 0x8C, 0xC2, 0x61, 0x21, 0x91, 0x9F,
  0x80, 0x1F, 0x98, 0x98, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x8F, 0x80, 0x1F, 0x04, 0x63, 0x08, 0xC3, 0x20, 0xC8, 0x32, 0x09,
  0x82, 0x61, 0x90, 0xC4, 0x63, 0xF0, 0x1F, 0x88, 0x0C, 0x06, 0x02, 0x01,
  0xF0, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x1F, 0x80, 0x1F, 0x88, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0xF8, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x00, 0x1F, 0x98,
  0x58, 0x0C, 0x0C, 0x06, 0x07, 0x1D, 0x82, 0xC1, 0x61, 0x98, 0xC7, 0xC0,
  0x10, 0x62, 0x08, 0xC1, 0x18, 0x62, 0x0C, 0x7F, 0x08, 0x23, 0x0C, 0x61,
  0x88, 0x21, 0x04, 0x61, 0x80, 0x1E, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x60, 0xC7, 0xC0, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x10, 0x20, 0x41, 0x82, 0x3C, 0x00, 0x10, 0xC4, 0x63, 0x30, 0xD8, 0x2C,
  0x0E, 0x03, 0xC1, 0x90, 0x64, 0x11, 0x84, 0x23, 0x0C, 0x10, 0x43, 0x0C,
  0x20, 0x82, 0x18, 0x61, 0x04, 0x3F, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x70,
  0xE2, 0x85, 0x16, 0x68, 0xB2, 0xCD, 0xA6, 0x65, 0x22, 0x31, 0x11, 0x89,
  0x88, 0xC0, 0x18, 0x63, 0x0C, 0xE1, 0x1E, 0x22, 0x44, 0x49, 0x89, 0xB3,
  0x34, 0x62, 0x88, 0x51, 0x0E, 0x60, 0xC0, 0x1F, 0x18, 0xD8, 0x28, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE1, 0x99, 0x8F, 0x80, 0x1F, 0x08, 0x8C,
  0x66, 0x32, 0x11, 0x18, 0xF8, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x00, 0x1F,
  0x18, 0xD8, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE1, 0x99, 0x8F,
  0x80, 0xC0, 0x20, 0x18, 0x1F, 0x08, 0xCC, 0x66, 0x32, 0x11, 0x18, 0xF0,
  0xC8, 0x66, 0x23, 0x10, 0x98, 0x60, 0x1F, 0x31, 0x20, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0x7F, 0x98, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x20, 0xC8, 0x26, 0x19, 0x86, 0x41,
  0x90, 0x4C, 0x13, 0x0C, 0xC3, 0x30, 0x8C, 0x61, 0xF0, 0x83, 0x82, 0x86,
  0x84, 0x8C, 0x88, 0x98, 0x90, 0xF0, 0xE0, 0xE0, 0xC0, 0x86, 0x1C, 0x31,
  0xA3, 0x8D, 0x14, 0x49, 0xA6, 0x49, 0x22, 0x4B, 0x14, 0x50, 0xA2, 0x87,
  0x1C, 0x30, 0xC1, 0x86, 0x00, 0x18, 0xC6, 0x20, 0x90, 0x2C, 0x0E, 0x01,
  0x00, 0xC0, 0x78, 0x12, 0x08, 0x86, 0x33, 0x0C, 0x87, 0x0A, 0x36, 0xCD,
  0x0E, 0x18, 0x20, 0x40, 0x83, 0x06, 0x00, 0x3F, 0x81, 0x80, 0x80, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x9F, 0x80, 0x1C, 0x43, 0x08,
  0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x0E, 0x00, 0x92, 0x6C, 0x92,
  0x49, 0xB0, 0x1C, 0x10, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30,
  0x8E, 0x00, 0x08, 0x1C, 0x14, 0x36, 0x22, 0x63, 0xC1, 0x7F, 0xFC, 0xCC,
  0x80, 0x3B, 0x66, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0x8C, 0xFC, 0x10, 0x10,
  0x10, 0x30, 0x2F, 0x33, 0x21, 0x61, 0x61, 0x43, 0x42, 0x66, 0xFC, 0x3D,
  0x8C, 0x30, 0x82, 0x08, 0x32, 0x78, 0x01, 0x01, 0x03, 0x03, 0x3A, 0x66,
  0xC6, 0xC6, 0x86, 0x84, 0x8C, 0x9C, 0xFC, 0x3D, 0x9C, 0x63, 0xF2, 0x08,
  0x32, 0x78, 0x03, 0x83, 0x01, 0x00, 0x81, 0xF0, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0xE0, 0x00, 0x1F, 0x99,
  0x98, 0xCC, 0x64, 0x32, 0x11, 0x18, 0x9C, 0x7E, 0x03, 0x01, 0x11, 0x8F,
  0x80, 0x10, 0x10, 0x10, 0x30, 0x2F, 0x33, 0x21, 0x63, 0x63, 0x42, 0x42,
  0x42, 0xC6, 0x11, 0x00, 0x32, 0x26, 0x64, 0x44, 0xC0, 0x04, 0x10, 0x00,
  0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0xC0, 0x10, 0x10,
  0x10, 0x30, 0x33, 0x26, 0x2C, 0x78, 0x78, 0x68, 0x4C, 0x44, 0xC6, 0x11,
  0x13, 0x32, 0x26, 0x64, 0x44, 0xC0, 0x2E, 0x73, 0x39, 0x23, 0x16, 0x31,
  0x62, 0x14, 0x23, 0x42, 0x34, 0x62, 0xC6, 0x20, 0x2F, 0x33, 0x23, 0x63,
  0x63, 0x62, 0x42, 0x46, 0xC6, 0x3C, 0xCF, 0x1C, 0x38, 0x70, 0xE1, 0x66,
  0x78, 0x17, 0x8C, 0x44, 0x26, 0x13, 0x09, 0x0C, 0x84, 0x66, 0x7E, 0x30,
  0x10, 0x08, 0x0C, 0x00, 0x3F, 0x66, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0x9C,
  0xFC, 0x0C, 0x08, 0x08, 0x18, 0x2E, 0x60, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC0, 0x3E, 0xC1, 0x83, 0x03, 0x81, 0x03, 0x44, 0xF8, 0x23, 0x3E, 0x84,
  0x63, 0x10, 0x84, 0x38, 0x62, 0x85, 0x0E, 0x3C, 0x50, 0xA3, 0x4E, 0xFC,
  0x87, 0x0A, 0x36, 0x4D, 0x9A, 0x3C, 0x70, 0x60, 0x8C, 0x71, 0x8A, 0x73,
  0x4A, 0x49, 0x59, 0x4A, 0x29, 0x47, 0x38, 0xC6, 0x00, 0x31, 0x89, 0x87,
  0x81, 0x80, 0x80, 0xE0, 0xD0, 0xCC, 0xC6, 0x00, 0x10, 0xC4, 0x21, 0x98,
  0x64, 0x1B, 0x02, 0x80, 0xE0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0xE0,
  0x00, 0x3E, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x60, 0xF8, 0x0E, 0x10, 0x60,
  0x81, 0x02, 0x18, 0x70, 0x20, 0x40, 0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF,
  0xFF, 0x80, 0x18, 0x18, 0x30, 0x40, 0x81, 0x02, 0x86, 0x18, 0x20, 0x41,
  0x82, 0x1C, 0x30, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 6, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 8, 14, 8, 0, -13 },
  { 41, 11, 12, 12, 1, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 4, 4, 2, -12 },
  { 74, 5, 15, 5, 1, -12 },
  { 84, 5, 15, 5, -1, -12 },
  { 94, 7, 7, 8, 2, -13 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 3, 4, 4, -1, -2 },
  { 110, 5, 1, 5, 0, -5 },
  { 111, 2, 2, 4, 0, -2 },
  { 112, 8, 12, 6, -1, -12 },
  { 124, 7, 12, 8, 1, -12 },
  { 135, 5, 12, 8, 2, -12 },
  { 143, 8, 12, 8, 0, -12 },
  { 155, 8, 12, 8, 0, -12 },
  { 167, 8, 12, 8, 0, -12 },
  { 179, 8, 12, 8, 0, -12 },
  { 191, 7, 12, 8, 1, -12 },
  { 202, 8, 12, 8, 1, -12 },
  { 214, 8, 12, 8, 0, -12 },
  { 226, 8, 12, 8, 0, -12 },
  { 238, 4, 9, 4, 0, -9 },
  { 243, 5, 11, 4, -1, -9 },
  { 250, 7, 8, 9, 1, -10 },
  { 257, 7, 4, 9, 1, -8 },
  { 261, 7, 8, 9, 1, -10 },
  { 268, 6, 12, 6, 1, -12 },
  { 277, 11, 14, 13, 1, -12 },
  { 297, 9, 12, 9, -1, -12 },
  { 311, 9, 12, 9, 0, -12 },
  { 325, 9, 12, 9, 1, -12 },
  { 339, 10, 12, 10, 0, -12 },
  { 354, 9, 12, 8, 0, -12 },
  { 368, 9, 12, 7, 0, -12 },
  { 382, 9, 12, 10, 1, -12 },
  { 396, 11, 12, 10, 0, -12 },
  { 413, 7, 12, 5, -1, -12 },
  { 424, 7, 15, 4, -3, -12 },
  { 438, 10, 12, 9, 0, -12 },
  { 453, 6, 12, 7, 0, -12 },
  { 462, 13, 12, 13, 0, -12 },
  { 482, 11, 12, 11, 0, -12 },
  { 499, 9, 12, 11, 1, -12 },
  { 513, 9, 12, 9, 0, -12 },
  { 527, 9, 15, 11, 1, -12 },
  { 544, 9, 12, 9, 0, -12 },
  { 558, 8, 12, 8, 0, -12 },
  { 570, 8, 12, 8, 1, -12 },
  { 582, 10, 12, 10, 1, -12 },
  { 597, 8, 12, 8, 2, -12 },
  { 609, 13, 12, 13, 2, -12 },
  { 629, 10, 12, 8, -1, -12 },
  { 644, 7, 12, 8, 2, -12 },
  { 655, 9, 12, 8, 0, -12 },
  { 669, 6, 15, 5, 0, -12 },
  { 681, 3, 12, 6, 2, -12 },
  { 686, 6, 15, 5, -1, -12 },
  { 698, 8, 7, 9, 0, -12 },
  { 705, 7, 2, 6, -2, 1 },
  { 707, 3, 3, 5, 2, -13 },
  { 709, 8, 9, 9, 1, -9 },
  { 718, 8, 13, 9, 0, -13 },
  { 731, 6, 9, 7, 1, -9 },
  { 738, 8, 13, 9, 1, -13 },
  { 751, 6, 9, 8, 1, -9 },
  { 758, 9, 17, 5, -2, -13 },
  { 778, 9, 13, 9, 0, -9 },
  { 793, 8, 13, 9, 0, -13 },
  { 806, 4, 13, 4, 0, -13 },
  { 813, 6, 17, 4, -2, -13 },
  { 826, 8, 13, 8, 0, -13 },
  { 839, 4, 13, 4, 0, -13 },
  { 846, 12, 9, 13, 0, -9 },
  { 860, 8, 9, 9, 0, -9 },
  { 869, 7, 9, 9, 1, -9 },
  { 877, 9, 13, 9, -1, -9 },
  { 892, 8, 13, 9, 1, -9 },
  { 905, 7, 9, 6, 0, -9 },
  { 913, 7, 9, 7, 0, -9 },
  { 921, 5, 11, 5, 1, -11 },
  { 928, 7, 9, 9, 1, -9 },
  { 936, 7, 9, 7, 1, -9 },
  { 944, 11, 9, 11, 1, -9 },
  { 957, 9, 9, 7, -1, -9 },
  { 968, 10, 13, 7, -2, -9 },
  { 985, 7, 9, 7, 0, -9 },
  { 993, 7, 15, 6, 0, -12 },
  { 1007, 1, 17, 8, 4, -13 },
  { 1010, 7, 15, 6, -1, -12 },
  { 1024, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Italic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC17PT7B_H_
