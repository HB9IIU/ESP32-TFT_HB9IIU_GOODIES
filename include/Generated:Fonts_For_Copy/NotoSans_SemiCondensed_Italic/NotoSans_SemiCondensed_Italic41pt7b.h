#ifndef _NOTOSANS_SEMICONDENSED_ITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x83, 0xC0,
  0xF0, 0x00, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x70,
  0xE6, 0x1C, 0x61, 0xCE, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x70, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x0C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0,
  0x01, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0C, 0x03, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x80, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xE6, 0xF0, 0x79, 0xC2,
  0x0E, 0x30, 0x03, 0xC6, 0x00, 0x78, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00,
  0x1E, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0x78, 0x00, 0x67, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0,
  0x0C, 0x78, 0x81, 0x8E, 0x1C, 0x77, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFC, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x01, 0x07, 0xE0, 0x07, 0x07, 0xF8, 0x07, 0x07, 0x1C, 0x03,
  0x83, 0x86, 0x03, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0x81, 0xC0, 0xC0, 0xC1,
  0xC0, 0xE0, 0xE1, 0xE0, 0x70, 0x70, 0xE0, 0x38, 0x38, 0xE0, 0x1C, 0x1C,
  0x70, 0x0E, 0x1C, 0x71, 0xE7, 0x0E, 0x73, 0xFB, 0x86, 0x3B, 0xFF, 0xC7,
  0x39, 0xC7, 0xFF, 0x39, 0xC3, 0xBF, 0x1C, 0xE1, 0xC6, 0x1C, 0xE0, 0xE0,
  0x1C, 0x70, 0x70, 0x0E, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x07, 0x06, 0x0E, 0x07, 0x03, 0x07, 0x07, 0x01, 0x83, 0x83, 0x80, 0xC3,
  0x83, 0x80, 0x73, 0x83, 0x80, 0x3F, 0xC3, 0xC0, 0x0F, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1E,
  0x1E, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3C, 0xF1, 0xE0, 0xE7,
  0x83, 0x83, 0x9C, 0x0F, 0x1E, 0xF0, 0x1E, 0xF3, 0x80, 0x7B, 0x8E, 0x00,
  0xFE, 0x38, 0x03, 0xF0, 0xE0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x03, 0xFC,
  0x1F, 0xFF, 0x78, 0x7F, 0xF1, 0xE0, 0x7F, 0x83, 0xC0, 0x3C, 0xE7, 0x9E,
  0x71, 0xC7, 0x1C, 0x63, 0x80, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0C, 0x03, 0xC6, 0x03,
  0xFB, 0x06, 0x3F, 0xFF, 0x03, 0xFF, 0x83, 0xE0, 0xC3, 0xB8, 0x03, 0xDC,
  0x03, 0xC7, 0x03, 0xC3, 0x80, 0xC1, 0xE0, 0x20, 0x70, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x70, 0xE0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFE, 0x77, 0xBF,
  0xEF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E,
  0x0F, 0x87, 0x83, 0xC0, 0xE1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00, 0xE7, 0x00,
  0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x1C, 0x3C,
  0x0F, 0x07, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0xF0, 0x3E, 0x07, 0xE1, 0xFE, 0x3F, 0xEF, 0xDE, 0x71, 0xC6, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0x01, 0xE0, 0x20, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0xC0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3D, 0xC0, 0x03, 0x9C, 0x00, 0x73, 0xC0,
  0x0E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x78,
  0x0F, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xF0, 0x78, 0x0F,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x02,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x18, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xE3, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0x7F, 0xF1, 0xF0, 0x3C, 0xF8,
  0x07, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x83, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xF1, 0xF0, 0x78,
  0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x1C, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x07, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x03,
  0x87, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x1E, 0x01, 0xE1, 0xE0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0x78,
  0x3F, 0x1F, 0xFF, 0x83, 0xFE, 0xE0, 0x7E, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x0F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0x1F, 0x1F,
  0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE3, 0xE1, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07,
  0x1C, 0x07, 0xF8, 0x73, 0x81, 0xFF, 0x87, 0x38, 0x3C, 0x38, 0x77, 0x07,
  0x87, 0x07, 0x70, 0x70, 0x70, 0x77, 0x0E, 0x07, 0x07, 0xE0, 0xE0, 0x70,
  0x7E, 0x1C, 0x0E, 0x06, 0xE1, 0xC0, 0xE0, 0xEE, 0x1C, 0x0E, 0x0E, 0xE1,
  0xC1, 0xE0, 0xEE, 0x1C, 0x1C, 0x1C, 0xE1, 0xC3, 0xC1, 0xCE, 0x1C, 0x7E,
  0x38, 0xE1, 0xFE, 0xFF, 0x0E, 0x0F, 0xC7, 0xE0, 0xE0, 0x30, 0x10, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x0E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xDE, 0x00, 0x1D, 0xE0, 0x03, 0xCE,
  0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0,
  0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE0,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x07,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0x81, 0xF0, 0x1C,
  0x03, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0x80,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x01, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x40, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x70, 0x03,
  0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00,
  0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xE0, 0x07, 0xC7, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x78,
  0x0F, 0x81, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xF7, 0xE0, 0x3E, 0x00, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x07,
  0xFC, 0x70, 0x0F, 0xF9, 0xE0, 0x1F, 0xF3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x70,
  0x78, 0x00, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E,
  0x07, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78,
  0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0,
  0x70, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x47, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x87,
  0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xBC, 0x00,
  0x1E, 0x78, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x77, 0x00, 0x1F,
  0xC0, 0xEE, 0x00, 0x3F, 0x81, 0xDC, 0x00, 0xEF, 0x03, 0xB8, 0x01, 0xDC,
  0x0F, 0x70, 0x07, 0x38, 0x1C, 0xE0, 0x0E, 0xF0, 0x39, 0xC0, 0x39, 0xE0,
  0x73, 0x80, 0x73, 0xC0, 0xE7, 0x01, 0xC7, 0x03, 0xCE, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x3C, 0x0E, 0x1C, 0x1C, 0x78, 0x1C, 0x38, 0x70, 0xE0, 0x78,
  0x70, 0xE1, 0xC0, 0xF0, 0xE3, 0x83, 0x81, 0xC1, 0xC7, 0x0F, 0x03, 0x83,
  0x9C, 0x1E, 0x07, 0x07, 0x38, 0x38, 0x1E, 0x0E, 0xE0, 0x70, 0x3C, 0x1F,
  0xC1, 0xE0, 0x70, 0x3F, 0x03, 0xC0, 0xE0, 0x7E, 0x07, 0x81, 0xC0, 0x78,
  0x0E, 0x07, 0x80, 0xF0, 0x1C, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x38, 0x1F, 0x80, 0x1E, 0x07,
  0xF0, 0x07, 0x81, 0xFC, 0x01, 0xC0, 0x77, 0x00, 0x70, 0x1D, 0xC0, 0x1C,
  0x0F, 0x78, 0x0F, 0x03, 0x8E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0xF0,
  0x38, 0x0E, 0x1C, 0x1E, 0x07, 0x87, 0x07, 0x81, 0xC1, 0xE1, 0xC0, 0x70,
  0x78, 0x70, 0x1C, 0x0E, 0x1C, 0x0F, 0x03, 0x8F, 0x03, 0xC0, 0xF3, 0xC0,
  0xE0, 0x1C, 0xE0, 0x38, 0x07, 0x38, 0x0E, 0x01, 0xEE, 0x07, 0x80, 0x3F,
  0x81, 0xE0, 0x0F, 0xE0, 0x70, 0x03, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7C, 0x07, 0xC0,
  0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x7C, 0x1E,
  0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70,
  0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0x9E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xE1, 0xE0, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC1, 0xC0, 0x38, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0x80, 0x40, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0xC0, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00,
  0x38, 0x38, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0,
  0x01, 0xEE, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x07, 0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0xF0,
  0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38,
  0x00, 0x77, 0x80, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x1C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0,
  0x0F, 0xC0, 0x38, 0xF0, 0x0D, 0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0,
  0x1D, 0xC0, 0x70, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x39, 0xC0, 0xE0, 0xF0,
  0x71, 0xC1, 0xE0, 0xF0, 0x71, 0xC1, 0xC0, 0xF0, 0xF1, 0xC3, 0xC0, 0xF0,
  0xE1, 0xC3, 0xC0, 0xF0, 0xE1, 0xC3, 0x80, 0xF1, 0xC1, 0xC7, 0x80, 0xF1,
  0xC1, 0xC7, 0x00, 0xF3, 0x81, 0xCF, 0x00, 0xF3, 0x81, 0xCE, 0x00, 0xF7,
  0x81, 0xCE, 0x00, 0xF7, 0x01, 0xDE, 0x00, 0xF7, 0x01, 0xDC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0,
  0x00, 0x71, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xEF, 0x00,
  0x03, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80,
  0x0E, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x78, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x3C, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xE0, 0xE0,
  0x78, 0x78, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x3D, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0F, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1B,
  0x80, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1,
  0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x38, 0x70, 0x07, 0x1E, 0x00,
  0x73, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xF1, 0xC7,
  0x8E, 0x1C, 0x30, 0x03, 0xF8, 0xE0, 0xFF, 0xB8, 0x3F, 0xF7, 0x0F, 0x87,
  0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1E,
  0x38, 0x03, 0xC7, 0x00, 0xF0, 0xE0, 0x3E, 0x1C, 0x07, 0xC3, 0xC1, 0xB8,
  0x7F, 0xEF, 0x07, 0xF9, 0xC0, 0x7E, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0xE0, 0x39, 0xFE, 0x07, 0x7F,
  0xE0, 0xFC, 0x3C, 0x3F, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C,
  0x7E, 0x0F, 0x0E, 0xFF, 0xE1, 0xCF, 0xF8, 0x38, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0x13, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x43, 0xFF, 0x83,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x1F, 0xCE, 0x01, 0xFF, 0x70, 0x1F, 0xFB, 0x81,
  0xE0, 0xFC, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70,
  0x07, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xF0,
  0x38, 0x0F, 0x81, 0xE0, 0xFC, 0x0F, 0xFD, 0xC0, 0x3F, 0xCE, 0x00, 0xFC,
  0x70, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x78, 0x0E, 0x70, 0x1E, 0xF0, 0x3C, 0xF3, 0xFC, 0xFF, 0xF0,
  0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x08, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x38, 0x0F, 0xFB, 0x80, 0xFF, 0xDC, 0x0F,
  0x07, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80,
  0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x1F, 0x07, 0x00, 0xF0, 0x38, 0x0F, 0x81,
  0xC0, 0x7C, 0x0F, 0x07, 0xE0, 0x7F, 0xEE, 0x01, 0xFE, 0x70, 0x07, 0xE3,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x81, 0x00, 0x78, 0x0E, 0x07, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xCF, 0xC0, 0xE7, 0xF8, 0x3B, 0xFF, 0x0F, 0xC3, 0xC7, 0xE0, 0x71, 0xF0,
  0x1C, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E,
  0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8E, 0x01,
  0xE0, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x7C, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x3C, 0x07,
  0x8F, 0x00, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7D, 0xC0, 0x1F, 0x3C, 0x03, 0xC3, 0x80, 0x78,
  0x78, 0x0E, 0x0F, 0x01, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x38, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x0E, 0x3F, 0x07, 0xE0, 0x73,
  0xFC, 0x7F, 0x83, 0xBF, 0xE7, 0xFE, 0x1F, 0x87, 0xF0, 0xF1, 0xF0, 0x3F,
  0x03, 0x8F, 0x81, 0xF0, 0x1C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F,
  0x1C, 0x03, 0x80, 0x79, 0xE0, 0x1C, 0x03, 0x8F, 0x01, 0xE0, 0x1C, 0x70,
  0x0F, 0x01, 0xE3, 0x80, 0x70, 0x0F, 0x3C, 0x03, 0x80, 0x71, 0xE0, 0x1C,
  0x03, 0x8F, 0x01, 0xE0, 0x1C, 0x70, 0x0F, 0x01, 0xE3, 0x80, 0x70, 0x0F,
  0x3C, 0x03, 0x80, 0x71, 0xE0, 0x1C, 0x03, 0x8F, 0x01, 0xE0, 0x1C, 0x70,
  0x0F, 0x01, 0xE0, 0x0E, 0x3F, 0x83, 0x9F, 0xF0, 0xEF, 0xFC, 0x3F, 0x0F,
  0x1F, 0x81, 0xC7, 0xC0, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0E, 0x38, 0x07, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0x80,
  0x3D, 0xC0, 0x1E, 0xE0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x03, 0x8F, 0xC0, 0x1C, 0xFF, 0x00, 0xEF, 0xFC,
  0x07, 0xE1, 0xE0, 0x7E, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0xC1, 0xE0, 0x7F, 0xFF, 0x03, 0x9F, 0xF0, 0x1C,
  0x7E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0xE0, 0xFF, 0xB8, 0x3F, 0xF7, 0x0F,
  0x07, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1, 0xC0,
  0x1E, 0x38, 0x07, 0xC7, 0x00, 0xF0, 0xE0, 0x3E, 0x1C, 0x07, 0xC3, 0xC1,
  0xF8, 0x7F, 0xEE, 0x07, 0xF9, 0xC0, 0x7E, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x3E, 0x1C, 0xFC,
  0x3B, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x1E, 0x02, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x80, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0x1F, 0xE1, 0xFC, 0x00,
  0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x3E, 0x38, 0x0F, 0x8F, 0x0F, 0xE3, 0xFF, 0x70, 0x7F, 0x9C, 0x0F,
  0xC7, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xCF, 0x01,
  0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C,
  0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00,
  0x7B, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x7B, 0xC0, 0xF8, 0x0F, 0x78,
  0x1F, 0x01, 0xCF, 0x03, 0x60, 0x78, 0xE0, 0xEC, 0x0E, 0x1C, 0x1D, 0x83,
  0xC3, 0x87, 0x30, 0x70, 0x70, 0xE7, 0x1E, 0x0E, 0x38, 0xE3, 0xC1, 0xC7,
  0x1C, 0x70, 0x39, 0xC3, 0x9E, 0x07, 0x38, 0x73, 0x80, 0xE7, 0x0E, 0xF0,
  0x1D, 0xC1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1D,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x1E,
  0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1E, 0x07, 0x80, 0x70, 0x7C,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x3C, 0x00, 0xE0,
  0x78, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x0F, 0x00, 0x0F, 0x1E,
  0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x5F, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 12, 10, 15, 4, -29 },
  { 53, 23, 29, 23, 1, -29 },
  { 137, 19, 33, 20, 1, -31 },
  { 216, 25, 30, 30, 3, -30 },
  { 310, 22, 30, 24, 1, -30 },
  { 393, 6, 10, 9, 4, -29 },
  { 401, 13, 35, 11, 1, -29 },
  { 458, 13, 35, 11, -3, -29 },
  { 515, 17, 17, 20, 4, -31 },
  { 552, 18, 19, 21, 2, -24 },
  { 595, 8, 10, 10, -2, -5 },
  { 605, 10, 4, 12, 1, -13 },
  { 610, 5, 5, 10, 1, -5 },
  { 614, 20, 29, 14, -2, -29 },
  { 687, 18, 30, 20, 2, -30 },
  { 755, 12, 29, 20, 5, -29 },
  { 799, 20, 30, 20, 0, -30 },
  { 874, 20, 30, 20, 0, -30 },
  { 949, 20, 29, 20, 0, -29 },
  { 1022, 19, 29, 20, 1, -29 },
  { 1091, 18, 30, 20, 2, -30 },
  { 1159, 18, 29, 20, 3, -29 },
  { 1225, 19, 30, 20, 1, -30 },
  { 1297, 18, 30, 20, 1, -30 },
  { 1365, 8, 22, 10, 1, -22 },
  { 1387, 11, 27, 10, -2, -22 },
  { 1425, 18, 19, 21, 2, -24 },
  { 1468, 17, 11, 21, 3, -20 },
  { 1492, 18, 19, 21, 2, -24 },
  { 1535, 15, 30, 16, 2, -30 },
  { 1592, 28, 33, 31, 2, -29 },
  { 1708, 20, 29, 21, -2, -29 },
  { 1781, 21, 29, 22, 1, -29 },
  { 1858, 21, 30, 21, 2, -30 },
  { 1937, 22, 29, 24, 1, -29 },
  { 2017, 20, 29, 19, 1, -29 },
  { 2090, 20, 29, 18, 1, -29 },
  { 2163, 23, 30, 25, 2, -30 },
  { 2250, 24, 29, 25, 1, -29 },
  { 2337, 16, 29, 12, -1, -29 },
  { 2395, 17, 37, 10, -6, -29 },
  { 2474, 23, 29, 21, 1, -29 },
  { 2558, 14, 29, 17, 1, -29 },
  { 2609, 31, 29, 32, 1, -29 },
  { 2722, 26, 29, 26, 1, -29 },
  { 2817, 23, 30, 26, 2, -30 },
  { 2904, 20, 29, 21, 1, -29 },
  { 2977, 23, 37, 26, 2, -30 },
  { 3084, 20, 29, 21, 1, -29 },
  { 3157, 20, 30, 19, 0, -30 },
  { 3232, 18, 29, 18, 4, -29 },
  { 3298, 22, 29, 25, 3, -29 },
  { 3378, 20, 29, 20, 4, -29 },
  { 3451, 32, 29, 32, 4, -29 },
  { 3567, 24, 29, 19, -2, -29 },
  { 3654, 18, 29, 19, 4, -29 },
  { 3720, 22, 29, 19, -1, -29 },
  { 3800, 16, 36, 12, -1, -29 },
  { 3872, 8, 29, 14, 4, -29 },
  { 3901, 16, 36, 12, -3, -29 },
  { 3973, 19, 17, 21, 1, -29 },
  { 4014, 16, 2, 15, -4, 4 },
  { 4018, 6, 6, 11, 6, -31 },
  { 4023, 19, 22, 21, 2, -22 },
  { 4076, 19, 31, 21, 1, -31 },
  { 4150, 15, 22, 17, 2, -22 },
  { 4192, 21, 31, 21, 2, -31 },
  { 4274, 16, 22, 19, 2, -22 },
  { 4318, 22, 41, 12, -5, -31 },
  { 4431, 21, 32, 21, 0, -22 },
  { 4515, 18, 31, 21, 1, -31 },
  { 4585, 9, 30, 10, 1, -30 },
  { 4619, 15, 40, 10, -5, -30 },
  { 4694, 19, 31, 18, 1, -31 },
  { 4768, 10, 31, 10, 1, -31 },
  { 4807, 29, 22, 32, 1, -22 },
  { 4887, 18, 22, 21, 1, -22 },
  { 4937, 17, 22, 21, 2, -22 },
  { 4984, 21, 32, 21, -1, -22 },
  { 5068, 19, 32, 21, 2, -22 },
  { 5144, 15, 22, 14, 1, -22 },
  { 5186, 16, 22, 16, 0, -22 },
  { 5230, 11, 27, 12, 2, -27 },
  { 5268, 18, 22, 21, 2, -22 },
  { 5318, 17, 22, 17, 2, -22 },
  { 5365, 27, 22, 27, 2, -22 },
  { 5440, 21, 22, 18, -2, -22 },
  { 5498, 23, 32, 17, -4, -22 },
  { 5590, 17, 22, 16, -1, -22 },
  { 5637, 15, 35, 14, 1, -29 },
  { 5703, 3, 41, 20, 9, -31 },
  { 5719, 15, 35, 14, -2, -29 },
  { 5785, 18, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Italic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC41PT7B_H_
