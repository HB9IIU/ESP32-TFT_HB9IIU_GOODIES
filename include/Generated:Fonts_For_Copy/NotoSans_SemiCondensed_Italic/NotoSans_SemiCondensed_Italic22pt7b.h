#ifndef _NOTOSANS_SEMICONDENSED_ITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC2, 0x08, 0x01, 0x0E,
  0x38, 0x66, 0xC9, 0xB2, 0x64, 0xD9, 0x00, 0x03, 0x30, 0x11, 0x01, 0x88,
  0x0C, 0xC0, 0x44, 0x1F, 0xFC, 0x33, 0x01, 0x18, 0x08, 0x80, 0xCC, 0x1F,
  0xF9, 0x22, 0x03, 0x10, 0x19, 0x80, 0x88, 0x0C, 0x40, 0x01, 0x00, 0x20,
  0x1E, 0x0F, 0xF1, 0xA4, 0x64, 0x0C, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x16,
  0x02, 0xC0, 0xD9, 0x13, 0x3F, 0xC3, 0xF0, 0x18, 0x03, 0x00, 0x1C, 0x08,
  0xD8, 0x66, 0x63, 0x19, 0x88, 0x46, 0x61, 0x13, 0x0C, 0x49, 0x93, 0x6F,
  0x7B, 0x65, 0xC9, 0x10, 0x6C, 0x43, 0x33, 0x08, 0x8C, 0x62, 0x23, 0x0D,
  0x98, 0x3C, 0x07, 0x80, 0xFC, 0x0C, 0xC1, 0x8C, 0x18, 0xC0, 0x98, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0x33, 0x63, 0x24, 0x1E, 0xC1, 0xCC, 0x1C, 0x67,
  0xC3, 0xE6, 0x6D, 0xA5, 0x80, 0x06, 0x18, 0x60, 0x83, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x80, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x82, 0x0C,
  0x10, 0x63, 0x80, 0x0C, 0x06, 0x23, 0x1D, 0x03, 0xF8, 0xE4, 0xD0, 0xCC,
  0x26, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x33, 0x66, 0x4C, 0x7F, 0xF0, 0x5F, 0x80, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x0F, 0x07, 0xE3, 0x18, 0xC3, 0x60,
  0xD8, 0x36, 0x0B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x86,
  0xE1, 0xF0, 0x0C, 0x77, 0xFA, 0x98, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x21,
  0x86, 0x18, 0x07, 0x83, 0xF8, 0x43, 0x00, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xE7, 0xFC,
  0x0F, 0x83, 0xF8, 0x43, 0x00, 0x30, 0x04, 0x01, 0x80, 0x60, 0xF8, 0x1F,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x39, 0xC7, 0xF0, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x6C, 0x19, 0x02, 0x60, 0xCC, 0x31, 0x8C, 0x31,
  0x04, 0x7F, 0xE0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0F, 0xE1, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0F, 0x81, 0xFC, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x39, 0xC7, 0xF0, 0x03, 0xC3, 0xF1, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0xE1, 0x7C, 0xE1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0x30, 0xC6,
  0x61, 0xF0, 0x3F, 0xDF, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0x0F, 0x07,
  0xE3, 0x0C, 0xC3, 0x30, 0xCC, 0x63, 0xB0, 0x78, 0x3E, 0x18, 0xCC, 0x33,
  0x06, 0x81, 0x30, 0xCE, 0x71, 0xF8, 0x0F, 0x1F, 0xCC, 0x6C, 0x36, 0x0B,
  0x0D, 0x86, 0xC3, 0x77, 0x9E, 0xC0, 0x40, 0x60, 0x30, 0x32, 0x71, 0xF0,
  0x19, 0xCC, 0x00, 0x00, 0x00, 0x02, 0x39, 0xC0, 0x0C, 0x71, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x18, 0x61, 0x0C, 0x00, 0x00, 0x40, 0x70, 0x70,
  0x70, 0x70, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x70, 0x70, 0x70, 0x30, 0x00, 0x3E, 0x7F, 0x43, 0x03, 0x03, 0x06,
  0x06, 0x1C, 0x38, 0x30, 0x20, 0x60, 0x00, 0x40, 0xE0, 0xE0, 0x01, 0xE0,
  0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x6C, 0x7C, 0x51, 0x98, 0xA2,
  0x31, 0xCC, 0x47, 0x90, 0x8E, 0x23, 0x14, 0x46, 0x6C, 0xF7, 0x98, 0xC4,
  0x10, 0x00, 0x30, 0x00, 0x38, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x30, 0x66, 0x18, 0xC3, 0xF8, 0xFF, 0x18,
  0x36, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x1F, 0x03, 0xF8, 0xC3, 0x98, 0x33,
  0x06, 0x61, 0x88, 0x73, 0xF8, 0x7F, 0x8C, 0x31, 0x83, 0x20, 0x6C, 0x19,
  0x83, 0x3F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x1C, 0x03, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x7B, 0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x30, 0xE3, 0x06, 0x30, 0x63,
  0x07, 0x20, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x64, 0x0C, 0xC1, 0xCC,
  0x38, 0xFF, 0x0F, 0xC0, 0x1F, 0xC7, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0xFC, 0x7F, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x7F, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x03, 0xE0, 0xFF, 0x1C,
  0x13, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC1, 0xEC, 0x06, 0xC0,
  0x6C, 0x06, 0xE0, 0x46, 0x0C, 0x79, 0xC1, 0xFC, 0x18, 0x18, 0xC1, 0x8C,
  0x0C, 0x60, 0x63, 0x03, 0x18, 0x10, 0x81, 0x8F, 0xFC, 0x7F, 0xE3, 0x03,
  0x18, 0x10, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x30, 0x0F, 0x8F,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC1, 0xF8, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x3E, 0x1E, 0x00, 0x18, 0x31, 0x86, 0x30, 0xC3, 0x18, 0x33, 0x03, 0x60,
  0x2E, 0x06, 0xC0, 0x7C, 0x06, 0x60, 0x66, 0x04, 0x60, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x3F, 0xFF, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x0F, 0x3C,
  0x0A, 0x3C, 0x1E, 0x3C, 0x16, 0x2C, 0x36, 0x64, 0x26, 0x64, 0x64, 0x64,
  0x4C, 0x64, 0xCC, 0x46, 0x8C, 0xC7, 0x8C, 0xC7, 0x08, 0xC7, 0x18, 0x86,
  0x18, 0x18, 0x18, 0xC0, 0xCF, 0x06, 0x78, 0x33, 0xC1, 0x1B, 0x18, 0x98,
  0xCC, 0xC6, 0x62, 0x23, 0x1B, 0x18, 0xD8, 0x82, 0xCC, 0x1E, 0x60, 0xE3,
  0x07, 0x10, 0x18, 0x07, 0xC0, 0xFE, 0x18, 0x33, 0x03, 0x30, 0x36, 0x03,
  0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x66, 0x0C,
  0x7B, 0x83, 0xF0, 0x1F, 0x07, 0xE3, 0x0C, 0xC3, 0x30, 0xCC, 0x32, 0x0D,
  0x86, 0x7F, 0x1F, 0x86, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07,
  0xC0, 0xFE, 0x18, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x66, 0x0C, 0x7B, 0x83, 0xF0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x1F, 0x07, 0xE3, 0x0C, 0xC3, 0x30, 0xCC,
  0x32, 0x0D, 0x86, 0x7F, 0x19, 0x86, 0x61, 0x18, 0xC3, 0x30, 0xCC, 0x33,
  0x06, 0x07, 0xC3, 0xFC, 0x61, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0F, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x3B, 0xC7, 0xF0, 0xFF,
  0xFF, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x18, 0x19, 0x81, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10,
  0x11, 0x81, 0x8C, 0x0C, 0x70, 0xC1, 0xDE, 0x07, 0xE0, 0xC0, 0x78, 0x1B,
  0x03, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x30, 0x46, 0x09, 0x81, 0x30,
  0x34, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0xC1, 0xE0, 0xE0, 0xF0,
  0x70, 0xD8, 0x78, 0x6C, 0x3C, 0x66, 0x36, 0x33, 0x1B, 0x31, 0x89, 0x98,
  0xCC, 0xC8, 0x64, 0x6C, 0x36, 0x36, 0x1A, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x03, 0x83, 0x81, 0xC1, 0x80, 0x18, 0x18, 0x61, 0x83, 0x1C, 0x18, 0xC0,
  0x4C, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0x40, 0x33,
  0x03, 0x18, 0x18, 0xC1, 0x83, 0x18, 0x18, 0xC0, 0xF0, 0x6C, 0x19, 0x0C,
  0x66, 0x19, 0x86, 0xC1, 0xA0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x3F, 0xC7,
  0xF8, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xF0, 0xF0, 0xCC, 0x44, 0x66,
  0x66, 0x62, 0x23, 0x33, 0x33, 0x0F, 0x87, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x1E, 0x1F, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0x58, 0x32, 0x08, 0xC6,
  0x11, 0x06, 0xC1, 0xA0, 0x30, 0xFF, 0xC6, 0x23, 0x1E, 0xCF, 0xF7, 0x1D,
  0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0x31, 0xCE, 0xF1, 0xEC, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x37, 0x05, 0xF1, 0xC6, 0x38, 0x66,
  0x0C, 0xC1, 0x10, 0x66, 0x0C, 0xC1, 0x98, 0x62, 0x98, 0xDE, 0x00, 0x0F,
  0x3F, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x3D, 0x8F, 0xF3, 0x8E, 0x61, 0x8C,
  0x33, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0xC7, 0x78, 0x7B, 0x00, 0x1E,
  0x3F, 0x61, 0x61, 0xC3, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xE6, 0x7E, 0x00,
  0xF0, 0x1F, 0x01, 0x80, 0x10, 0x03, 0x00, 0x7C, 0x0F, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0xB8, 0x0F, 0x00, 0x0F, 0x63, 0xFC, 0xE3,
  0x98, 0x63, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0x8C, 0x71, 0xDE, 0x1E,
  0xC0, 0x10, 0x06, 0x00, 0xC6, 0x30, 0xFC, 0x00, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x06, 0xE1, 0x7C, 0xE3, 0x30, 0xCC, 0x33, 0x0C, 0x83, 0x60,
  0x98, 0x66, 0x19, 0x86, 0xC1, 0x80, 0x0C, 0x60, 0x00, 0x18, 0x43, 0x0C,
  0x30, 0xC2, 0x18, 0x61, 0x86, 0x30, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x16, 0x0F, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x31, 0xC4, 0x61, 0x98, 0x33, 0x06, 0xC0, 0xB0, 0x1F, 0x06, 0x60,
  0xCC, 0x18, 0xC3, 0x18, 0xC3, 0x80, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C,
  0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0xC0, 0x13, 0x8E, 0x17, 0xDF, 0x38,
  0xE3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x20, 0x82, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x86, 0xC3, 0x0C, 0x13, 0xC5, 0xF3, 0x8C, 0xE3,
  0x30, 0xCC, 0x36, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x1B, 0x06, 0x1E, 0x1F,
  0xDC, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB9, 0x8F, 0x80,
  0x09, 0xC0, 0xBE, 0x1C, 0x61, 0xC3, 0x18, 0x31, 0x82, 0x10, 0x63, 0x06,
  0x30, 0x63, 0x0C, 0x29, 0x82, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0E,
  0xC3, 0x31, 0xCE, 0xF1, 0xEC, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x13, 0x8B, 0x8E, 0x07, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x00, 0x1F, 0x3F, 0x60, 0x60, 0x30, 0x38, 0x1C, 0x06, 0x06, 0x06,
  0xCE, 0xFC, 0x10, 0xC7, 0xFF, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xCB,
  0xC0, 0x30, 0xC8, 0x36, 0x09, 0x86, 0x61, 0x98, 0x6C, 0x1B, 0x0C, 0xC3,
  0x31, 0xCC, 0xF1, 0xEC, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x62, 0x31, 0x30,
  0x98, 0x58, 0x3C, 0x1C, 0x0E, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x71, 0xB1,
  0x46, 0xCD, 0x13, 0x34, 0xCC, 0x93, 0x36, 0x58, 0xD1, 0x63, 0xC5, 0x0E,
  0x1C, 0x18, 0x60, 0x18, 0x63, 0x18, 0x26, 0x06, 0xC0, 0xF0, 0x0C, 0x03,
  0x80, 0x70, 0x1B, 0x06, 0x61, 0x84, 0x70, 0xC0, 0x18, 0x31, 0x83, 0x18,
  0x60, 0x86, 0x08, 0xC0, 0x8C, 0x0D, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xF0, 0x00, 0x1F, 0xC7,
  0xE0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0xFC, 0x01, 0x83, 0x81, 0x81, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x38,
  0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x0E, 0x00, 0xFF,
  0xFF, 0xFC, 0x0C, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x04, 0x07,
  0x07, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0x78, 0x77, 0xF8,
  0x30,
};

const GFXglyph NotoSans_SemiCondensed_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 13, 16, 12, 0, -16 },
  { 45, 11, 18, 11, 0, -17 },
  { 70, 14, 16, 16, 1, -16 },
  { 98, 12, 16, 13, 0, -16 },
  { 122, 3, 6, 5, 2, -16 },
  { 125, 7, 19, 6, 1, -16 },
  { 142, 7, 19, 6, -2, -16 },
  { 159, 9, 9, 11, 2, -17 },
  { 170, 10, 10, 11, 1, -13 },
  { 183, 4, 6, 5, -1, -3 },
  { 186, 6, 2, 6, 0, -7 },
  { 188, 3, 3, 5, 0, -3 },
  { 190, 10, 16, 8, -1, -16 },
  { 210, 10, 16, 11, 1, -16 },
  { 230, 6, 16, 11, 3, -16 },
  { 242, 11, 16, 11, 0, -16 },
  { 264, 11, 16, 11, 0, -16 },
  { 286, 11, 16, 11, 0, -16 },
  { 308, 11, 16, 11, 0, -16 },
  { 330, 10, 16, 11, 1, -16 },
  { 350, 10, 16, 11, 1, -16 },
  { 370, 10, 16, 11, 1, -16 },
  { 390, 9, 16, 11, 1, -16 },
  { 408, 5, 12, 5, 0, -12 },
  { 416, 6, 15, 5, -1, -12 },
  { 428, 10, 10, 11, 1, -13 },
  { 441, 10, 6, 11, 1, -11 },
  { 449, 10, 10, 11, 1, -13 },
  { 462, 8, 16, 8, 1, -16 },
  { 478, 15, 18, 17, 1, -16 },
  { 512, 11, 16, 11, -1, -16 },
  { 534, 11, 16, 12, 1, -16 },
  { 556, 12, 16, 11, 1, -16 },
  { 580, 12, 16, 13, 1, -16 },
  { 604, 10, 16, 10, 1, -16 },
  { 624, 10, 16, 9, 1, -16 },
  { 644, 12, 16, 13, 1, -16 },
  { 668, 13, 16, 13, 1, -16 },
  { 694, 9, 16, 7, -1, -16 },
  { 712, 9, 20, 5, -3, -16 },
  { 735, 12, 16, 11, 1, -16 },
  { 759, 7, 16, 9, 1, -16 },
  { 773, 16, 16, 17, 1, -16 },
  { 805, 13, 16, 14, 1, -16 },
  { 831, 12, 16, 14, 1, -16 },
  { 855, 10, 16, 11, 1, -16 },
  { 875, 12, 20, 14, 1, -16 },
  { 905, 10, 16, 11, 1, -16 },
  { 925, 11, 16, 10, 0, -16 },
  { 947, 10, 16, 10, 2, -16 },
  { 967, 13, 16, 13, 1, -16 },
  { 993, 11, 16, 11, 2, -16 },
  { 1015, 17, 16, 17, 2, -16 },
  { 1049, 13, 16, 10, -1, -16 },
  { 1075, 10, 16, 10, 2, -16 },
  { 1095, 11, 16, 10, 0, -16 },
  { 1117, 8, 20, 6, 0, -16 },
  { 1137, 4, 16, 8, 2, -16 },
  { 1145, 9, 20, 6, -2, -16 },
  { 1168, 10, 10, 11, 1, -16 },
  { 1181, 8, 1, 8, -2, 2 },
  { 1182, 4, 4, 6, 3, -17 },
  { 1184, 10, 12, 11, 1, -12 },
  { 1199, 11, 17, 11, 0, -17 },
  { 1223, 8, 12, 9, 1, -12 },
  { 1235, 11, 17, 11, 1, -17 },
  { 1259, 8, 12, 10, 1, -12 },
  { 1271, 12, 22, 6, -3, -17 },
  { 1304, 11, 17, 11, 0, -12 },
  { 1328, 10, 17, 11, 0, -17 },
  { 1350, 6, 16, 5, 0, -16 },
  { 1362, 9, 21, 5, -3, -16 },
  { 1386, 11, 17, 10, 0, -17 },
  { 1410, 6, 17, 5, 0, -17 },
  { 1423, 16, 12, 17, 0, -12 },
  { 1447, 10, 12, 11, 0, -12 },
  { 1462, 9, 12, 11, 1, -12 },
  { 1476, 12, 17, 11, -1, -12 },
  { 1502, 10, 17, 11, 1, -12 },
  { 1524, 9, 12, 8, 0, -12 },
  { 1538, 8, 12, 9, 0, -12 },
  { 1550, 6, 14, 7, 1, -14 },
  { 1561, 10, 12, 11, 1, -12 },
  { 1576, 9, 12, 9, 1, -12 },
  { 1590, 14, 12, 14, 1, -12 },
  { 1611, 11, 12, 10, -1, -12 },
  { 1628, 12, 17, 9, -2, -12 },
  { 1654, 10, 12, 8, -1, -12 },
  { 1669, 9, 19, 8, 0, -16 },
  { 1691, 1, 22, 11, 5, -17 },
  { 1694, 8, 19, 8, -1, -16 },
  { 1713, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Italic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC22PT7B_H_
