#ifndef _NOTOSANS_SEMICONDENSED_ITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0C, 0x00,
  0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0xDE,
  0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x31, 0xC3, 0x80, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x0E, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x80, 0x38, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x1C,
  0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFD, 0x9E, 0x07, 0x8C, 0x10, 0x78, 0xE0, 0x03, 0xC7,
  0x00, 0x1E, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x3C, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3B, 0xE0, 0x01, 0x8F, 0x00, 0x1C, 0x78, 0x00,
  0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x30, 0xF1, 0x01, 0x87, 0x8C, 0x1C, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x01, 0xE0, 0x7F, 0x80, 0x0E, 0x07, 0xFE, 0x00, 0xE0, 0x38,
  0x70, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0x1C, 0x1C, 0x07, 0x01, 0xE0, 0xE0,
  0x78, 0x0E, 0x07, 0x03, 0x80, 0x70, 0x38, 0x38, 0x03, 0x81, 0xC3, 0xC0,
  0x3C, 0x1E, 0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0x0E, 0x07, 0x1E, 0x00, 0x70,
  0x38, 0xE3, 0xE3, 0x83, 0x8E, 0x3F, 0xDC, 0x1C, 0xF3, 0xFE, 0xF1, 0xE7,
  0x3C, 0x73, 0xFE, 0x71, 0xC3, 0xDF, 0xE7, 0x9C, 0x1E, 0x7E, 0x38, 0xE0,
  0xF0, 0x03, 0x87, 0x07, 0x80, 0x3C, 0x70, 0x38, 0x01, 0xC3, 0x81, 0xC0,
  0x1E, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x70, 0x0E, 0x07, 0x07, 0x80, 0xF0,
  0x38, 0x38, 0x0F, 0x01, 0xC1, 0xC0, 0x70, 0x0E, 0x1E, 0x07, 0x80, 0x70,
  0xE0, 0x78, 0x03, 0xDE, 0x03, 0x80, 0x1F, 0xF0, 0x3C, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x38,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xC7, 0xCF, 0x01, 0xC7,
  0xC3, 0xC1, 0xE7, 0xC1, 0xE0, 0xE3, 0xC0, 0x78, 0xF3, 0xC0, 0x3E, 0xF1,
  0xE0, 0x0F, 0x78, 0xF0, 0x07, 0xF8, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7F, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xF9,
  0xE0, 0x7F, 0xF8, 0xF8, 0x1F, 0xF0, 0x3E, 0x00, 0x3D, 0xF7, 0x9E, 0x79,
  0xC7, 0x1C, 0xF3, 0x8E, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xE0, 0x3C, 0x38,
  0x0F, 0xCE, 0x03, 0xFF, 0x01, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC,
  0x1F, 0x80, 0x0E, 0x70, 0x07, 0x9C, 0x03, 0xC7, 0x81, 0xE0, 0xE0, 0x38,
  0x3C, 0x04, 0x0F, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x38,
  0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01,
  0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x1E, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFC, 0x0F, 0xE1,
  0xFF, 0x1F, 0xF9, 0xF3, 0xDF, 0x3C, 0x61, 0xE2, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0x3E, 0x01, 0x80,
  0x7C, 0x04, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xF8, 0x3E, 0x01, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x80,
  0x07, 0xC3, 0xC0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xDC, 0x00,
  0x1E, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x0C, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x88, 0x00, 0xF8,
  0x70, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF8, 0x20, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x1E, 0x7F, 0x80,
  0xE7, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0xF8, 0x0F, 0x81, 0xF0,
  0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x78, 0x07,
  0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xC3, 0xE0, 0x78,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x03, 0xF0, 0xFE, 0xFF, 0x83,
  0xFF, 0xB8, 0x0F, 0xFB, 0xC0, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x40, 0x7E, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0x07, 0xC3, 0xE3, 0xF0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xC3, 0xE1, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0xFC, 0x0E, 0x1E, 0x03, 0xFF, 0x0E, 0x1C, 0x0F,
  0xFF, 0x0F, 0x38, 0x1E, 0x0E, 0x07, 0x38, 0x1C, 0x0E, 0x07, 0x78, 0x38,
  0x1E, 0x0F, 0x70, 0x78, 0x1E, 0x0E, 0x70, 0x70, 0x1C, 0x0E, 0x70, 0x70,
  0x1C, 0x0E, 0xF0, 0xE0, 0x3C, 0x0E, 0xE0, 0xE0, 0x38, 0x1E, 0xE0, 0xE0,
  0x38, 0x1C, 0xE0, 0xE0, 0x78, 0x1C, 0xE0, 0xE0, 0x78, 0x38, 0xE0, 0xE0,
  0xF8, 0x38, 0xE0, 0xF1, 0xF8, 0x70, 0xE0, 0xFF, 0x9F, 0xE0, 0xE0, 0x7F,
  0x1F, 0xC0, 0xF0, 0x3E, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x04, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x1C,
  0x01, 0xF0, 0x1E, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x7C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x00, 0x7C,
  0x0F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0,
  0x78, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xE1, 0xE0,
  0x3E, 0x00, 0x40, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x70, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3C, 0x07, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x3E, 0x0F,
  0x00, 0x7E, 0x07, 0x80, 0x7E, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xE0, 0x3F, 0x00,
  0x30, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0xFE, 0x78, 0x03, 0xFF, 0x3C, 0x01, 0xFF, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x07, 0xC0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xC0, 0x07, 0x80,
  0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0x70, 0x00, 0x7F,
  0x80, 0xEE, 0x00, 0x0E, 0xF0, 0x1D, 0xC0, 0x03, 0xDC, 0x07, 0xB8, 0x00,
  0x77, 0x80, 0xF7, 0x00, 0x1E, 0xF0, 0x1E, 0xF0, 0x03, 0x9E, 0x03, 0x9E,
  0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1C, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0xC3, 0x81, 0xE3, 0xC0, 0x78, 0x70, 0x78, 0x78, 0x0F, 0x0E, 0x0F,
  0x0F, 0x01, 0xE1, 0xC3, 0xC1, 0xE0, 0x38, 0x3C, 0x78, 0x78, 0x0F, 0x07,
  0x9E, 0x0F, 0x01, 0xE0, 0xF3, 0xC1, 0xE0, 0x3C, 0x1E, 0xF0, 0x3C, 0x07,
  0x01, 0xDE, 0x07, 0x80, 0xE0, 0x3F, 0x81, 0xE0, 0x3C, 0x07, 0xF0, 0x3C,
  0x07, 0x80, 0xFC, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x1C, 0x03, 0xE0,
  0x1E, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xE0,
  0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x01, 0xFC, 0x00, 0x78, 0x0E, 0xE0, 0x03,
  0x80, 0x77, 0x80, 0x3C, 0x07, 0xBC, 0x01, 0xE0, 0x3D, 0xE0, 0x0F, 0x01,
  0xE7, 0x80, 0x78, 0x0E, 0x3C, 0x03, 0x80, 0xF1, 0xE0, 0x3C, 0x07, 0x87,
  0x01, 0xE0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0E, 0x07, 0x07,
  0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01,
  0xE0, 0x3C, 0x70, 0x0E, 0x01, 0xE7, 0x80, 0xF0, 0x0F, 0x3C, 0x07, 0x80,
  0x39, 0xE0, 0x3C, 0x01, 0xEF, 0x01, 0xE0, 0x0F, 0x70, 0x0E, 0x00, 0x3B,
  0x80, 0xF0, 0x01, 0xFC, 0x07, 0x80, 0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0x01,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x0F,
  0x00, 0x1F, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x0F, 0x83,
  0xC0, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x81,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x81,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xF0, 0xF0,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE,
  0x3E, 0x07, 0xE0, 0x18, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x80, 0x0F, 0x83, 0xC0, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x80, 0x3C, 0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70,
  0x00, 0x39, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x7B,
  0x80, 0x0F, 0x80, 0x0F, 0x70, 0x01, 0xF0, 0x03, 0xCF, 0x00, 0x7E, 0x00,
  0x79, 0xE0, 0x0F, 0xC0, 0x1F, 0x3C, 0x03, 0xF8, 0x03, 0xC7, 0x80, 0x77,
  0x00, 0x78, 0xF0, 0x0E, 0xE0, 0x1E, 0x1E, 0x03, 0xDC, 0x03, 0xC3, 0xC0,
  0x73, 0x80, 0xF0, 0x78, 0x1E, 0x70, 0x1E, 0x0F, 0x03, 0x8E, 0x03, 0xC1,
  0xE0, 0xF1, 0xC0, 0xF0, 0x3C, 0x1C, 0x38, 0x1E, 0x07, 0x83, 0x87, 0x07,
  0x80, 0xF0, 0xF0, 0xE0, 0xF0, 0x1E, 0x1C, 0x1C, 0x3C, 0x03, 0xC7, 0x83,
  0x87, 0x80, 0x78, 0xE0, 0x70, 0xE0, 0x0F, 0x3C, 0x0E, 0x3C, 0x01, 0xE7,
  0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x3D, 0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00,
  0xF7, 0x00, 0xE7, 0x00, 0x1F, 0xE0, 0x1D, 0xE0, 0x03, 0xB8, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80,
  0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x3C,
  0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x3C,
  0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0x70,
  0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x03, 0x9C, 0x00, 0x1F,
  0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xF1,
  0xE1, 0xC3, 0xC3, 0x83, 0x80, 0x00, 0xFC, 0x38, 0x1F, 0xF1, 0xC1, 0xFF,
  0xDE, 0x1F, 0x8E, 0xE0, 0xF0, 0x3F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF8,
  0x7C, 0x3F, 0xC1, 0xFF, 0xDC, 0x0F, 0xFC, 0xE0, 0x1F, 0x87, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE3, 0xF0, 0x0F, 0x3F, 0xC0, 0x73, 0xFF, 0x07, 0xB8, 0xF8,
  0x3F, 0x83, 0xE1, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8, 0x03,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0xF7,
  0xFF, 0x07, 0x3F, 0xF0, 0x38, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF8, 0x61, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x41, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xF1, 0xE0, 0x1F, 0xF3, 0xC0,
  0x7F, 0xF7, 0x81, 0xF8, 0xEE, 0x07, 0xC0, 0xFC, 0x0F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1E, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x7C, 0x3B, 0xC0, 0x7F, 0xF7, 0x00,
  0xFF, 0xCE, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x78, 0x07, 0x9E, 0x03, 0xE7, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xC2, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x0E,
  0x01, 0xFF, 0x1C, 0x07, 0xFF, 0x78, 0x1F, 0x8E, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03,
  0xE0, 0xF0, 0x0F, 0x81, 0xE0, 0x3F, 0x03, 0xC0, 0xFE, 0x07, 0xC3, 0xFC,
  0x07, 0xFF, 0x70, 0x0F, 0xFD, 0xE0, 0x0F, 0xE3, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x60, 0x0F, 0x80, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF0, 0x0F, 0x3F,
  0xC0, 0x73, 0xFF, 0x07, 0xB8, 0xF8, 0x3F, 0x83, 0xE1, 0xF8, 0x0F, 0x0F,
  0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01,
  0xE0, 0x00, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x23, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x0F,
  0x01, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0,
  0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x00, 0x0E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x78, 0x01,
  0xE3, 0xC0, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x0F, 0xC0, 0x7C, 0x03, 0x9F, 0xF0, 0xFF, 0x81,
  0xDF, 0xF8, 0xFF, 0xC1, 0xEE, 0x3E, 0xF3, 0xF0, 0xFE, 0x0F, 0xE0, 0x78,
  0x7E, 0x07, 0xE0, 0x3C, 0x3E, 0x03, 0xE0, 0x1E, 0x3E, 0x01, 0xF0, 0x0F,
  0x1F, 0x00, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0x07, 0x87, 0x80, 0x38, 0x03,
  0xC3, 0xC0, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x3C, 0x38, 0x03, 0xC0,
  0x1E, 0x3C, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x03, 0xC3, 0x80, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x00, 0xE1, 0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x0F, 0xC0, 0x39, 0xFF, 0x83, 0xDF, 0xFC, 0x1F, 0xF3, 0xF0, 0xFE, 0x0F,
  0x87, 0xE0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x07, 0xE3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x78, 0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x7C, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xC3, 0xF0, 0x03, 0x8F, 0xF0, 0x07,
  0x3F, 0xF0, 0x1E, 0xE3, 0xE0, 0x3F, 0x83, 0xE0, 0x7E, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x7F, 0xF0, 0x1E,
  0x7F, 0xC0, 0x3C, 0x7F, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x38, 0x1F, 0xF1, 0xC1, 0xFF, 0xDE, 0x1F, 0x8E, 0xE0,
  0xF0, 0x3F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0x03, 0xF8, 0x7C, 0x3F, 0xC1, 0xFF,
  0xDC, 0x0F, 0xFD, 0xE0, 0x3F, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x0F, 0x83, 0x9F, 0xC1, 0xDF, 0xC1, 0xEF, 0xE0, 0xFE, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3E, 0x1E, 0x1E, 0x00, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x80, 0x3E, 0x30, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0xFD, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80,
  0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0x03, 0xF8, 0x7C,
  0x3B, 0x83, 0xFF, 0xDC, 0x0F, 0xFC, 0xE0, 0x3F, 0x87, 0x00, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x03,
  0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00,
  0x3B, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xC0, 0x3D,
  0xE0, 0x3E, 0x01, 0xEF, 0x03, 0xF8, 0x1E, 0x78, 0x1F, 0xC0, 0xF3, 0xC1,
  0xFE, 0x07, 0x1E, 0x0E, 0xF0, 0x78, 0xF0, 0x77, 0x83, 0xC7, 0x87, 0x3C,
  0x3C, 0x3C, 0x39, 0xE1, 0xE1, 0xE3, 0xCF, 0x1E, 0x0F, 0x1C, 0x78, 0xF0,
  0x79, 0xE1, 0xC7, 0x03, 0xCE, 0x0E, 0x78, 0x1E, 0x70, 0x73, 0xC0, 0xF7,
  0x03, 0xBC, 0x07, 0xB8, 0x1D, 0xE0, 0x3F, 0xC0, 0xEE, 0x01, 0xDC, 0x07,
  0xF0, 0x0E, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x9E, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x8F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x03,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0x7F, 0xC8, 0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 34, 12, 1, -33 },
  { 48, 13, 12, 17, 5, -33 },
  { 68, 26, 33, 26, 1, -33 },
  { 176, 21, 38, 23, 1, -35 },
  { 276, 29, 33, 34, 3, -33 },
  { 396, 25, 33, 27, 1, -33 },
  { 500, 6, 12, 10, 5, -33 },
  { 509, 15, 40, 13, 1, -33 },
  { 584, 15, 40, 13, -4, -33 },
  { 659, 18, 19, 22, 5, -35 },
  { 702, 20, 22, 24, 3, -27 },
  { 757, 9, 11, 11, -2, -5 },
  { 770, 11, 3, 13, 1, -14 },
  { 775, 5, 6, 11, 1, -5 },
  { 779, 22, 33, 16, -2, -33 },
  { 870, 20, 33, 23, 2, -33 },
  { 953, 13, 33, 23, 6, -33 },
  { 1007, 22, 33, 23, 0, -33 },
  { 1098, 22, 33, 23, 0, -33 },
  { 1189, 22, 33, 23, 0, -33 },
  { 1280, 21, 33, 23, 1, -33 },
  { 1367, 21, 33, 23, 2, -33 },
  { 1454, 21, 33, 23, 3, -33 },
  { 1541, 22, 33, 23, 1, -33 },
  { 1632, 21, 33, 23, 1, -33 },
  { 1719, 9, 26, 11, 1, -25 },
  { 1749, 12, 31, 11, -2, -25 },
  { 1796, 20, 21, 24, 3, -27 },
  { 1849, 19, 13, 24, 3, -23 },
  { 1880, 20, 21, 24, 3, -27 },
  { 1933, 17, 34, 17, 2, -33 },
  { 2006, 32, 37, 35, 2, -33 },
  { 2154, 24, 33, 23, -3, -33 },
  { 2253, 24, 33, 25, 1, -33 },
  { 2352, 23, 33, 24, 3, -33 },
  { 2447, 25, 33, 27, 1, -33 },
  { 2551, 22, 33, 21, 1, -33 },
  { 2642, 22, 33, 20, 1, -33 },
  { 2733, 25, 33, 28, 3, -33 },
  { 2837, 27, 33, 28, 1, -33 },
  { 2949, 18, 33, 14, -1, -33 },
  { 3024, 19, 42, 11, -7, -33 },
  { 3124, 26, 33, 23, 1, -33 },
  { 3232, 16, 33, 20, 1, -33 },
  { 3298, 35, 33, 35, 1, -33 },
  { 3443, 29, 33, 29, 1, -33 },
  { 3563, 25, 33, 29, 3, -33 },
  { 3667, 23, 33, 23, 1, -33 },
  { 3762, 25, 41, 29, 3, -33 },
  { 3891, 23, 33, 24, 1, -33 },
  { 3986, 22, 33, 21, 0, -33 },
  { 4077, 20, 33, 20, 4, -33 },
  { 4160, 25, 33, 28, 3, -33 },
  { 4264, 23, 33, 23, 4, -33 },
  { 4359, 35, 33, 36, 5, -33 },
  { 4504, 28, 33, 22, -3, -33 },
  { 4620, 21, 33, 21, 4, -33 },
  { 4707, 24, 33, 21, -1, -33 },
  { 4806, 18, 40, 13, -1, -33 },
  { 4896, 8, 33, 16, 5, -33 },
  { 4929, 17, 40, 13, -3, -33 },
  { 5014, 21, 20, 23, 1, -33 },
  { 5067, 17, 3, 17, -4, 4 },
  { 5074, 7, 7, 12, 7, -35 },
  { 5081, 21, 25, 24, 2, -25 },
  { 5147, 21, 35, 24, 1, -35 },
  { 5239, 17, 25, 19, 2, -25 },
  { 5293, 23, 35, 24, 2, -35 },
  { 5394, 18, 25, 21, 2, -25 },
  { 5451, 24, 46, 13, -5, -35 },
  { 5589, 23, 36, 24, 0, -25 },
  { 5693, 21, 35, 24, 1, -35 },
  { 5785, 11, 34, 11, 1, -34 },
  { 5832, 18, 45, 11, -6, -34 },
  { 5934, 21, 35, 21, 1, -35 },
  { 6026, 11, 35, 11, 1, -35 },
  { 6075, 33, 25, 36, 1, -25 },
  { 6179, 21, 25, 24, 1, -25 },
  { 6245, 19, 25, 23, 2, -25 },
  { 6305, 23, 36, 24, -1, -25 },
  { 6409, 21, 36, 24, 2, -25 },
  { 6504, 17, 25, 16, 1, -25 },
  { 6558, 18, 25, 18, 0, -25 },
  { 6615, 13, 30, 14, 2, -30 },
  { 6664, 21, 25, 24, 2, -25 },
  { 6730, 20, 25, 19, 2, -25 },
  { 6793, 29, 25, 30, 3, -25 },
  { 6884, 23, 25, 20, -2, -25 },
  { 6956, 26, 36, 19, -4, -25 },
  { 7073, 19, 25, 18, -1, -25 },
  { 7133, 17, 40, 16, 1, -33 },
  { 7218, 3, 46, 22, 10, -35 },
  { 7236, 17, 40, 16, -2, -33 },
  { 7321, 20, 6, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_Italic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Italic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Italic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_ITALIC46PT7B_H_
