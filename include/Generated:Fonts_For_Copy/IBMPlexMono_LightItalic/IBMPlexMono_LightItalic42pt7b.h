#ifndef _IBMPLEXMONO_LIGHTITALIC42PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0xF0, 0x70, 0xDC, 0x36, 0x0D, 0x83, 0x61,
  0xD8, 0x7E, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x38, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80,
  0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60,
  0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE0, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x80, 0x01, 0xC1, 0x80, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x80, 0x70,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xF1, 0x9F, 0x03,
  0x83, 0x0F, 0x0E, 0x06, 0x0E, 0x1C, 0x0C, 0x08, 0x30, 0x10, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x83, 0x00, 0x03, 0x86,
  0x00, 0x07, 0xC8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0x8F, 0x00, 0x02, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xE3, 0x01, 0x01, 0x8F,
  0x06, 0x07, 0x0F, 0x0C, 0x1C, 0x0F, 0x98, 0xF0, 0x07, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x1F, 0xE0, 0x06, 0x03, 0x87, 0x00,
  0xE0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C,
  0x03, 0x07, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x71,
  0xC0, 0x0C, 0x06, 0x18, 0x00, 0x61, 0xC3, 0x00, 0x07, 0xF8, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x61,
  0xFE, 0x00, 0x0E, 0x38, 0x70, 0x00, 0xC7, 0x03, 0x00, 0x18, 0x60, 0x18,
  0x03, 0x86, 0x01, 0x80, 0x30, 0xE0, 0x38, 0x06, 0x0C, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x30, 0x07, 0x0E,
  0x06, 0x00, 0x3F, 0xC0, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x1F, 0x1C, 0x00, 0x3D, 0xF8, 0x00, 0x70, 0x60, 0x00, 0x30, 0x38,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x0F, 0xC0, 0x0B, 0x06, 0x60,
  0x0D, 0xC6, 0x38, 0x04, 0x67, 0x0E, 0x0E, 0x3B, 0x03, 0xFE, 0x0F, 0x80,
  0xFC, 0x03, 0x80, 0x33, 0x77, 0x66, 0x66, 0xEE, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x1C, 0x0C, 0x07, 0x7E, 0x30, 0xFE, 0x7F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x39, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x30, 0x1C, 0x01, 0xC0,
  0x30, 0x0E, 0x00, 0xE0, 0x10, 0x02, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x0E, 0x1E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0x77,
  0xFF, 0xEF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xE0, 0x78, 0x0E, 0x00, 0xC0, 0xE0, 0x07, 0x0E, 0x00,
  0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x07, 0x03, 0xF0, 0x78, 0x1B, 0x83, 0xC0,
  0xDC, 0x1E, 0x0E, 0xE0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x07, 0x1C, 0x00, 0x30,
  0x60, 0x03, 0x83, 0x80, 0x38, 0x0E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x0E, 0x60,
  0x03, 0xC6, 0x00, 0x78, 0x60, 0x0E, 0x0E, 0x03, 0xC0, 0xE0, 0x18, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00,
  0xE0, 0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00,
  0x18, 0x08, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x08, 0x00, 0x18, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0,
  0x78, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0x70, 0xE0, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x1F, 0x80,
  0x1D, 0xFF, 0x80, 0x6C, 0x0F, 0x01, 0xC0, 0x0E, 0x02, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x08, 0x00, 0x38, 0xE0, 0x01, 0xC1,
  0xC0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x7F, 0x03, 0x3F, 0xF0, 0xEC, 0x0F, 0x1B, 0x00, 0x73, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x37, 0x00, 0x0E, 0xE0, 0x03, 0x8E, 0x00,
  0xE0, 0xE0, 0x78, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x60, 0x00, 0x6E, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00,
  0xE0, 0xC0, 0x03, 0x03, 0x80, 0x1C, 0x07, 0x81, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xC0, 0xF0, 0x18, 0x00, 0xE0, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x07,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3C, 0x0E,
  0x0E, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0x9C, 0x00, 0xB1, 0xE0, 0x6E, 0x1F, 0xF9, 0x81, 0xFC, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x1F, 0x1E, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0,
  0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0x03, 0xCF,
  0x00, 0xE7, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0x81, 0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x38, 0x1E, 0x33, 0x07, 0xFB, 0x30, 0x70, 0xB7, 0x0C,
  0x07, 0x60, 0xC0, 0x76, 0x18, 0x06, 0x61, 0x80, 0x66, 0x18, 0x06, 0x63,
  0x80, 0x6E, 0x38, 0x06, 0xC3, 0x00, 0xEC, 0x30, 0x0C, 0xC3, 0x00, 0xCC,
  0x38, 0x1C, 0xC1, 0x82, 0xCC, 0x1E, 0xFC, 0xC0, 0xFD, 0xCC, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x86,
  0x00, 0x0E, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0x80, 0x3C,
  0x1C, 0x00, 0x60, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80,
  0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1,
  0x80, 0x1C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x00, 0x0E,
  0x18, 0x00, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x06, 0x00,
  0x1C, 0x70, 0x00, 0x43, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x21, 0x80, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x60, 0x1E, 0x01, 0x80,
  0x1C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C,
  0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x70,
  0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0,
  0x0E, 0x06, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0xC7, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0xFC, 0xE0, 0x3F, 0xE7, 0x00, 0x03, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x07, 0x0C, 0x00,
  0x38, 0x70, 0x03, 0xC3, 0x80, 0x2E, 0x0F, 0x07, 0x60, 0x3F, 0xF3, 0x00,
  0x7E, 0x18, 0x00, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1C, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x07, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70,
  0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x20, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x40, 0x07,
  0x0C, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x78, 0x3C, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x83, 0x00, 0x07, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0x8F, 0x00, 0x00, 0xCF, 0x80, 0x00,
  0x6F, 0xE0, 0x00, 0x7E, 0x30, 0x00, 0x3E, 0x1C, 0x00, 0x1E, 0x06, 0x00,
  0x0E, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0xC0, 0x36, 0x0E, 0xC0, 0x76, 0x0C, 0xC0, 0x66, 0x0C, 0xC0,
  0xC6, 0x0C, 0xE0, 0xCE, 0x0C, 0x61, 0x8E, 0x1C, 0x63, 0x8C, 0x1C, 0x63,
  0x0C, 0x18, 0x36, 0x0C, 0x18, 0x3E, 0x0C, 0x18, 0x3C, 0x1C, 0x18, 0x3C,
  0x18, 0x38, 0x18, 0x18, 0x38, 0x10, 0x18, 0x30, 0x10, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x1F, 0x00, 0x18, 0x3E, 0x00,
  0x30, 0x6C, 0x00, 0x60, 0xDC, 0x00, 0xC1, 0x98, 0x03, 0x83, 0x30, 0x06,
  0x0E, 0x60, 0x0C, 0x1C, 0xE0, 0x18, 0x30, 0xC0, 0x30, 0x61, 0x80, 0xE0,
  0xC3, 0x81, 0xC1, 0x83, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18,
  0x1C, 0x18, 0x30, 0x18, 0x70, 0x60, 0x30, 0xE0, 0xC0, 0x71, 0x83, 0x80,
  0xE3, 0x07, 0x00, 0xC6, 0x0C, 0x01, 0x8C, 0x18, 0x03, 0xB8, 0x30, 0x03,
  0x70, 0x60, 0x06, 0xC1, 0xC0, 0x0D, 0x83, 0x80, 0x1F, 0x06, 0x00, 0x1E,
  0x0C, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x78,
  0x0E, 0x00, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00,
  0x07, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x76, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60,
  0x00, 0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80, 0x38,
  0x0E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x60, 0x03, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x38,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x03, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0,
  0x78, 0x0E, 0x00, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7,
  0x00, 0x07, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E,
  0x60, 0x00, 0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80,
  0x38, 0x0E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x81, 0x00, 0x0C, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00, 0x07,
  0xC0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x60, 0x03,
  0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x06, 0x18, 0x00, 0x38, 0x60, 0x03, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x38, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x03,
  0x81, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xF0, 0x38, 0x00, 0xF0,
  0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x83, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xF0, 0x00, 0x70,
  0xF0, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x61,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80,
  0x03, 0x86, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x60, 0x03, 0x81, 0xC0, 0x1C, 0x07,
  0x81, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x71,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xC0, 0x60, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06,
  0x03, 0x80, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x1D,
  0xC0, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0x60, 0x38, 0x18, 0xC0, 0xF0, 0x31, 0x81, 0xE0, 0xE3, 0x06, 0xC1, 0x86,
  0x0D, 0x83, 0x0C, 0x3B, 0x06, 0x18, 0x66, 0x1C, 0x30, 0xCC, 0x30, 0x63,
  0x18, 0x61, 0xC6, 0x30, 0xC3, 0x9C, 0x33, 0x86, 0x30, 0x66, 0x0C, 0x60,
  0xCC, 0x19, 0x81, 0x98, 0x33, 0x03, 0x70, 0x6E, 0x06, 0xC0, 0xD8, 0x0D,
  0x81, 0xB0, 0x1B, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0E, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63,
  0x80, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0C, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x30,
  0x70, 0x00, 0x71, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xCE, 0x00,
  0x0E, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x60, 0x30, 0x07, 0x01,
  0xC0, 0x70, 0x06, 0x03, 0x00, 0x30, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x38,
  0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x06, 0x40, 0x00, 0x28, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x46, 0x38, 0xC7, 0x18, 0xC3, 0x01, 0xF8, 0x60, 0xFF,
  0x8C, 0x3C, 0x19, 0x8E, 0x00, 0xF3, 0x80, 0x1E, 0xE0, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x07,
  0x9C, 0x01, 0xE3, 0x80, 0x6C, 0x3C, 0x19, 0x83, 0xFE, 0x3E, 0x1F, 0x07,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC3, 0xF0, 0x18, 0xFF, 0x81, 0x98, 0x3C, 0x1B, 0x00, 0xE1, 0xE0, 0x0E,
  0x3C, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x73, 0x00, 0x07, 0x30, 0x00,
  0x73, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00,
  0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0xF0, 0x03, 0x8F, 0x00, 0x70, 0xCC,
  0x0F, 0x0C, 0x7F, 0xC0, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0xF0, 0x38, 0x70, 0x07, 0x18, 0x00, 0xCE, 0x00, 0x23, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x13, 0x80, 0x07, 0x60, 0x01, 0x9C, 0x00, 0xC3,
  0x00, 0x70, 0xF0, 0x78, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xC3, 0x81,
  0xFF, 0x98, 0x1E, 0x0E, 0xC1, 0xC0, 0x16, 0x1C, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80,
  0x03, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x03, 0x86, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xC0, 0x17, 0x07, 0x83,
  0x30, 0x1F, 0xF1, 0x80, 0x3F, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1C, 0x07, 0x06, 0x00, 0x71, 0x80, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x3B,
  0x00, 0x0E, 0x60, 0x03, 0xCC, 0x0F, 0xE3, 0xFF, 0xF0, 0x7F, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x06, 0x60, 0x01, 0xCE,
  0x00, 0x71, 0xC0, 0x1C, 0x1E, 0x07, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFC, 0x38, 0x1F, 0xF9, 0x81, 0xE0, 0xEC, 0x1C, 0x01, 0x61, 0xC0,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x03, 0xC3, 0x80, 0x1E, 0x0C,
  0x01, 0x60, 0x78, 0x33, 0x01, 0xFF, 0x18, 0x03, 0xF0, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x30, 0x03, 0x81, 0xE0,
  0x78, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x0F, 0x81, 0xCF, 0xF8, 0x77, 0x0F, 0x19, 0x01,
  0xC6, 0x80, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x77, 0x00, 0x19, 0xC0,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0E, 0xE0, 0x03,
  0x38, 0x00, 0xCC, 0x00, 0x30, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x08, 0x1C, 0x0F, 0x07,
  0x07, 0x01, 0x83, 0x80, 0x61, 0xC0, 0x19, 0xC0, 0x0E, 0xE0, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x03, 0x00, 0xC0, 0xF0, 0x18, 0x07, 0x03, 0x00,
  0x70, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE1, 0xF8, 0x07, 0x3F, 0xE0, 0x33, 0x83, 0x81, 0xB0, 0x0C,
  0x0D, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x1C, 0x03, 0x07, 0x80, 0x39, 0xE0, 0x01,
  0xC7, 0x00, 0x0C, 0x18, 0x02, 0x60, 0xE0, 0x3B, 0x03, 0x03, 0x98, 0x1C,
  0x39, 0xC0, 0x63, 0x8E, 0x03, 0xB8, 0x60, 0x0F, 0x83, 0x00, 0x38, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x0C, 0x18, 0x0F, 0x1C, 0x0E, 0x0E, 0x1C, 0x06, 0x1C, 0x03, 0x1C, 0x01,
  0xB8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0C, 0xF0, 0x78, 0x3B, 0xF1, 0xF8,
  0x6C, 0x66, 0x38, 0xD0, 0x70, 0x71, 0xC0, 0xE0, 0x63, 0x01, 0x81, 0xC6,
  0x07, 0x03, 0x9C, 0x0E, 0x06, 0x30, 0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0,
  0x60, 0x31, 0x80, 0xC0, 0x63, 0x03, 0x81, 0xCE, 0x07, 0x03, 0x18, 0x0C,
  0x06, 0x30, 0x18, 0x0C, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x31, 0x81, 0xC0,
  0xE7, 0x03, 0x81, 0x8C, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x00, 0x1C, 0x3E,
  0x07, 0x3F, 0xE1, 0xDC, 0x3C, 0x64, 0x07, 0x1A, 0x00, 0xC7, 0x00, 0x33,
  0x80, 0x0C, 0xE0, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3C, 0x0E, 0x0E, 0x00, 0xE3, 0x80, 0x0C,
  0x60, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x36,
  0x00, 0x0E, 0xE0, 0x01, 0x8C, 0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x0F, 0x01,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x0F, 0xC0, 0x18, 0xFF, 0x80, 0x66,
  0x0F, 0x01, 0xB0, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x60, 0xE0, 0x01,
  0x83, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x70, 0xF0, 0x03, 0x83, 0xC0, 0x1C, 0x0C, 0xC0, 0xF0,
  0x31, 0xFF, 0x00, 0xC3, 0xF8, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x70, 0x7F, 0xE6, 0x0F, 0x07, 0x61,
  0xC0, 0x16, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C,
  0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x8E, 0x00,
  0x78, 0x60, 0x0B, 0x07, 0x83, 0x30, 0x3F, 0xE3, 0x00, 0xF8, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xFF, 0x87, 0xFF, 0xF9, 0xFF,
  0x03, 0xB0, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x81, 0xF0, 0xE0, 0x07,
  0x0C, 0x00, 0x21, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE6, 0x00, 0x0E, 0xF0,
  0x01, 0xC3, 0xC0, 0x78, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x40, 0x70, 0x0E, 0x06, 0x03, 0xC0, 0x60, 0x70, 0x06, 0x1E, 0x00,
  0x63, 0x80, 0x0E, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x67,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x0F,
  0x30, 0x05, 0x8E, 0x03, 0x61, 0xC1, 0x98, 0x7F, 0xC6, 0x07, 0xC3, 0x80,
  0xFF, 0x00, 0x6F, 0xE0, 0x0E, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x1C, 0x18,
  0x03, 0x81, 0x80, 0x38, 0x18, 0x07, 0x01, 0x80, 0xE0, 0x18, 0x3C, 0x03,
  0x8F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x18, 0x0C, 0x18, 0x60, 0x30,
  0x61, 0x81, 0xC1, 0x8E, 0x06, 0x07, 0x30, 0x18, 0x0C, 0xC0, 0x60, 0x33,
  0x01, 0x80, 0xCC, 0x06, 0x03, 0x30, 0x38, 0x0D, 0xC0, 0xC0, 0x36, 0x03,
  0x01, 0xD8, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x66, 0x07, 0x03,
  0xB8, 0x18, 0x0C, 0xE0, 0x60, 0x33, 0x82, 0x81, 0xCE, 0x0A, 0x0E, 0x18,
  0xCC, 0x70, 0x7E, 0x3F, 0x80, 0xF0, 0x7C, 0x00, 0x01, 0xC0, 0x7C, 0x07,
  0xE0, 0xFE, 0x0F, 0x71, 0x86, 0x3C, 0x33, 0x07, 0x70, 0x32, 0x07, 0x40,
  0x36, 0x07, 0x00, 0x34, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x58, 0x00, 0xC0, 0x58, 0x0C, 0xC0,
  0xD8, 0x1C, 0xC1, 0x9C, 0x78, 0xE3, 0x8D, 0xE0, 0x7F, 0x0F, 0xC0, 0x3C,
  0x07, 0x00, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xE0,
  0x16, 0x07, 0x01, 0xB0, 0x1C, 0x19, 0x80, 0xFF, 0x9C, 0x01, 0xF0, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x18, 0x01,
  0xC1, 0xF0, 0x3C, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x18,
  0x7F, 0xF8, 0xC7, 0x03, 0xFE, 0x30, 0x03, 0xF1, 0x80, 0x07, 0x1C, 0x00,
  0x70, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x1C, 0x03,
  0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x1F, 0xF0, 0x19, 0xDF,
  0xFC, 0xCE, 0x0F, 0xFE, 0x70, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x0C, 0x7F, 0x00, 0x61, 0x8E, 0x01, 0x8C, 0x1C, 0x0E, 0x60, 0x38,
  0x31, 0x80, 0x71, 0x8C, 0x00, 0xFC, 0x30, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 29, 25, 9, -29 },
  { 30, 10, 11, 25, 10, -31 },
  { 44, 25, 29, 25, 1, -29 },
  { 135, 23, 37, 25, 1, -33 },
  { 242, 28, 29, 25, -1, -29 },
  { 344, 25, 29, 25, 0, -29 },
  { 435, 4, 11, 25, 13, -31 },
  { 441, 15, 38, 25, 9, -32 },
  { 513, 15, 38, 25, 2, -32 },
  { 585, 22, 21, 25, 2, -23 },
  { 643, 20, 20, 25, 3, -23 },
  { 693, 8, 11, 25, 6, -5 },
  { 704, 12, 2, 25, 7, -14 },
  { 707, 5, 5, 25, 9, -5 },
  { 711, 24, 38, 25, 1, -32 },
  { 825, 21, 29, 25, 3, -29 },
  { 902, 20, 29, 25, 2, -29 },
  { 975, 22, 29, 25, 1, -29 },
  { 1055, 22, 29, 25, 1, -29 },
  { 1135, 22, 29, 25, 1, -29 },
  { 1215, 22, 29, 25, 2, -29 },
  { 1295, 19, 29, 25, 3, -29 },
  { 1364, 20, 29, 25, 5, -29 },
  { 1437, 22, 29, 25, 2, -29 },
  { 1517, 19, 29, 25, 4, -29 },
  { 1586, 8, 23, 25, 9, -23 },
  { 1609, 11, 29, 25, 6, -23 },
  { 1649, 20, 23, 25, 4, -24 },
  { 1707, 22, 10, 25, 2, -18 },
  { 1735, 20, 23, 25, 2, -24 },
  { 1793, 17, 29, 25, 6, -29 },
  { 1855, 20, 34, 25, 3, -29 },
  { 1940, 22, 29, 25, 0, -29 },
  { 2020, 21, 29, 25, 2, -29 },
  { 2097, 21, 29, 25, 3, -29 },
  { 2174, 22, 29, 25, 2, -29 },
  { 2254, 23, 29, 25, 2, -29 },
  { 2338, 23, 29, 25, 2, -29 },
  { 2422, 21, 29, 25, 3, -29 },
  { 2499, 23, 29, 25, 2, -29 },
  { 2583, 23, 29, 25, 2, -29 },
  { 2667, 20, 29, 25, 3, -29 },
  { 2740, 25, 29, 25, 2, -29 },
  { 2831, 17, 29, 25, 4, -29 },
  { 2893, 24, 29, 25, 1, -29 },
  { 2980, 23, 29, 25, 2, -29 },
  { 3064, 21, 29, 25, 3, -29 },
  { 3141, 22, 29, 25, 2, -29 },
  { 3221, 21, 36, 25, 3, -29 },
  { 3316, 22, 29, 25, 2, -29 },
  { 3396, 23, 29, 25, 1, -29 },
  { 3480, 23, 29, 25, 4, -29 },
  { 3564, 22, 29, 25, 3, -29 },
  { 3644, 21, 29, 25, 5, -29 },
  { 3721, 23, 29, 25, 3, -29 },
  { 3805, 27, 29, 25, 0, -29 },
  { 3903, 23, 29, 25, 4, -29 },
  { 3987, 26, 29, 25, 0, -29 },
  { 4082, 18, 38, 25, 7, -32 },
  { 4168, 10, 38, 25, 8, -32 },
  { 4216, 17, 38, 25, 1, -32 },
  { 4297, 21, 17, 25, 3, -29 },
  { 4342, 20, 2, 25, 0, 5 },
  { 4347, 5, 8, 25, 10, -33 },
  { 4352, 19, 22, 25, 3, -22 },
  { 4405, 20, 31, 25, 3, -31 },
  { 4483, 18, 22, 25, 3, -22 },
  { 4533, 21, 31, 25, 3, -31 },
  { 4615, 19, 22, 25, 3, -22 },
  { 4668, 27, 39, 25, -1, -31 },
  { 4800, 21, 30, 25, 2, -22 },
  { 4879, 18, 31, 25, 3, -31 },
  { 4949, 18, 31, 25, 4, -31 },
  { 5019, 19, 40, 25, 3, -32 },
  { 5114, 21, 31, 25, 3, -31 },
  { 5196, 17, 31, 25, 5, -31 },
  { 5262, 23, 22, 25, 1, -22 },
  { 5326, 18, 22, 25, 3, -22 },
  { 5376, 19, 22, 25, 3, -22 },
  { 5429, 22, 30, 25, 1, -22 },
  { 5512, 20, 30, 25, 3, -22 },
  { 5587, 20, 22, 25, 5, -22 },
  { 5642, 20, 22, 25, 2, -22 },
  { 5697, 20, 29, 25, 3, -29 },
  { 5770, 18, 22, 25, 4, -22 },
  { 5820, 20, 22, 25, 3, -22 },
  { 5875, 22, 22, 25, 2, -22 },
  { 5936, 24, 22, 25, 1, -22 },
  { 6002, 21, 30, 25, 1, -22 },
  { 6081, 21, 22, 25, 2, -22 },
  { 6139, 19, 38, 25, 5, -32 },
  { 6230, 8, 38, 25, 9, -32 },
  { 6268, 19, 38, 25, 2, -32 },
  { 6359, 22, 8, 25, 2, -17 },
};

const GFXfont IBMPlexMono_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_LIGHTITALIC42PT7B_H_
