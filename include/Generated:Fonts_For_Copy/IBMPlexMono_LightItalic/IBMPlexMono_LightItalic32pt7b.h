#ifndef _IBMPLEXMONO_LIGHTITALIC32PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x82,
  0x00, 0x00, 0x00, 0x38, 0xE3, 0x80, 0x31, 0x90, 0x98, 0xCC, 0x66, 0x33,
  0x19, 0x0C, 0x84, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x01, 0xF8,
  0x7F, 0x1F, 0x87, 0xF0, 0x18, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x07, 0xE1, 0xFC, 0x7E, 0x1F, 0x88, 0x61, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x08, 0x20, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x71,
  0x38, 0x60, 0x86, 0x30, 0xC1, 0x10, 0x60, 0x08, 0x20, 0x06, 0x10, 0x03,
  0x88, 0x00, 0xF4, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0x1C, 0x00, 0x86,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x6C, 0x18, 0x67, 0x08, 0x31, 0xE4,
  0x70, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x03, 0xE0, 0x0C, 0x1F, 0xC0, 0x60, 0xE3, 0x03, 0x03, 0x06, 0x08, 0x18,
  0x18, 0x60, 0x60, 0x63, 0x01, 0x81, 0x18, 0x06, 0x0C, 0x40, 0x1C, 0x73,
  0x00, 0x3F, 0x98, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x9F, 0xC0,
  0x0C, 0x61, 0x80, 0x23, 0x06, 0x01, 0x88, 0x18, 0x0C, 0x20, 0x60, 0x20,
  0x81, 0x81, 0x82, 0x04, 0x0C, 0x0C, 0x30, 0x60, 0x3F, 0x83, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1C, 0x38, 0x03, 0x03, 0x00, 0x60,
  0x20, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x61,
  0x80, 0x7F, 0xE0, 0x1C, 0xF0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x58, 0x07, 0x1F, 0x81, 0x73, 0x38, 0x66,
  0xC3, 0xF8, 0x78, 0x3E, 0x0E, 0x00, 0x6D, 0xA5, 0xB6, 0xC0, 0x00, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0xC1, 0x81, 0xF9, 0x9F, 0x3F, 0xF8, 0x07, 0xC0, 0x03, 0x80,
  0x06, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x30, 0x20, 0x20,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x1C, 0xE3, 0x8C, 0x71,
  0x84, 0x30, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE1, 0xC3, 0xC1, 0xC3, 0xC3,
  0x86, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0x60,
  0x18, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x3D, 0x80, 0xE3, 0x03, 0x86, 0x0E, 0x0C, 0x08, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0x07, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x03,
  0xFE, 0x07, 0x07, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x40, 0x0C, 0xE0, 0x0C, 0x70,
  0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x06, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x02, 0x18, 0x03, 0x08, 0x03, 0x0C,
  0x03, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0x81, 0x00, 0xC1, 0x00,
  0x61, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x33, 0xE0, 0x3F, 0xF8,
  0x38, 0x1C, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x33, 0xF0, 0x6F, 0xF1, 0xB0, 0x73, 0x80, 0x66, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x63,
  0x83, 0xC3, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x40, 0x08, 0x80, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x1E, 0x0F, 0x18, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x1C, 0x1C, 0x0F, 0xF8, 0x0F, 0xF0,
  0x38, 0x1C, 0x60, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x1C, 0xF0, 0x38, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0,
  0x3F, 0xF0, 0xF0, 0x73, 0x80, 0x66, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x73, 0x83, 0x63, 0xFD, 0x83, 0xF3,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x38, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x38, 0xE0, 0x0E, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60,
  0x40, 0xC0, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x20, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0F,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x03, 0xE0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0xF3, 0x31, 0xFA, 0x63, 0x8A,
  0x63, 0x06, 0x62, 0x06, 0x66, 0x06, 0x46, 0x06, 0x46, 0x04, 0xC6, 0x04,
  0xC6, 0x0C, 0xC6, 0x1C, 0xC7, 0xEC, 0xC3, 0xEC, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x02,
  0x30, 0x03, 0x08, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x60, 0x30, 0x3F, 0xF8, 0x3F, 0xFE, 0x18, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x0C, 0x1F, 0xF8, 0x1F,
  0xFC, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x02, 0x30, 0x03, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x1C, 0x3F, 0xF0, 0x7F, 0xF8, 0x60, 0x1C, 0x60,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xC0,
  0x33, 0x00, 0x66, 0x00, 0x98, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x0D, 0x80, 0x33, 0x80, 0xC3, 0x83, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xFC, 0x18, 0x1E, 0x18, 0x06, 0x18, 0x07, 0x18, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x40, 0x1C, 0xC0,
  0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC6,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC6, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC6, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C,
  0x07, 0x18, 0x03, 0x30, 0x02, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0xFE, 0xC0, 0xFE, 0xC0, 0x06, 0xC0, 0x04, 0xC0,
  0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x6C, 0x3F, 0xC8, 0x0F,
  0x98, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C,
  0x30, 0x03, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x40,
  0x19, 0x80, 0x63, 0x80, 0xC3, 0x87, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x18,
  0x01, 0xC6, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x18, 0x1C, 0x0C, 0x0E,
  0x03, 0x07, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x78, 0x01,
  0xB3, 0x00, 0x78, 0xC0, 0x1C, 0x18, 0x06, 0x06, 0x01, 0x81, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0C, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x2C, 0x78, 0x1B, 0x1A, 0x04,
  0x86, 0xC3, 0x61, 0x31, 0x98, 0xCC, 0x46, 0x31, 0x31, 0x8C, 0x68, 0x63,
  0x1E, 0x10, 0xC3, 0x0C, 0x20, 0x83, 0x18, 0x20, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x02, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x00, 0x0E, 0x00, 0xC3, 0x80, 0x20, 0xB0, 0x08, 0x2C, 0x06,
  0x1B, 0x01, 0x86, 0x40, 0x61, 0x98, 0x18, 0x66, 0x04, 0x11, 0x81, 0x04,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x43, 0x0C, 0x18, 0x82, 0x06,
  0x60, 0x81, 0x98, 0x60, 0x36, 0x18, 0x0D, 0x86, 0x03, 0x61, 0x80, 0x50,
  0x40, 0x1C, 0x30, 0x07, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C,
  0x06, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0x60, 0x18, 0x70, 0x70, 0x3F, 0xE0, 0x1F,
  0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x11,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x03,
  0x8F, 0xFF, 0x87, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C,
  0x60, 0x18, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0x00, 0x01, 0x84,
  0x01, 0x8E, 0x00, 0xDC, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0xFC, 0x0F, 0xFF,
  0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x11, 0x80, 0x0C, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x03, 0x8F, 0xFF, 0x87, 0xFF, 0x03,
  0x06, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x18, 0x30, 0x0C,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03,
  0x81, 0xC3, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x60, 0x03, 0x38, 0x03, 0x8F,
  0x03, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x8C, 0x00,
  0x86, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x04, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x20, 0x0C, 0x18, 0x06,
  0x0E, 0x0E, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x18, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x20, 0xC0, 0x20, 0xC0, 0x31,
  0x80, 0x31, 0x80, 0x33, 0x00, 0x33, 0x00, 0x36, 0x00, 0x16, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x09, 0x80, 0x02,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x1C, 0x11, 0x87, 0x0C, 0x61, 0x43, 0x18,
  0xD0, 0xC6, 0x24, 0x21, 0x19, 0x18, 0x46, 0x46, 0x11, 0x19, 0x84, 0xC6,
  0x43, 0x21, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x06, 0x83, 0xC1, 0xE0,
  0xE0, 0x38, 0x38, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x03, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x0C,
  0xC0, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x18,
  0xC0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C,
  0x07, 0x01, 0x83, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x03, 0x30, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20,
  0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C,
  0x04, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x0F, 0xF8, 0x7F,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x01,
  0xB0, 0x03, 0x10, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x0C, 0x18, 0x0C, 0x18,
  0x06, 0x30, 0x06, 0x60, 0x02, 0xC0, 0x03, 0x40, 0x02, 0xFF, 0xFF, 0xFF,
  0xFE, 0x4E, 0x62, 0x31, 0x07, 0xC6, 0x1F, 0xCC, 0xF0, 0x59, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x98, 0x0F, 0x1C, 0x36, 0x3F, 0xCF, 0x1F, 0x1E,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x78, 0x13, 0xFC, 0x6C, 0x18, 0xD0, 0x19, 0xC0, 0x33, 0x00,
  0x66, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0x66, 0x01, 0x9B, 0x0F, 0x33, 0xFC, 0x63, 0xE0, 0x03, 0xE0, 0x3F,
  0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x05, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x03, 0x60, 0x19, 0x80, 0xE3, 0x07, 0x0F,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x07, 0xC6, 0x0F, 0xF6, 0x1C, 0x16, 0x30,
  0x0E, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0xD8, 0x7F,
  0x98, 0x1F, 0x18, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x31, 0xC0, 0x33, 0x00,
  0x6C, 0x00, 0xD8, 0x07, 0x30, 0x7C, 0x7F, 0xE1, 0xFE, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0xCC, 0x03, 0x0C, 0x0E, 0x1F, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C,
  0x18, 0x00, 0xF0, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x1D, 0x80,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE3, 0x07, 0xFB, 0x0E, 0x0B,
  0x18, 0x07, 0x30, 0x06, 0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x1C, 0x38, 0x6C,
  0x1F, 0xCC, 0x0F, 0x88, 0x00, 0x18, 0x00, 0x18, 0x40, 0x30, 0xE0, 0x70,
  0x7F, 0xE0, 0x1F, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x3C, 0x1B, 0xF8, 0x68, 0x73, 0x40, 0xCE,
  0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80, 0x36,
  0x00, 0x98, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x20, 0xC3, 0xC3, 0x1C, 0x08, 0xE0, 0x6E,
  0x01, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x30,
  0x20, 0xF0, 0xC0, 0x71, 0x80, 0x73, 0x00, 0x76, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0xF0, 0x1B, 0xFC, 0x16, 0x0C, 0x34, 0x0C, 0x38,
  0x04, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x38, 0x20, 0xE0, 0x67, 0x80, 0x63,
  0x00, 0x63, 0x01, 0x61, 0x87, 0x61, 0x8E, 0x40, 0xDC, 0xC0, 0xF8, 0xC0,
  0x70, 0xFF, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x21, 0x03, 0x10, 0x73, 0x1C, 0x33, 0x83, 0x70, 0x3C, 0x03,
  0x80, 0x33, 0x87, 0x1B, 0xE7, 0xCE, 0x34, 0x66, 0x0C, 0x33, 0x06, 0x19,
  0x06, 0x0D, 0x83, 0x06, 0xC1, 0x83, 0x60, 0xC1, 0x30, 0x60, 0x98, 0x20,
  0xC8, 0x30, 0x6C, 0x18, 0x36, 0x0C, 0x1B, 0x06, 0x09, 0x82, 0x04, 0xC1,
  0x06, 0x00, 0x18, 0xF0, 0x6F, 0xE1, 0x21, 0xCD, 0x03, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x02, 0x60,
  0x19, 0x80, 0x64, 0x01, 0xB0, 0x06, 0xC0, 0x18, 0x03, 0xE0, 0x1F, 0xF0,
  0x70, 0x71, 0x80, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xCC, 0x03, 0x1C, 0x1C,
  0x1F, 0xF0, 0x0F, 0x80, 0x0C, 0x78, 0x09, 0xFE, 0x1B, 0x06, 0x1A, 0x03,
  0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x6C, 0x3C, 0x67, 0xF8,
  0x63, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xC6, 0x1F, 0xEC, 0x70, 0x59, 0x80, 0x76, 0x00, 0xCC,
  0x00, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00,
  0xCC, 0x03, 0x9C, 0x07, 0x1C, 0x36, 0x3F, 0xCC, 0x1F, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0xFE, 0x3F,
  0xFD, 0xFC, 0x16, 0x00, 0x68, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x39,
  0x80, 0x23, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x60, 0x00, 0xD8, 0x01, 0xBC, 0x0E, 0x3F, 0xF8,
  0x1F, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x0F,
  0xFF, 0xDF, 0xFF, 0xC1, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x02, 0x0C, 0x1E, 0x18, 0x70,
  0x33, 0xC0, 0x4E, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x30, 0x0D, 0x80, 0x36,
  0x00, 0xD8, 0x02, 0x60, 0x19, 0x80, 0x64, 0x01, 0xB0, 0x06, 0xC0, 0x1B,
  0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x02, 0xCE, 0x1B, 0x1F, 0xC8,
  0x3C, 0x60, 0x7C, 0x07, 0xF8, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x80, 0x61,
  0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0x80,
  0xC1, 0x03, 0x06, 0x0E, 0x0C, 0x78, 0x1F, 0xC0, 0x3E, 0x00, 0x30, 0xC2,
  0x20, 0xC3, 0x60, 0xC3, 0x60, 0xC3, 0x60, 0x83, 0x60, 0x83, 0x41, 0x83,
  0x41, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x03, 0xC3, 0x06, 0x83, 0x06,
  0x85, 0x0C, 0xC5, 0x9C, 0xF9, 0xF8, 0x70, 0xF0, 0x03, 0x83, 0x80, 0xF9,
  0xF8, 0x73, 0x33, 0x9C, 0x6C, 0x36, 0x05, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x01, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x16, 0x09, 0x82, 0xC7, 0x98, 0xD9, 0xC3, 0xF1, 0xE0, 0x3C, 0x38,
  0x00, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18,
  0x06, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x30, 0x2C, 0x38, 0x6C, 0x1F, 0xC8, 0x0F, 0x98, 0x00,
  0x18, 0x00, 0x18, 0x40, 0x30, 0xE0, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F,
  0x83, 0x3F, 0xF3, 0x30, 0x7E, 0x20, 0x0E, 0x60, 0x1C, 0x60, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x08, 0x18, 0x08, 0x70,
  0x0C, 0xF8, 0x0C, 0xFF, 0xC4, 0xCF, 0xFC, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x0C, 0x30,
  0xC2, 0x08, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x20, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x3F, 0x81,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x1C, 0x01, 0x3F, 0x03, 0x63, 0x02, 0x61, 0x86, 0xC1, 0xCC, 0xC0, 0xFC,
  0x80, 0x78,
};

const GFXglyph IBMPlexMono_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 22, 19, 7, -22 },
  { 18, 9, 9, 19, 7, -24 },
  { 29, 20, 22, 19, 0, -22 },
  { 84, 17, 28, 19, 1, -25 },
  { 144, 22, 22, 19, -1, -22 },
  { 205, 19, 22, 19, 0, -22 },
  { 258, 3, 9, 19, 10, -24 },
  { 262, 11, 28, 19, 7, -24 },
  { 301, 11, 28, 19, 2, -24 },
  { 340, 16, 16, 19, 2, -18 },
  { 372, 16, 16, 19, 2, -18 },
  { 404, 6, 9, 19, 5, -4 },
  { 411, 9, 2, 19, 5, -11 },
  { 414, 3, 3, 19, 7, -3 },
  { 416, 18, 28, 19, 1, -24 },
  { 479, 16, 22, 19, 2, -22 },
  { 523, 15, 22, 19, 1, -22 },
  { 565, 16, 22, 19, 1, -22 },
  { 609, 16, 22, 19, 1, -22 },
  { 653, 17, 22, 19, 1, -22 },
  { 700, 16, 22, 19, 2, -22 },
  { 744, 15, 22, 19, 2, -22 },
  { 786, 16, 22, 19, 3, -22 },
  { 830, 16, 22, 19, 2, -22 },
  { 874, 15, 22, 19, 3, -22 },
  { 916, 6, 17, 19, 7, -17 },
  { 929, 8, 22, 19, 5, -17 },
  { 951, 15, 18, 19, 3, -19 },
  { 985, 16, 8, 19, 2, -14 },
  { 1001, 15, 18, 19, 2, -19 },
  { 1035, 14, 22, 19, 4, -22 },
  { 1074, 16, 26, 19, 2, -22 },
  { 1126, 17, 22, 19, 0, -22 },
  { 1173, 16, 22, 19, 2, -22 },
  { 1217, 15, 22, 19, 3, -22 },
  { 1259, 16, 22, 19, 2, -22 },
  { 1303, 17, 22, 19, 2, -22 },
  { 1350, 17, 22, 19, 2, -22 },
  { 1397, 16, 22, 19, 2, -22 },
  { 1441, 18, 22, 19, 1, -22 },
  { 1491, 18, 22, 19, 1, -22 },
  { 1541, 15, 22, 19, 2, -22 },
  { 1583, 18, 22, 19, 2, -22 },
  { 1633, 13, 22, 19, 3, -22 },
  { 1669, 18, 22, 19, 1, -22 },
  { 1719, 18, 22, 19, 1, -22 },
  { 1769, 16, 22, 19, 2, -22 },
  { 1813, 17, 22, 19, 2, -22 },
  { 1860, 16, 28, 19, 2, -22 },
  { 1916, 17, 22, 19, 2, -22 },
  { 1963, 17, 22, 19, 1, -22 },
  { 2010, 18, 22, 19, 3, -22 },
  { 2060, 17, 22, 19, 2, -22 },
  { 2107, 16, 22, 19, 4, -22 },
  { 2151, 18, 22, 19, 2, -22 },
  { 2201, 20, 22, 19, 0, -22 },
  { 2256, 18, 22, 19, 3, -22 },
  { 2306, 19, 22, 19, 0, -22 },
  { 2359, 13, 28, 19, 6, -24 },
  { 2405, 8, 28, 19, 6, -24 },
  { 2433, 13, 28, 19, 1, -24 },
  { 2479, 16, 13, 19, 2, -22 },
  { 2505, 16, 2, 19, 0, 3 },
  { 2509, 4, 6, 19, 7, -25 },
  { 2512, 15, 17, 19, 2, -17 },
  { 2544, 15, 24, 19, 2, -24 },
  { 2589, 14, 17, 19, 2, -17 },
  { 2619, 16, 24, 19, 2, -24 },
  { 2667, 15, 17, 19, 2, -17 },
  { 2699, 21, 30, 19, -1, -24 },
  { 2778, 16, 23, 19, 1, -17 },
  { 2824, 14, 24, 19, 2, -24 },
  { 2866, 14, 24, 19, 3, -24 },
  { 2908, 15, 30, 19, 2, -24 },
  { 2965, 16, 24, 19, 2, -24 },
  { 3013, 12, 24, 19, 4, -24 },
  { 3049, 17, 17, 19, 1, -17 },
  { 3086, 14, 17, 19, 2, -17 },
  { 3116, 15, 17, 19, 2, -17 },
  { 3148, 16, 23, 19, 1, -17 },
  { 3194, 15, 23, 19, 2, -17 },
  { 3238, 15, 17, 19, 4, -17 },
  { 3270, 15, 17, 19, 2, -17 },
  { 3302, 15, 22, 19, 2, -22 },
  { 3344, 14, 17, 19, 3, -17 },
  { 3374, 15, 17, 19, 2, -17 },
  { 3406, 16, 17, 19, 2, -17 },
  { 3440, 19, 17, 19, 0, -17 },
  { 3481, 16, 23, 19, 1, -17 },
  { 3527, 16, 17, 19, 2, -17 },
  { 3561, 14, 28, 19, 4, -24 },
  { 3610, 6, 28, 19, 7, -24 },
  { 3631, 15, 28, 19, 1, -24 },
  { 3684, 16, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_LIGHTITALIC32PT7B_H_
