#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/IBMPlexMono_LightItalic
// Headers: 67

#include "IBMPlexMono_LightItalic6pt7b.h"
#include "IBMPlexMono_LightItalic7pt7b.h"
#include "IBMPlexMono_LightItalic8pt7b.h"
#include "IBMPlexMono_LightItalic9pt7b.h"
#include "IBMPlexMono_LightItalic10pt7b.h"
#include "IBMPlexMono_LightItalic11pt7b.h"
#include "IBMPlexMono_LightItalic12pt7b.h"
#include "IBMPlexMono_LightItalic13pt7b.h"
#include "IBMPlexMono_LightItalic14pt7b.h"
#include "IBMPlexMono_LightItalic15pt7b.h"
#include "IBMPlexMono_LightItalic16pt7b.h"
#include "IBMPlexMono_LightItalic17pt7b.h"
#include "IBMPlexMono_LightItalic18pt7b.h"
#include "IBMPlexMono_LightItalic19pt7b.h"
#include "IBMPlexMono_LightItalic20pt7b.h"
#include "IBMPlexMono_LightItalic21pt7b.h"
#include "IBMPlexMono_LightItalic22pt7b.h"
#include "IBMPlexMono_LightItalic23pt7b.h"
#include "IBMPlexMono_LightItalic24pt7b.h"
#include "IBMPlexMono_LightItalic25pt7b.h"
#include "IBMPlexMono_LightItalic26pt7b.h"
#include "IBMPlexMono_LightItalic27pt7b.h"
#include "IBMPlexMono_LightItalic28pt7b.h"
#include "IBMPlexMono_LightItalic29pt7b.h"
#include "IBMPlexMono_LightItalic30pt7b.h"
#include "IBMPlexMono_LightItalic31pt7b.h"
#include "IBMPlexMono_LightItalic32pt7b.h"
#include "IBMPlexMono_LightItalic33pt7b.h"
#include "IBMPlexMono_LightItalic34pt7b.h"
#include "IBMPlexMono_LightItalic35pt7b.h"
#include "IBMPlexMono_LightItalic36pt7b.h"
#include "IBMPlexMono_LightItalic37pt7b.h"
#include "IBMPlexMono_LightItalic38pt7b.h"
#include "IBMPlexMono_LightItalic39pt7b.h"
#include "IBMPlexMono_LightItalic40pt7b.h"
#include "IBMPlexMono_LightItalic41pt7b.h"
#include "IBMPlexMono_LightItalic42pt7b.h"
#include "IBMPlexMono_LightItalic43pt7b.h"
#include "IBMPlexMono_LightItalic44pt7b.h"
#include "IBMPlexMono_LightItalic45pt7b.h"
#include "IBMPlexMono_LightItalic46pt7b.h"
#include "IBMPlexMono_LightItalic47pt7b.h"
#include "IBMPlexMono_LightItalic48pt7b.h"
#include "IBMPlexMono_LightItalic49pt7b.h"
#include "IBMPlexMono_LightItalic50pt7b.h"
#include "IBMPlexMono_LightItalic51pt7b.h"
#include "IBMPlexMono_LightItalic52pt7b.h"
#include "IBMPlexMono_LightItalic53pt7b.h"
#include "IBMPlexMono_LightItalic54pt7b.h"
#include "IBMPlexMono_LightItalic55pt7b.h"
#include "IBMPlexMono_LightItalic56pt7b.h"
#include "IBMPlexMono_LightItalic57pt7b.h"
#include "IBMPlexMono_LightItalic58pt7b.h"
#include "IBMPlexMono_LightItalic59pt7b.h"
#include "IBMPlexMono_LightItalic60pt7b.h"
#include "IBMPlexMono_LightItalic61pt7b.h"
#include "IBMPlexMono_LightItalic62pt7b.h"
#include "IBMPlexMono_LightItalic63pt7b.h"
#include "IBMPlexMono_LightItalic64pt7b.h"
#include "IBMPlexMono_LightItalic65pt7b.h"
#include "IBMPlexMono_LightItalic66pt7b.h"
#include "IBMPlexMono_LightItalic67pt7b.h"
#include "IBMPlexMono_LightItalic68pt7b.h"
#include "IBMPlexMono_LightItalic69pt7b.h"
#include "IBMPlexMono_LightItalic70pt7b.h"
#include "IBMPlexMono_LightItalic71pt7b.h"
#include "IBMPlexMono_LightItalic72pt7b.h"
