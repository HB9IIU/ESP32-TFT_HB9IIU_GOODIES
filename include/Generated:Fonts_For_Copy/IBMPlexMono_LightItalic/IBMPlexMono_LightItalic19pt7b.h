#ifndef _IBMPLEXMONO_LIGHTITALIC19PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x44, 0x40, 0x0C, 0xC0, 0x4A, 0x52, 0x9D, 0x00,
  0x02, 0x40, 0x64, 0x04, 0x40, 0x48, 0x38, 0xF0, 0x88, 0x09, 0x01, 0x10,
  0xF1, 0xC1, 0x20, 0x22, 0x02, 0x40, 0x24, 0x00, 0x02, 0x00, 0x81, 0xF0,
  0x93, 0x44, 0x91, 0x04, 0x40, 0xE0, 0x1E, 0x02, 0x60, 0x88, 0x22, 0x89,
  0xB4, 0xC3, 0xE0, 0x40, 0x10, 0x00, 0x1C, 0x12, 0x22, 0x42, 0x24, 0x24,
  0x44, 0x83, 0x90, 0x00, 0x00, 0x9C, 0x12, 0x22, 0x42, 0x44, 0x24, 0x44,
  0x83, 0x80, 0x0F, 0x03, 0x10, 0x42, 0x08, 0x41, 0x08, 0x12, 0x0F, 0x82,
  0x20, 0x84, 0x10, 0x42, 0x14, 0xE2, 0xA7, 0x8C, 0x6A, 0x80, 0x06, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x30, 0x10, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20,
  0x81, 0x04, 0x10, 0xC0, 0x04, 0x01, 0x00, 0x43, 0x13, 0x3F, 0x03, 0x01,
  0x40, 0x88, 0x43, 0x00, 0x04, 0x02, 0x01, 0x00, 0x8F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x6D, 0x68, 0xFC, 0xF0, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x22, 0x0D, 0x01, 0x40, 0x53,
  0x1C, 0xCE, 0x02, 0x80, 0xA0, 0x2C, 0x11, 0x08, 0x3C, 0x00, 0x06, 0x0D,
  0x0C, 0x8C, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x0F,
  0xF8, 0x1F, 0x18, 0xC8, 0x28, 0x10, 0x08, 0x0C, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x0F, 0xF0, 0x1F, 0x18, 0xC8, 0x20, 0x10, 0x08, 0x08, 0x78,
  0x06, 0x01, 0x00, 0xA0, 0x58, 0x67, 0xC0, 0x00, 0xC0, 0x50, 0x28, 0x1A,
  0x0C, 0x82, 0x21, 0x08, 0x82, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00,
  0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x17, 0x86, 0x10, 0x02, 0x00, 0x80,
  0x68, 0x13, 0x0C, 0x3C, 0x00, 0x03, 0x02, 0x06, 0x02, 0x02, 0x02, 0xF9,
  0x86, 0x81, 0xC0, 0xC0, 0x70, 0x48, 0x63, 0xC0, 0x7F, 0xC0, 0x60, 0x50,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x00, 0x0F,
  0x0C, 0x22, 0x05, 0x81, 0x20, 0x88, 0x61, 0xE1, 0x84, 0x80, 0xA0, 0x28,
  0x1B, 0x0C, 0x7E, 0x00, 0x3E, 0x30, 0xB0, 0x50, 0x28, 0x1C, 0x0B, 0x0C,
  0xFE, 0x02, 0x02, 0x02, 0x02, 0x0E, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x4C, 0x80, 0x00, 0x81, 0x83, 0x02, 0x06, 0x04,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x0C, 0x18, 0x30, 0x30, 0x20,
  0x00, 0x3D, 0x86, 0x08, 0x10, 0x20, 0x43, 0x18, 0x20, 0x40, 0x03, 0x06,
  0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x7A, 0x45, 0x22, 0xA1, 0x90, 0xC8,
  0xE7, 0xD1, 0x04, 0x02, 0x00, 0xF8, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09,
  0x82, 0x21, 0x08, 0x42, 0x3F, 0x88, 0x24, 0x09, 0x03, 0x80, 0x40, 0x3F,
  0x10, 0x48, 0x24, 0x16, 0x0A, 0x09, 0xF8, 0x83, 0x40, 0xA0, 0x70, 0x70,
  0x2F, 0xE0, 0x1E, 0x10, 0x90, 0x28, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x41, 0x20, 0xD8, 0xC7, 0xC0, 0x3F, 0x08, 0x62, 0x08, 0x83, 0x20, 0x58,
  0x34, 0x0D, 0x02, 0x40, 0x90, 0x24, 0x12, 0x08, 0xFC, 0x00, 0x3F, 0xC8,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x07, 0xF9, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0xFF, 0x00, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60, 0x10, 0x07, 0xF9,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x22, 0x05,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x1E, 0xC0, 0xB0, 0x24, 0x11, 0x8C, 0x3D,
  0x00, 0x20, 0x48, 0x12, 0x05, 0x83, 0x40, 0x90, 0x27, 0xF9, 0x02, 0x40,
  0xB0, 0x48, 0x12, 0x04, 0x81, 0x00, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0x00, 0x1F,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x88,
  0xC3, 0xC0, 0x20, 0x64, 0x10, 0x84, 0x11, 0x06, 0x40, 0x90, 0x15, 0x03,
  0x20, 0x42, 0x08, 0x43, 0x0C, 0x40, 0x88, 0x18, 0x20, 0x41, 0x82, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x0F, 0xE0, 0x20, 0x4C, 0x35, 0x15,
  0x49, 0x5A, 0x53, 0x24, 0xC9, 0x22, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x00, 0x30, 0x4C, 0x13, 0x05, 0xA3, 0x48, 0x92, 0x24, 0xC9, 0x12, 0x44,
  0xA1, 0x48, 0x32, 0x0C, 0x83, 0x00, 0x0F, 0x04, 0x22, 0x0D, 0x01, 0x40,
  0x50, 0x1C, 0x0E, 0x02, 0x80, 0xA0, 0x2C, 0x11, 0x08, 0x3C, 0x00, 0x3F,
  0x88, 0x32, 0x04, 0x81, 0x60, 0x50, 0x27, 0xF1, 0x00, 0x40, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x22, 0x0D, 0x01, 0x40, 0x50, 0x1C,
  0x0E, 0x02, 0x80, 0xA0, 0x2C, 0x11, 0x08, 0x3C, 0x02, 0x20, 0x50, 0x18,
  0x3F, 0x88, 0x32, 0x04, 0x81, 0x60, 0x50, 0x27, 0xF1, 0x10, 0x44, 0x10,
  0x8C, 0x22, 0x0C, 0x81, 0x00, 0x1F, 0x08, 0x34, 0x09, 0x00, 0x40, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x80, 0x28, 0x1B, 0x0C, 0x3E, 0x00, 0xFF, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x00, 0x20, 0x48, 0x12, 0x05, 0x83, 0x40, 0x90, 0x24, 0x09,
  0x02, 0x40, 0xB0, 0x44, 0x11, 0x0C, 0x3C, 0x00, 0x80, 0x60, 0x24, 0x09,
  0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x64, 0x0A, 0x02, 0x80, 0xC0, 0x30,
  0x00, 0x40, 0x28, 0x05, 0x01, 0x22, 0x24, 0xC4, 0x98, 0x95, 0x22, 0xA4,
  0x94, 0x94, 0x62, 0x8C, 0x61, 0x8C, 0x30, 0x30, 0x31, 0x06, 0x08, 0x40,
  0x88, 0x05, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x09, 0x01, 0x10, 0x20, 0x84,
  0x08, 0xC0, 0x40, 0x80, 0x70, 0x24, 0x19, 0x0C, 0x22, 0x09, 0x01, 0xC0,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00, 0x1F, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0xC0, 0x1F, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x88, 0x88, 0x84,
  0x44, 0x42, 0x22, 0x21, 0x11, 0x10, 0x1F, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x06,
  0x03, 0x80, 0x90, 0x44, 0x20, 0x98, 0x2C, 0x0C, 0xFF, 0x80, 0xC8, 0x80,
  0x1E, 0x91, 0x50, 0x68, 0x3C, 0x14, 0x0A, 0x05, 0x06, 0x45, 0x3C, 0xC0,
  0x30, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x8D, 0x82, 0x81, 0x40, 0xA0, 0x50,
  0x28, 0x2A, 0x34, 0xF0, 0x1E, 0x10, 0x90, 0x68, 0x04, 0x06, 0x01, 0x00,
  0x82, 0x42, 0x1E, 0x00, 0x00, 0x40, 0x10, 0x08, 0x02, 0x1E, 0x88, 0x64,
  0x09, 0x02, 0xC1, 0x20, 0x48, 0x12, 0x0C, 0x45, 0x1E, 0xC0, 0x1F, 0x18,
  0xD8, 0x28, 0x14, 0x37, 0xE3, 0x00, 0x83, 0x43, 0x1E, 0x00, 0x01, 0xF0,
  0x10, 0x02, 0x00, 0x20, 0x3F, 0xE0, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x88, 0x04, 0x80, 0x28, 0x01,
  0x80, 0x1E, 0x90, 0xD0, 0x28, 0x1C, 0x14, 0x0A, 0x05, 0x06, 0x45, 0x1C,
  0x80, 0x80, 0x48, 0x63, 0xC0, 0x10, 0x18, 0x08, 0x04, 0x02, 0xF1, 0x88,
  0x82, 0xC1, 0x41, 0xA0, 0x90, 0x48, 0x24, 0x14, 0x08, 0x0C, 0x08, 0x00,
  0x00, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x20, 0x23, 0x26, 0x28, 0x30, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0xF0, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x23, 0x10, 0x48, 0x14, 0x06, 0x00, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x2F, 0x0C, 0x62, 0x09, 0x84, 0x43, 0x17, 0x04, 0x89, 0x23, 0x45,
  0x21, 0x80, 0xF8, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x23, 0x24, 0x38, 0x70, 0x2C, 0xC6, 0x64, 0x88, 0x91, 0x14, 0x44, 0x88,
  0x91, 0x12, 0x22, 0x44, 0x59, 0x98, 0x2F, 0x18, 0x88, 0x2C, 0x14, 0x1A,
  0x09, 0x04, 0x82, 0x41, 0x40, 0x80, 0x1E, 0x10, 0x90, 0x28, 0x1C, 0x0C,
  0x06, 0x06, 0x82, 0x43, 0x1E, 0x00, 0x2F, 0x18, 0xD8, 0x28, 0x14, 0x0A,
  0x05, 0x02, 0x82, 0xA3, 0x4F, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x90,
  0xD0, 0x28, 0x1C, 0x14, 0x0A, 0x05, 0x06, 0x45, 0x3C, 0x80, 0x80, 0x40,
  0x20, 0x10, 0xF3, 0x8E, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x00, 0x1F, 0x10, 0x50, 0x0C, 0x03, 0xC0, 0x18, 0x04, 0x02, 0xC1,
  0x1F, 0x00, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x44, 0xC5, 0x83, 0x80, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x8E, 0x8A, 0x76, 0xF0, 0x88, 0x48, 0x24, 0x12, 0x09, 0x0C, 0x84, 0x44,
  0x26, 0x3C, 0x00, 0x44, 0x91, 0x14, 0x45, 0x11, 0x48, 0x62, 0x18, 0x8A,
  0x22, 0x99, 0x39, 0x80, 0x18, 0xE4, 0xA5, 0x18, 0x83, 0x10, 0x40, 0x08,
  0x21, 0x04, 0x62, 0x8A, 0xAE, 0x60, 0x20, 0x90, 0x50, 0x28, 0x24, 0x12,
  0x09, 0x04, 0x86, 0x45, 0x1D, 0x80, 0x80, 0x48, 0x43, 0xC0, 0x3C, 0xD0,
  0xE4, 0x10, 0x08, 0x04, 0x06, 0x03, 0x11, 0x04, 0xF8, 0xA3, 0xC0, 0x0F,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x10, 0xF0, 0x0C, 0x02, 0x01,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x3C, 0x00, 0x11, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0x88, 0x80, 0x1E, 0x01, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x10, 0x07, 0x8C, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0xF0, 0x00,
  0x30, 0x52, 0x28, 0x4A, 0x1C,
};

const GFXglyph IBMPlexMono_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 13, 11, 4, -13 },
  { 8, 5, 5, 11, 4, -14 },
  { 12, 12, 13, 11, 0, -13 },
  { 32, 10, 17, 11, 1, -15 },
  { 54, 12, 13, 11, 0, -13 },
  { 74, 11, 13, 11, 0, -13 },
  { 92, 2, 5, 11, 6, -14 },
  { 94, 7, 17, 11, 4, -14 },
  { 109, 7, 17, 11, 1, -14 },
  { 124, 10, 9, 11, 1, -10 },
  { 136, 9, 9, 11, 1, -10 },
  { 147, 3, 5, 11, 3, -2 },
  { 149, 6, 1, 11, 3, -6 },
  { 150, 2, 2, 11, 4, -2 },
  { 151, 10, 17, 11, 1, -14 },
  { 173, 10, 13, 11, 1, -13 },
  { 190, 9, 13, 11, 1, -13 },
  { 205, 9, 13, 11, 1, -13 },
  { 220, 9, 13, 11, 1, -13 },
  { 235, 10, 13, 11, 0, -13 },
  { 252, 10, 13, 11, 1, -13 },
  { 269, 9, 13, 11, 1, -13 },
  { 284, 9, 13, 11, 2, -13 },
  { 299, 10, 13, 11, 1, -13 },
  { 316, 9, 13, 11, 2, -13 },
  { 331, 3, 10, 11, 4, -10 },
  { 335, 4, 13, 11, 3, -10 },
  { 342, 9, 11, 11, 2, -11 },
  { 355, 10, 4, 11, 1, -8 },
  { 360, 9, 11, 11, 1, -11 },
  { 373, 7, 13, 11, 3, -13 },
  { 385, 9, 15, 11, 1, -13 },
  { 402, 10, 13, 11, 0, -13 },
  { 419, 9, 13, 11, 1, -13 },
  { 434, 9, 13, 11, 2, -13 },
  { 449, 10, 13, 11, 1, -13 },
  { 466, 10, 13, 11, 1, -13 },
  { 483, 10, 13, 11, 1, -13 },
  { 500, 10, 13, 11, 1, -13 },
  { 517, 10, 13, 11, 1, -13 },
  { 534, 10, 13, 11, 1, -13 },
  { 551, 9, 13, 11, 1, -13 },
  { 566, 11, 13, 11, 1, -13 },
  { 584, 7, 13, 11, 2, -13 },
  { 596, 10, 13, 11, 1, -13 },
  { 613, 10, 13, 11, 1, -13 },
  { 630, 10, 13, 11, 1, -13 },
  { 647, 10, 13, 11, 1, -13 },
  { 664, 10, 16, 11, 1, -13 },
  { 684, 10, 13, 11, 1, -13 },
  { 701, 10, 13, 11, 1, -13 },
  { 718, 10, 13, 11, 2, -13 },
  { 735, 10, 13, 11, 1, -13 },
  { 752, 10, 13, 11, 2, -13 },
  { 769, 11, 13, 11, 1, -13 },
  { 787, 12, 13, 11, 0, -13 },
  { 807, 10, 13, 11, 2, -13 },
  { 824, 12, 13, 11, 0, -13 },
  { 844, 8, 17, 11, 3, -14 },
  { 861, 4, 17, 11, 4, -14 },
  { 870, 8, 17, 11, 0, -14 },
  { 887, 10, 7, 11, 1, -13 },
  { 896, 9, 1, 11, 0, 2 },
  { 898, 3, 3, 11, 4, -14 },
  { 900, 9, 10, 11, 1, -10 },
  { 912, 9, 14, 11, 1, -14 },
  { 928, 9, 10, 11, 1, -10 },
  { 940, 10, 14, 11, 1, -14 },
  { 958, 9, 10, 11, 1, -10 },
  { 970, 12, 18, 11, 0, -14 },
  { 997, 9, 14, 11, 1, -10 },
  { 1013, 9, 14, 11, 1, -14 },
  { 1029, 8, 14, 11, 2, -14 },
  { 1043, 9, 18, 11, 1, -14 },
  { 1064, 10, 14, 11, 1, -14 },
  { 1082, 8, 14, 11, 2, -14 },
  { 1096, 11, 10, 11, 0, -10 },
  { 1110, 9, 10, 11, 1, -10 },
  { 1122, 9, 10, 11, 1, -10 },
  { 1134, 9, 14, 11, 1, -10 },
  { 1150, 9, 14, 11, 1, -10 },
  { 1166, 9, 10, 11, 2, -10 },
  { 1178, 9, 10, 11, 1, -10 },
  { 1190, 9, 13, 11, 1, -13 },
  { 1205, 8, 10, 11, 2, -10 },
  { 1215, 9, 10, 11, 1, -10 },
  { 1227, 10, 10, 11, 1, -10 },
  { 1240, 11, 10, 11, 0, -10 },
  { 1254, 9, 14, 11, 1, -10 },
  { 1270, 10, 10, 11, 1, -10 },
  { 1283, 9, 17, 11, 2, -14 },
  { 1303, 4, 17, 11, 4, -14 },
  { 1312, 9, 17, 11, 1, -14 },
  { 1332, 10, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_LIGHTITALIC19PT7B_H_
