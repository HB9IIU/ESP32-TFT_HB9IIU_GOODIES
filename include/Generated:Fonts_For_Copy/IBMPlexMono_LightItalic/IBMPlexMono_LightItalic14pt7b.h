#ifndef _IBMPLEXMONO_LIGHTITALIC14PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x25, 0x00, 0xD0, 0x59, 0xAA, 0x09, 0x05, 0x04, 0x8E, 0x71,
  0x41, 0x23, 0x9C, 0x50, 0x48, 0x24, 0x00, 0x04, 0x1E, 0x29, 0x48, 0x28,
  0x38, 0x0E, 0x12, 0x12, 0xD2, 0x3C, 0x10, 0x38, 0xA4, 0x92, 0x89, 0x47,
  0x40, 0x30, 0xA4, 0x92, 0x51, 0x47, 0x00, 0x1C, 0x22, 0x22, 0x22, 0x34,
  0x58, 0x88, 0x89, 0x8D, 0x72, 0x6A, 0x19, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x20, 0x86, 0x00, 0x20, 0x84, 0x20, 0x84, 0x22, 0x10, 0x88, 0x88, 0x00,
  0x10, 0x22, 0x4B, 0xE3, 0x09, 0x22, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x04,
  0x08, 0x00, 0x6A, 0x40, 0xF0, 0xE0, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x3C, 0xC5, 0x0C, 0x18, 0x32,
  0x61, 0x42, 0x8C, 0xE0, 0x18, 0xA4, 0xA4, 0x10, 0x41, 0x04, 0x13, 0xF0,
  0x1E, 0x22, 0x21, 0x02, 0x02, 0x04, 0x08, 0x10, 0x60, 0xFE, 0x1E, 0x23,
  0x01, 0x02, 0x1C, 0x06, 0x02, 0x02, 0xC4, 0x38, 0x02, 0x06, 0x0A, 0x12,
  0x22, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x3E, 0x81, 0x02, 0x07, 0x88, 0x81,
  0x02, 0x8C, 0xF0, 0x0C, 0x42, 0x1E, 0x46, 0x18, 0x61, 0x8D, 0xE0, 0xFE,
  0x18, 0x82, 0x10, 0x82, 0x10, 0x42, 0x00, 0x3C, 0x85, 0x0A, 0x23, 0x98,
  0xA1, 0x42, 0x84, 0xF0, 0x3C, 0x86, 0x0C, 0x1C, 0x6F, 0x83, 0x04, 0x10,
  0xC0, 0x68, 0x00, 0x34, 0x32, 0x00, 0x00, 0x64, 0x88, 0x02, 0x18, 0xC2,
  0x0C, 0x04, 0x06, 0x02, 0xFE, 0x00, 0x07, 0xE0, 0x40, 0x81, 0x81, 0x04,
  0x66, 0x20, 0x7A, 0x18, 0x42, 0x19, 0x84, 0x00, 0x41, 0x00, 0x3C, 0xC5,
  0x0C, 0xDA, 0x54, 0xA9, 0x52, 0x9D, 0x02, 0x03, 0xC0, 0x0C, 0x18, 0x50,
  0xA2, 0x44, 0x4F, 0xA1, 0x43, 0x04, 0x7C, 0x85, 0x0A, 0x27, 0x90, 0xA1,
  0x42, 0x85, 0xF0, 0x1C, 0x45, 0x0C, 0x08, 0x10, 0x20, 0x42, 0xC4, 0xF0,
  0x7C, 0x89, 0x0A, 0x14, 0x30, 0x61, 0x42, 0x8D, 0xE0, 0x7E, 0x81, 0x02,
  0x07, 0xD0, 0x20, 0x40, 0x81, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xD0, 0x20,
  0x40, 0x81, 0x00, 0x3C, 0xC5, 0x0C, 0x08, 0x13, 0xA1, 0x42, 0x8C, 0xE8,
  0x42, 0x85, 0x0C, 0x17, 0xD0, 0xA1, 0x42, 0x85, 0x08, 0x7E, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x21, 0xF8, 0x3E, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x44, 0x88, 0xE0, 0x43, 0x44, 0x48, 0x50, 0xB0, 0xD0, 0x88, 0x88, 0x84,
  0x84, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x83, 0xF0, 0x21, 0x33, 0x55,
  0x55, 0x49, 0x4A, 0x42, 0x42, 0x82, 0x82, 0x62, 0xC5, 0x8D, 0x19, 0x52,
  0xA5, 0x4A, 0x8D, 0x18, 0x3C, 0xC5, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x8C,
  0xE0, 0x7C, 0x85, 0x0A, 0x18, 0x3F, 0xA0, 0x40, 0x81, 0x00, 0x3C, 0xC5,
  0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x40, 0xA0, 0x80, 0x7C, 0x85,
  0x0A, 0x18, 0x3F, 0xA4, 0x44, 0x89, 0x08, 0x1E, 0x21, 0x40, 0x20, 0x38,
  0x06, 0x02, 0x02, 0xC2, 0x3C, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x42, 0x85, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x8C, 0xF0,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0x60, 0x80, 0x81, 0x82, 0x82,
  0x92, 0xB2, 0xB4, 0xAC, 0xCC, 0xCC, 0x88, 0x21, 0x90, 0x84, 0x82, 0x80,
  0x80, 0x40, 0x50, 0x48, 0x42, 0x41, 0x00, 0x81, 0x42, 0x44, 0x28, 0x28,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x7F, 0x00, 0x3C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0xF0, 0x92, 0x49, 0x12, 0x48, 0x92, 0x3C, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0xF0, 0x18, 0x30, 0x92, 0x28, 0x30, 0x80,
  0xFE, 0xA4, 0x3D, 0x18, 0x61, 0x86, 0x67, 0x40, 0x40, 0x81, 0x02, 0xE6,
  0x48, 0x61, 0x42, 0x85, 0xF0, 0x39, 0x18, 0x20, 0x86, 0x27, 0x00, 0x02,
  0x04, 0x09, 0xE4, 0xD0, 0xA1, 0x42, 0x9C, 0xF0, 0x3D, 0x18, 0x7E, 0x82,
  0x17, 0x80, 0x07, 0x82, 0x02, 0x07, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x24, 0x0A, 0x03, 0x00, 0x3E, 0x9A, 0x14, 0x28, 0x51, 0x9E, 0x04,
  0x89, 0xE0, 0x61, 0x04, 0x17, 0x65, 0x18, 0x61, 0x86, 0x20, 0x18, 0x00,
  0x3C, 0x10, 0x82, 0x09, 0x38, 0xC0, 0x04, 0x00, 0x1F, 0x08, 0x20, 0x82,
  0x08, 0x29, 0x1C, 0x30, 0x40, 0x81, 0x02, 0xE6, 0x48, 0xA6, 0x51, 0x97,
  0x10, 0xE1, 0x08, 0x84, 0x21, 0x09, 0xB2, 0x00, 0x5B, 0x6D, 0x49, 0x49,
  0x52, 0x92, 0x92, 0x5D, 0x94, 0x61, 0x86, 0x18, 0x80, 0x39, 0x18, 0x61,
  0x86, 0x37, 0x80, 0x2E, 0x32, 0x21, 0x42, 0x42, 0x42, 0x7C, 0x40, 0x80,
  0x80, 0x3E, 0x9A, 0x14, 0x28, 0x51, 0x9E, 0x04, 0x08, 0x10, 0xFD, 0x84,
  0x10, 0x41, 0x04, 0x00, 0x3D, 0x14, 0x1E, 0x06, 0x17, 0x80, 0x10, 0x20,
  0x87, 0xF2, 0x04, 0x08, 0x12, 0x58, 0xC0, 0x45, 0x18, 0x61, 0x8E, 0x66,
  0x80, 0xE4, 0x85, 0x12, 0x24, 0x4B, 0x1C, 0x00, 0x93, 0x26, 0x4C, 0x9A,
  0x34, 0xB6, 0x00, 0x33, 0x55, 0x09, 0x08, 0x88, 0x9B, 0x6C, 0x22, 0x45,
  0x0A, 0x14, 0x29, 0x8D, 0x02, 0x8C, 0xF0, 0x7B, 0x0C, 0x20, 0x86, 0x58,
  0xAF, 0x00, 0x1C, 0x82, 0x08, 0x10, 0x4E, 0x08, 0x21, 0x04, 0x20, 0x70,
  0x29, 0x24, 0x92, 0x92, 0x48, 0x38, 0x20, 0x84, 0x20, 0x81, 0xCC, 0x20,
  0x82, 0x08, 0xE0, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 9, 10, 8, 0, -10 },
  { 19, 8, 12, 8, 0, -11 },
  { 31, 9, 10, 8, 0, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 4, 8, 4, -10 },
  { 54, 5, 13, 8, 3, -11 },
  { 63, 5, 13, 8, 1, -11 },
  { 72, 7, 7, 8, 1, -8 },
  { 79, 7, 7, 8, 1, -8 },
  { 86, 3, 4, 8, 2, -2 },
  { 88, 4, 1, 8, 2, -5 },
  { 89, 2, 2, 8, 3, -2 },
  { 90, 8, 13, 8, 0, -11 },
  { 103, 7, 10, 8, 1, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 8, 10, 8, 0, -10 },
  { 130, 8, 10, 8, 0, -10 },
  { 140, 8, 10, 8, 0, -10 },
  { 150, 7, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 6, 10, 8, 2, -10 },
  { 175, 7, 10, 8, 1, -10 },
  { 184, 7, 10, 8, 1, -10 },
  { 193, 3, 8, 8, 3, -8 },
  { 196, 4, 10, 8, 2, -8 },
  { 201, 7, 8, 8, 1, -8 },
  { 208, 7, 4, 8, 1, -6 },
  { 212, 6, 8, 8, 1, -8 },
  { 218, 6, 10, 8, 2, -10 },
  { 226, 7, 12, 8, 1, -10 },
  { 237, 7, 10, 8, 0, -10 },
  { 246, 7, 10, 8, 1, -10 },
  { 255, 7, 10, 8, 1, -10 },
  { 264, 7, 10, 8, 1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 7, 10, 8, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 8, 10, 8, 1, -10 },
  { 337, 6, 10, 8, 1, -10 },
  { 345, 8, 10, 8, 0, -10 },
  { 355, 7, 10, 8, 1, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 7, 10, 8, 1, -10 },
  { 382, 7, 13, 8, 1, -10 },
  { 394, 7, 10, 8, 1, -10 },
  { 403, 8, 10, 8, 0, -10 },
  { 413, 8, 10, 8, 1, -10 },
  { 423, 7, 10, 8, 1, -10 },
  { 432, 7, 10, 8, 2, -10 },
  { 441, 8, 10, 8, 1, -10 },
  { 451, 9, 10, 8, 0, -10 },
  { 463, 8, 10, 8, 1, -10 },
  { 473, 9, 10, 8, 0, -10 },
  { 485, 6, 13, 8, 2, -11 },
  { 495, 3, 13, 8, 3, -11 },
  { 500, 6, 13, 8, 0, -11 },
  { 510, 7, 6, 8, 1, -10 },
  { 516, 7, 1, 8, 0, 1 },
  { 517, 2, 3, 8, 3, -12 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 7, 10, 8, 1, -10 },
  { 533, 6, 7, 8, 1, -7 },
  { 539, 7, 10, 8, 1, -10 },
  { 548, 6, 7, 8, 1, -7 },
  { 554, 9, 13, 8, 0, -10 },
  { 569, 7, 10, 8, 1, -7 },
  { 578, 6, 10, 8, 1, -10 },
  { 586, 6, 10, 8, 1, -10 },
  { 594, 6, 13, 8, 1, -10 },
  { 604, 7, 10, 8, 1, -10 },
  { 613, 5, 10, 8, 2, -10 },
  { 620, 8, 7, 8, 0, -7 },
  { 627, 6, 7, 8, 1, -7 },
  { 633, 6, 7, 8, 1, -7 },
  { 639, 8, 10, 8, 0, -7 },
  { 649, 7, 10, 8, 1, -7 },
  { 658, 6, 7, 8, 2, -7 },
  { 664, 6, 7, 8, 1, -7 },
  { 670, 7, 10, 8, 1, -10 },
  { 679, 6, 7, 8, 1, -7 },
  { 685, 7, 7, 8, 1, -7 },
  { 692, 7, 7, 8, 1, -7 },
  { 699, 8, 7, 8, 0, -7 },
  { 706, 7, 10, 8, 0, -7 },
  { 715, 7, 7, 8, 1, -7 },
  { 722, 6, 13, 8, 2, -11 },
  { 732, 3, 13, 8, 3, -11 },
  { 737, 6, 13, 8, 1, -11 },
  { 747, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_LIGHTITALIC14PT7B_H_
