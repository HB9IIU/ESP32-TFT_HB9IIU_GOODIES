#ifndef _IBMPLEXMONO_LIGHTITALIC55PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFE, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0x9F, 0xC0,
  0x3E, 0x0E, 0x0F, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x1C,
  0x03, 0x00, 0x40, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x60,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x3E, 0x18, 0x00,
  0x00, 0xFE, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xDF, 0xC0, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x1C, 0x1F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06,
  0x01, 0xE0, 0x00, 0x18, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x0E, 0x01, 0xE1, 0x00, 0x30, 0x07, 0x06, 0x00, 0xC0, 0x3C,
  0x3C, 0x03, 0x00, 0xF0, 0xF8, 0x1C, 0x07, 0x81, 0xF0, 0x70, 0x7C, 0x03,
  0xF9, 0xC7, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x3F,
  0xFC, 0x00, 0x1C, 0x03, 0xE1, 0xE0, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x70, 0x00, 0x60, 0x07, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x38, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x7C, 0x38, 0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x0F, 0xFC, 0x1C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x3F, 0xF0, 0x00,
  0x03, 0x83, 0xFF, 0xC0, 0x00, 0x38, 0x3C, 0x1E, 0x00, 0x01, 0xC3, 0xC0,
  0x30, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x0F, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x78, 0x04, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0x70, 0x00, 0x5C, 0x0E, 0x70, 0x00, 0xDE, 0x0E, 0x78, 0x00,
  0xCE, 0x1C, 0x78, 0x01, 0x87, 0x3C, 0x3E, 0x07, 0x87, 0xB8, 0x1F, 0xFF,
  0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x39, 0xCE,
  0x73, 0xBD, 0xCE, 0x73, 0x9D, 0xEE, 0x73, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x70, 0x03, 0x7C, 0x07, 0x03, 0xFF, 0xF8, 0x71, 0xFF,
  0x0F, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x03,
  0xC0, 0x18, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C,
  0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1D,
  0xC0, 0x3E, 0x03, 0xB8, 0x07, 0x80, 0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3E, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x9E, 0x00,
  0x0F, 0x87, 0x00, 0x07, 0xC1, 0xC0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x1C,
  0x00, 0xF8, 0x07, 0x00, 0x18, 0x03, 0xC0, 0x04, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xC0, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0xF0, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x60, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x0E,
  0x3F, 0xF8, 0x00, 0xEF, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x1C, 0x7F,
  0xF8, 0x1E, 0xFF, 0xFE, 0x0E, 0xF0, 0x1F, 0x8F, 0xE0, 0x03, 0xE7, 0x40,
  0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x7E,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFC, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xB8, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xCF, 0x80, 0x0E, 0xE3, 0xF0, 0x1E, 0xE0, 0xFF, 0xFE, 0x70,
  0x3F, 0xFC, 0x78, 0x03, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xC0, 0x7E,
  0x3C, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00,
  0x0C, 0x70, 0x07, 0xC3, 0x1C, 0x07, 0xF9, 0xCE, 0x03, 0xFF, 0x73, 0x81,
  0xE0, 0xDC, 0xE0, 0x70, 0x0F, 0x30, 0x38, 0x03, 0xDC, 0x0E, 0x00, 0xE7,
  0x07, 0x00, 0x39, 0xC1, 0xC0, 0x0E, 0x70, 0x70, 0x03, 0x9C, 0x1C, 0x00,
  0xEE, 0x0E, 0x00, 0x3B, 0x83, 0x80, 0x0C, 0xE0, 0xE0, 0x07, 0x38, 0x38,
  0x01, 0xCE, 0x0E, 0x00, 0x73, 0x83, 0x80, 0x3C, 0xE0, 0xE0, 0x0F, 0x38,
  0x38, 0x05, 0x8C, 0x07, 0x03, 0xE3, 0x01, 0xFF, 0xB8, 0xC0, 0x3F, 0xCE,
  0x30, 0x07, 0xE3, 0x8E, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0x81,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x02, 0x0E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xC0, 0x38,
  0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3E,
  0x07, 0x00, 0x07, 0xC0, 0x70, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07,
  0xC0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0x3C, 0x01, 0xFF, 0xE7, 0x80, 0x3F, 0xFC, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xB8, 0x1E, 0x00, 0x77,
  0x01, 0xF0, 0x3C, 0xE0, 0x3F, 0xFF, 0x38, 0x01, 0xFF, 0xC7, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x03,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x1C,
  0xF7, 0x80, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x3F,
  0x01, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xEE, 0x00, 0x3B, 0x81,
  0xDC, 0x00, 0x67, 0x03, 0xB8, 0x01, 0xCE, 0x07, 0x30, 0x07, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x71, 0xC0, 0xE1, 0xC0, 0xE1,
  0xC1, 0xC3, 0x81, 0xC3, 0x87, 0x07, 0x03, 0x87, 0x0E, 0x1C, 0x07, 0x06,
  0x38, 0x38, 0x1C, 0x0E, 0xE0, 0x70, 0x38, 0x1D, 0xC0, 0xE0, 0x70, 0x3F,
  0x01, 0xC0, 0xE0, 0x3E, 0x03, 0x81, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0x00, 0x70, 0x38, 0x02, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x70,
  0x3F, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x07, 0x03, 0xB8, 0x00, 0x38, 0x0E,
  0xE0, 0x00, 0xE0, 0x3B, 0x80, 0x03, 0x80, 0xE7, 0x00, 0x0E, 0x07, 0x1C,
  0x00, 0x38, 0x1C, 0x70, 0x00, 0xE0, 0x71, 0xC0, 0x07, 0x01, 0xC3, 0x80,
  0x1C, 0x07, 0x0E, 0x00, 0x70, 0x1C, 0x38, 0x01, 0xC0, 0xE0, 0x70, 0x07,
  0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70,
  0x07, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x07, 0x00, 0x70, 0x70, 0x1C, 0x01,
  0xC1, 0xC0, 0x70, 0x03, 0x87, 0x03, 0x80, 0x0E, 0x1C, 0x0E, 0x00, 0x38,
  0x70, 0x38, 0x00, 0xF3, 0x80, 0xE0, 0x01, 0xCE, 0x03, 0x80, 0x07, 0x38,
  0x0E, 0x00, 0x1C, 0xE0, 0x70, 0x00, 0x3B, 0x81, 0xC0, 0x00, 0xEE, 0x07,
  0x00, 0x03, 0xF0, 0x1C, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFC,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3E, 0x00,
  0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x20, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xE0,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x04, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x10, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F,
  0x80, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x18, 0x03, 0xC0, 0x38, 0x38, 0x07, 0xC0, 0x38, 0x38, 0x07, 0xC0, 0x70,
  0x38, 0x0F, 0xC0, 0x70, 0x38, 0x0F, 0xC0, 0x70, 0x38, 0x0D, 0xC0, 0x70,
  0x38, 0x1D, 0xC0, 0xE0, 0x38, 0x1C, 0xC0, 0xE0, 0x38, 0x38, 0xC0, 0xE0,
  0x38, 0x38, 0xC0, 0xE0, 0x38, 0x30, 0xC1, 0xC0, 0x30, 0x70, 0xC1, 0xC0,
  0x30, 0x70, 0xE1, 0xC0, 0x70, 0xE0, 0xE1, 0xC0, 0x70, 0xE0, 0xE3, 0x80,
  0x70, 0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3, 0x80, 0x71, 0x80, 0xE3, 0x80,
  0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x77, 0x00, 0xE7, 0x00,
  0x77, 0x00, 0x67, 0x00, 0x76, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0x6E, 0x00,
  0x6E, 0x00, 0x6E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x63, 0x87, 0x1C, 0x38,
  0xE1, 0x87, 0x0C, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x70, 0x1F,
  0xFF, 0x1C, 0x0F, 0x80, 0xE7, 0x07, 0x80, 0x0D, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xE1, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x5C, 0x0F, 0x00, 0x77, 0x03, 0xE0, 0x79, 0xFC, 0x7F, 0xFC, 0x7F, 0x0F,
  0xFE, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0xF0,
  0x03, 0x87, 0xFF, 0x00, 0xE3, 0xFF, 0xE0, 0x39, 0xE0, 0xFC, 0x0E, 0xE0,
  0x0F, 0x07, 0xE0, 0x01, 0xE1, 0xD0, 0x00, 0x38, 0x7C, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x78, 0xE8, 0x00, 0x3C, 0x3B, 0x00, 0x1E, 0x0E, 0x70, 0x1F,
  0x03, 0x8F, 0xFF, 0x80, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x04, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x04, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0xF8, 0x1C, 0x00, 0x7F, 0xF0, 0xE0, 0x07, 0xFF, 0xC7, 0x00,
  0x7C, 0x07, 0x38, 0x07, 0x80, 0x0D, 0xC0, 0x78, 0x00, 0x2E, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x5C, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0xEE, 0x00, 0xFC,
  0x1E, 0x70, 0x03, 0xFF, 0xE3, 0x80, 0x0F, 0xFE, 0x1C, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x7E, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1E,
  0x38, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0xC7, 0x00, 0x0F, 0xC3, 0x80, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x43, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x07,
  0xC0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x80, 0xF8, 0x0E,
  0x70, 0x3C, 0x00, 0x6E, 0x0F, 0x00, 0x05, 0xC3, 0xC0, 0x00, 0xF8, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x05, 0xC1, 0xE0, 0x01, 0xB8, 0x1E, 0x00, 0x6F, 0x03,
  0xF0, 0x39, 0xC0, 0x3F, 0xFE, 0x38, 0x03, 0xFF, 0x87, 0x00, 0x1F, 0xC0,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x3C,
  0x07, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x0F, 0x1F, 0xF8,
  0x0E, 0x3F, 0xFC, 0x0E, 0x78, 0x3E, 0x0E, 0x60, 0x0F, 0x0E, 0xC0, 0x0F,
  0x0F, 0x80, 0x07, 0x1F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x3E,
  0x01, 0xC0, 0x7C, 0x01, 0xC0, 0xF0, 0x01, 0xC3, 0xE0, 0x03, 0x87, 0xC0,
  0x03, 0x8F, 0x00, 0x03, 0xBE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x30,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xFB, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x1C, 0x3F, 0xF8,
  0x03, 0x8F, 0xFF, 0x80, 0x73, 0xC0, 0xF8, 0x0E, 0xE0, 0x0F, 0x01, 0xD8,
  0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x0F, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x07, 0xE0, 0x03,
  0x8F, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x81, 0xC0,
  0x02, 0x70, 0x3C, 0x00, 0x6E, 0x03, 0x80, 0x3D, 0xC0, 0x78, 0x0F, 0x38,
  0x07, 0x03, 0xCF, 0x00, 0xF0, 0xF1, 0xC0, 0x0E, 0x3C, 0x38, 0x01, 0xEF,
  0x07, 0x00, 0x1F, 0xC0, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x20, 0x38, 0x01,
  0xC1, 0xC0, 0x0F, 0x07, 0x00, 0xF8, 0x1C, 0x07, 0x80, 0x70, 0x3C, 0x01,
  0xC3, 0xE0, 0x0E, 0x1F, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1C,
  0xFE, 0x1F, 0xE0, 0x77, 0xFC, 0xFF, 0xC1, 0xD8, 0xF3, 0x0F, 0x0E, 0x81,
  0xD8, 0x1C, 0x3C, 0x03, 0x40, 0x70, 0xF0, 0x0E, 0x01, 0xC3, 0x80, 0x38,
  0x07, 0x0E, 0x01, 0xC0, 0x1C, 0x38, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01,
  0xC7, 0x00, 0x70, 0x06, 0x1C, 0x01, 0xC0, 0x38, 0x70, 0x06, 0x00, 0xE1,
  0xC0, 0x38, 0x03, 0x86, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x38, 0xE0,
  0x0E, 0x00, 0xC3, 0x80, 0x38, 0x07, 0x0E, 0x00, 0xC0, 0x1C, 0x38, 0x07,
  0x00, 0x70, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0,
  0x38, 0x70, 0x07, 0x00, 0xE1, 0xC0, 0x18, 0x03, 0x87, 0x00, 0xE0, 0x0E,
  0x18, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0x1F, 0xF8, 0x0E, 0x3F, 0xFC, 0x0E, 0x78, 0x3E, 0x0E, 0x60, 0x0F, 0x0E,
  0xC0, 0x0F, 0x0F, 0x80, 0x07, 0x1F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xF0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x0F, 0xC0,
  0xF8, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x38, 0x7F, 0xF0, 0x03, 0x8F, 0xFF, 0x80, 0x39, 0xE0, 0xFC, 0x03,
  0xB8, 0x03, 0xC0, 0x7E, 0x00, 0x1E, 0x07, 0x40, 0x00, 0xE0, 0x7C, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3A, 0x00, 0x0F,
  0x03, 0xB0, 0x01, 0xE0, 0x39, 0xC0, 0x7C, 0x03, 0x8F, 0xFF, 0x80, 0x38,
  0x7F, 0xF0, 0x07, 0x81, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x70,
  0x1F, 0xFF, 0x1C, 0x0F, 0x80, 0xE7, 0x07, 0x80, 0x0D, 0xC3, 0xC0, 0x01,
  0x71, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xF0, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xB8, 0x78,
  0x00, 0x7E, 0x0F, 0x00, 0x77, 0x03, 0xF0, 0x79, 0xC0, 0x7F, 0xFC, 0x70,
  0x0F, 0xFE, 0x1C, 0x00, 0xFE, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xC7,
  0xFF, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3A, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0x80, 0x7E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x10, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x83, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x08, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x0E, 0x01, 0xF0,
  0x03, 0x81, 0xF0, 0x00, 0xE1, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x0E, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0xF8, 0xE0, 0x01, 0xF0, 0xF0, 0x03, 0x70, 0xF0,
  0x06, 0x70, 0x7C, 0x1E, 0x70, 0x3F, 0xFC, 0x70, 0x1F, 0xF8, 0xF0, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xF0, 0x01, 0xEF, 0xFC, 0x00, 0x3B,
  0xFE, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80, 0x1C, 0x0F, 0xC0, 0x07,
  0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x1C, 0x0E, 0x1C, 0x01, 0xC0, 0x61,
  0xC0, 0x18, 0x07, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x38, 0x07, 0x1C, 0x03,
  0x80, 0x71, 0x80, 0x38, 0x07, 0x38, 0x03, 0x80, 0x73, 0x80, 0x30, 0x07,
  0x38, 0x07, 0x00, 0x73, 0x80, 0x70, 0x07, 0x38, 0x07, 0x00, 0x73, 0x00,
  0x70, 0x07, 0x70, 0x07, 0x00, 0x77, 0x00, 0x60, 0x07, 0x70, 0x0E, 0x00,
  0x77, 0x00, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0xE6, 0x00, 0xE0, 0x0E, 0xE0,
  0x0E, 0x00, 0xEE, 0x01, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xCE, 0x01, 0xC0,
  0x38, 0xE0, 0x3E, 0x03, 0x8E, 0x06, 0xE0, 0x70, 0xF0, 0xEF, 0x1F, 0x07,
  0xFC, 0x7F, 0xE0, 0x7F, 0x87, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0x38,
  0x70, 0xF0, 0xF8, 0x71, 0xC0, 0xE7, 0xC0, 0xE7, 0x01, 0xDE, 0x00, 0xCC,
  0x03, 0x98, 0x01, 0x90, 0x07, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x07, 0xC0,
  0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xB0, 0x00, 0x38,
  0x02, 0x60, 0x06, 0x70, 0x0C, 0xE0, 0x3C, 0xE0, 0x39, 0xC1, 0xF1, 0xC0,
  0xE3, 0x87, 0xC3, 0xC3, 0xC7, 0xBE, 0x03, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x81, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x7E, 0x07, 0x80, 0x0B,
  0x80, 0x78, 0x06, 0x70, 0x0F, 0x83, 0xCE, 0x00, 0xFF, 0xF1, 0xC0, 0x0F,
  0xFC, 0x38, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x01, 0x00, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x1F, 0xFF, 0xC3, 0x87, 0x81, 0xFC, 0x71,
  0xE0, 0x03, 0xEE, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x78, 0x18, 0x00, 0x1E, 0x03, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x18, 0x7F, 0xC0, 0x03, 0x9F, 0xFF,
  0xC0, 0x73, 0x83, 0xFF, 0xCE, 0x70, 0x07, 0xFF, 0xCE, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x20, 0x7F, 0x80, 0x07, 0x0F, 0xFC,
  0x00, 0x71, 0xE3, 0xC0, 0x0E, 0x38, 0x1E, 0x00, 0xE3, 0x80, 0xF0, 0x1C,
  0x70, 0x07, 0x83, 0xC7, 0x00, 0x3C, 0x78, 0xE0, 0x03, 0xFF, 0x0E, 0x00,
  0x1F, 0xE0, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 11, 38, 33, 11, -38 },
  { 54, 14, 15, 33, 13, -41 },
  { 81, 33, 38, 33, 1, -38 },
  { 238, 30, 52, 33, 2, -45 },
  { 433, 37, 40, 33, -1, -39 },
  { 618, 32, 40, 33, 0, -39 },
  { 778, 5, 15, 33, 17, -41 },
  { 788, 19, 50, 33, 12, -42 },
  { 907, 19, 50, 33, 3, -42 },
  { 1026, 28, 27, 33, 3, -30 },
  { 1121, 26, 27, 33, 4, -30 },
  { 1209, 11, 14, 33, 8, -6 },
  { 1229, 16, 3, 33, 9, -18 },
  { 1235, 7, 6, 33, 11, -6 },
  { 1241, 30, 50, 33, 2, -42 },
  { 1429, 27, 40, 33, 4, -39 },
  { 1564, 26, 38, 33, 2, -38 },
  { 1688, 28, 39, 33, 2, -39 },
  { 1825, 28, 40, 33, 2, -39 },
  { 1965, 29, 38, 33, 1, -38 },
  { 2103, 28, 39, 33, 3, -38 },
  { 2240, 25, 39, 33, 4, -38 },
  { 2362, 27, 38, 33, 6, -38 },
  { 2491, 28, 40, 33, 3, -39 },
  { 2631, 25, 39, 33, 5, -39 },
  { 2753, 11, 29, 33, 11, -29 },
  { 2793, 14, 37, 33, 8, -29 },
  { 2858, 26, 31, 33, 5, -32 },
  { 2959, 28, 14, 33, 3, -24 },
  { 3008, 26, 31, 33, 3, -32 },
  { 3109, 22, 39, 33, 8, -39 },
  { 3217, 26, 45, 33, 4, -39 },
  { 3364, 29, 38, 33, 0, -38 },
  { 3502, 27, 38, 33, 3, -38 },
  { 3631, 26, 40, 33, 5, -39 },
  { 3761, 28, 38, 33, 3, -38 },
  { 3894, 29, 38, 33, 3, -38 },
  { 4032, 30, 38, 33, 3, -38 },
  { 4175, 27, 40, 33, 4, -39 },
  { 4310, 30, 38, 33, 2, -38 },
  { 4453, 30, 38, 33, 2, -38 },
  { 4596, 26, 39, 33, 4, -38 },
  { 4723, 32, 38, 33, 3, -38 },
  { 4875, 22, 38, 33, 5, -38 },
  { 4980, 31, 38, 33, 2, -38 },
  { 5128, 30, 38, 33, 2, -38 },
  { 5271, 27, 40, 33, 4, -39 },
  { 5406, 29, 38, 33, 3, -38 },
  { 5544, 27, 49, 33, 4, -39 },
  { 5710, 29, 38, 33, 3, -38 },
  { 5848, 30, 40, 33, 2, -39 },
  { 5998, 30, 38, 33, 5, -38 },
  { 6141, 28, 39, 33, 4, -38 },
  { 6278, 29, 38, 33, 6, -38 },
  { 6416, 32, 38, 33, 3, -38 },
  { 6568, 35, 38, 33, 0, -38 },
  { 6735, 31, 38, 33, 5, -38 },
  { 6883, 33, 38, 33, 0, -38 },
  { 7040, 22, 50, 33, 10, -42 },
  { 7178, 14, 50, 33, 10, -42 },
  { 7266, 23, 50, 33, 1, -42 },
  { 7410, 27, 22, 33, 4, -38 },
  { 7485, 27, 3, 33, 0, 6 },
  { 7496, 6, 10, 33, 13, -42 },
  { 7504, 26, 30, 33, 3, -29 },
  { 7602, 26, 42, 33, 4, -41 },
  { 7739, 24, 30, 33, 4, -29 },
  { 7829, 29, 42, 33, 3, -41 },
  { 7982, 25, 30, 33, 4, -29 },
  { 8076, 36, 53, 33, -1, -41 },
  { 8315, 27, 41, 33, 2, -29 },
  { 8454, 24, 41, 33, 4, -41 },
  { 8577, 24, 42, 33, 5, -41 },
  { 8703, 25, 53, 33, 4, -41 },
  { 8869, 27, 42, 33, 4, -41 },
  { 9011, 22, 42, 33, 6, -41 },
  { 9127, 30, 29, 33, 1, -29 },
  { 9236, 24, 29, 33, 4, -29 },
  { 9323, 25, 30, 33, 4, -29 },
  { 9417, 28, 40, 33, 2, -29 },
  { 9557, 26, 40, 33, 3, -29 },
  { 9687, 27, 28, 33, 6, -28 },
  { 9782, 26, 30, 33, 3, -29 },
  { 9880, 26, 39, 33, 4, -38 },
  { 10007, 24, 29, 33, 5, -28 },
  { 10094, 26, 29, 33, 4, -29 },
  { 10189, 28, 30, 33, 3, -29 },
  { 10294, 31, 30, 33, 1, -29 },
  { 10411, 27, 40, 33, 2, -28 },
  { 10546, 27, 30, 33, 3, -29 },
  { 10648, 26, 50, 33, 6, -42 },
  { 10811, 12, 50, 33, 11, -42 },
  { 10886, 25, 50, 33, 3, -42 },
  { 11043, 28, 11, 33, 3, -22 },
};

const GFXfont IBMPlexMono_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_LIGHTITALIC55PT7B_H_
