#ifndef _IBMPLEXMONO_LIGHTITALIC66PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80,
  0xF3, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x1C,
  0x07, 0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x78,
  0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x8E, 0x3F, 0x80, 0x07,
  0xC0, 0xE0, 0x7C, 0x00, 0xF0, 0x0E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x1F,
  0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x04, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x18, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x0F,
  0xC3, 0x80, 0x00, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x02, 0x00, 0x1C, 0x00, 0xF0,
  0x70, 0x01, 0x80, 0x1E, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0xFC, 0x03, 0x80,
  0x3C, 0x07, 0xE0, 0x38, 0x07, 0xC0, 0x3F, 0x03, 0x81, 0xF8, 0x01, 0xFE,
  0x38, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0x38, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x1C, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0xE0, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xC0, 0x00, 0x07, 0xC1, 0xFC,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xDE, 0x00, 0x00, 0xF8, 0x03, 0xDC, 0x00, 0x03, 0xF0, 0x07, 0x3C, 0x00,
  0x06, 0xF0, 0x1C, 0x78, 0x00, 0x08, 0xE0, 0x78, 0xF0, 0x00, 0x31, 0xE0,
  0xE0, 0xF0, 0x00, 0xE1, 0xC3, 0xC1, 0xF0, 0x03, 0x83, 0xC7, 0x01, 0xF8,
  0x1E, 0x03, 0xDC, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0xFE, 0x0E, 0x0F, 0xFC,
  0x7F, 0xE7, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x01, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x80, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x0F, 0x00, 0x3D, 0xE0, 0x0F, 0xC0, 0x1E,
  0xF0, 0x07, 0xE0, 0x1F, 0x78, 0x03, 0xF0, 0x0F, 0xBC, 0x03, 0xF8, 0x07,
  0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00,
  0x7E, 0x78, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x03,
  0xC0, 0x01, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xE0, 0x00, 0x0E, 0x1F, 0xFF,
  0x00, 0x07, 0x9F, 0xFF, 0xE0, 0x01, 0xEF, 0x01, 0xFC, 0x00, 0x76, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x78, 0x7F,
  0xFC, 0x00, 0xF3, 0xFF, 0xFE, 0x03, 0xCF, 0x00, 0xFE, 0x07, 0xB8, 0x00,
  0x7E, 0x1E, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x79, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x38,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F,
  0xCF, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xBC,
  0x3F, 0x00, 0x0E, 0xF0, 0x3F, 0x80, 0x79, 0xE0, 0x3F, 0xFF, 0xE7, 0x80,
  0x1F, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x1F, 0x07, 0x0E, 0x00, 0x7F, 0xC7,
  0x0E, 0x01, 0xFF, 0xE7, 0x1E, 0x01, 0xF0, 0x77, 0x1C, 0x03, 0xC0, 0x3F,
  0x1C, 0x07, 0x80, 0x1F, 0x1C, 0x07, 0x00, 0x0E, 0x3C, 0x0F, 0x00, 0x0E,
  0x3C, 0x0F, 0x00, 0x0E, 0x3C, 0x0E, 0x00, 0x1E, 0x38, 0x0E, 0x00, 0x1E,
  0x38, 0x1E, 0x00, 0x1E, 0x78, 0x1E, 0x00, 0x1C, 0x78, 0x1E, 0x00, 0x1C,
  0x78, 0x1C, 0x00, 0x1C, 0x78, 0x1C, 0x00, 0x1C, 0x70, 0x3C, 0x00, 0x3C,
  0x70, 0x3C, 0x00, 0x3C, 0x70, 0x3C, 0x00, 0x38, 0x70, 0x3C, 0x00, 0x78,
  0x70, 0x1C, 0x00, 0x78, 0xF0, 0x1C, 0x00, 0xB8, 0xF0, 0x1E, 0x01, 0xF8,
  0xF0, 0x1F, 0x03, 0x78, 0xF0, 0x0F, 0xDE, 0x70, 0xF0, 0x0F, 0xFE, 0x70,
  0x70, 0x03, 0xF8, 0x70, 0x70, 0x00, 0x40, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0xFC, 0xF0, 0x00,
  0xFF, 0xFC, 0xF0, 0x01, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x06, 0xE0, 0x3E, 0x00,
  0x0C, 0xE0, 0x1F, 0x00, 0x1D, 0xE0, 0x1F, 0xC0, 0x79, 0xE0, 0x0F, 0xFF,
  0xF1, 0xE0, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x03,
  0xC7, 0xFC, 0x00, 0x00, 0x07, 0x9F, 0x7C, 0x00, 0x00, 0x0F, 0x7C, 0x78,
  0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x7B, 0xC0, 0x01, 0xEE, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0xF3, 0x80, 0x0F, 0x3C,
  0x07, 0x1E, 0x00, 0x71, 0xE0, 0x38, 0xF0, 0x07, 0x8E, 0x03, 0xC3, 0x80,
  0x78, 0x70, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x3C, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0x38, 0x1C, 0x1E, 0x0F, 0x01, 0xC0, 0xE1, 0xE0,
  0x70, 0x1E, 0x07, 0x8F, 0x03, 0x80, 0xF0, 0x1C, 0xF0, 0x3C, 0x07, 0x80,
  0xE7, 0x01, 0xE0, 0x3C, 0x07, 0x78, 0x0F, 0x01, 0xC0, 0x3F, 0x80, 0x78,
  0x0E, 0x00, 0xFC, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x1C, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x06, 0x00, 0x78, 0x0E,
  0x00, 0x30, 0x03, 0xC0, 0x70, 0x01, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x1F,
  0xC0, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0x00, 0x1E,
  0x01, 0xFC, 0x00, 0x01, 0xE0, 0x1D, 0xE0, 0x00, 0x1E, 0x01, 0xDE, 0x00,
  0x01, 0xE0, 0x3C, 0xE0, 0x00, 0x1C, 0x03, 0xCF, 0x00, 0x01, 0xC0, 0x3C,
  0xF0, 0x00, 0x3C, 0x03, 0x87, 0x00, 0x03, 0xC0, 0x38, 0x70, 0x00, 0x3C,
  0x03, 0x87, 0x80, 0x03, 0xC0, 0x78, 0x78, 0x00, 0x38, 0x07, 0x83, 0x80,
  0x03, 0x80, 0x78, 0x3C, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x70,
  0x3C, 0x00, 0x78, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x70,
  0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x07, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x07, 0x81, 0xE0,
  0x1E, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x03, 0x81, 0xE0, 0x1C, 0x00, 0x3C,
  0x1E, 0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x3C, 0x00, 0x1C, 0x1C, 0x03, 0xC0,
  0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x1E, 0x3C, 0x03, 0x80, 0x01, 0xE3, 0xC0,
  0x38, 0x00, 0x0E, 0x3C, 0x07, 0x80, 0x00, 0xF3, 0x80, 0x78, 0x00, 0x0F,
  0x38, 0x07, 0x80, 0x00, 0x77, 0x80, 0x78, 0x00, 0x07, 0x78, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x70, 0x00, 0x07, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x3F,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x20, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x7E, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x7C, 0x00, 0xE0, 0xF0, 0x07, 0xE0, 0x0F, 0x07, 0x80, 0x3F,
  0x00, 0x78, 0x3C, 0x01, 0xF8, 0x03, 0x81, 0xE0, 0x1D, 0xC0, 0x1C, 0x0F,
  0x00, 0xEE, 0x01, 0xE0, 0x78, 0x0F, 0x70, 0x0F, 0x03, 0x80, 0x73, 0x80,
  0x70, 0x1C, 0x03, 0x9C, 0x03, 0x80, 0xE0, 0x38, 0xE0, 0x3C, 0x07, 0x01,
  0xC7, 0x01, 0xE0, 0x38, 0x1E, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0xE0, 0x70,
  0x0E, 0x0F, 0x07, 0x07, 0x80, 0xF0, 0x70, 0x38, 0x3C, 0x07, 0x83, 0x81,
  0xC1, 0xC0, 0x3C, 0x3C, 0x0E, 0x0E, 0x01, 0xE1, 0xC0, 0x70, 0xF0, 0x0F,
  0x1E, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x3C,
  0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0xC0,
  0x1E, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x07, 0xF8, 0x00,
  0x77, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x20, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF8, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0x07, 0x02, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x3C,
  0x03, 0xFF, 0xFC, 0x78, 0x0F, 0xC0, 0x78, 0xF0, 0x3E, 0x00, 0x19, 0xC0,
  0xF8, 0x00, 0x1B, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x5E, 0x0F, 0x00, 0x01, 0xB8,
  0x0F, 0x00, 0x06, 0xF0, 0x1F, 0x00, 0x39, 0xE0, 0x1F, 0x81, 0xE3, 0xFE,
  0x1F, 0xFF, 0x83, 0xFC, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x00,
  0x03, 0x81, 0xFF, 0xC0, 0x03, 0x87, 0xFF, 0xF0, 0x07, 0x8F, 0x01, 0xF8,
  0x07, 0x9C, 0x00, 0x78, 0x07, 0xB8, 0x00, 0x3C, 0x07, 0xB0, 0x00, 0x3C,
  0x07, 0x60, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03, 0xC0,
  0x7B, 0x80, 0x0F, 0x80, 0x71, 0xE0, 0x3F, 0x00, 0xF0, 0xFF, 0xFE, 0x00,
  0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3E,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x87, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0xE0, 0x00,
  0xFF, 0xF0, 0x38, 0x00, 0xFF, 0xFF, 0x1E, 0x00, 0x7E, 0x01, 0xE7, 0x80,
  0x3E, 0x00, 0x1D, 0xE0, 0x1F, 0x00, 0x03, 0x78, 0x07, 0x80, 0x00, 0x5C,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x5E, 0x01, 0xE0, 0x00,
  0x37, 0x80, 0x3C, 0x00, 0x19, 0xC0, 0x0F, 0x80, 0x0C, 0x70, 0x01, 0xF8,
  0x1E, 0x3C, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x07, 0xFF, 0x83, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x8F, 0x00,
  0x07, 0xF8, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x47, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x3E, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x07, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0xFC, 0x03, 0xCF, 0x01, 0xF0,
  0x00, 0xCF, 0x03, 0xE0, 0x00, 0x6F, 0x07, 0xC0, 0x00, 0x2E, 0x07, 0x80,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x06, 0xF0, 0x1E, 0x00, 0x0C, 0xF0, 0x1F, 0x00, 0x1C, 0xE0, 0x0F, 0xC0,
  0x78, 0xE0, 0x07, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0xFF,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x40, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x03, 0xF8, 0x00, 0xF0, 0x7F, 0xF0, 0x07, 0x8F, 0xFF, 0xC0,
  0x3C, 0xF0, 0x3F, 0x01, 0xC6, 0x00, 0x7C, 0x0E, 0x60, 0x01, 0xE0, 0xF6,
  0x00, 0x0F, 0x07, 0xA0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x07, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0x7C, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xC1, 0xF0, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x0F,
  0x07, 0xFF, 0x80, 0x03, 0x87, 0xFF, 0xF0, 0x00, 0xE3, 0xC0, 0x7E, 0x00,
  0x79, 0xC0, 0x07, 0x80, 0x1E, 0x60, 0x01, 0xF0, 0x07, 0xB0, 0x00, 0x3C,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x74, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x18, 0xF0, 0x0F, 0x00, 0x0F, 0x3C, 0x03, 0xC0,
  0x07, 0x8E, 0x00, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x01, 0xE1, 0xE0, 0x03,
  0x80, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x1E, 0x00, 0x1C, 0x7C, 0x07, 0x80,
  0x07, 0xBE, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x04, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0xF3, 0xFE, 0x0F, 0xF8, 0x1C, 0x7F, 0xC3, 0xFF,
  0x03, 0x98, 0x7C, 0xE1, 0xF0, 0x76, 0x07, 0xB8, 0x1E, 0x1E, 0x80, 0x76,
  0x01, 0xC3, 0xE0, 0x0F, 0x80, 0x38, 0x7C, 0x01, 0xE0, 0x07, 0x0F, 0x00,
  0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x03, 0x8F,
  0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x1E, 0x3C, 0x00, 0xF0, 0x03,
  0xC7, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0x01, 0xC7, 0x80, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0x01, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x80, 0x1E, 0x3C, 0x00,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3C, 0x1F, 0xFC, 0x01, 0xE3, 0xFF, 0xF0, 0x0F, 0x3C, 0x0F, 0xC0,
  0x71, 0x80, 0x1F, 0x03, 0x98, 0x00, 0x78, 0x3D, 0x80, 0x03, 0xC1, 0xE8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3C, 0x1F, 0xFC, 0x00, 0x0E, 0x1F, 0xFF, 0xC0, 0x07, 0x8F, 0x01, 0xF8,
  0x01, 0xE7, 0x00, 0x1E, 0x00, 0x7B, 0x80, 0x03, 0xC0, 0x1E, 0xC0, 0x00,
  0xF0, 0x07, 0x60, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xE0,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x7B, 0x80, 0x0F, 0x80, 0x1C,
  0x78, 0x0F, 0xC0, 0x0F, 0x0F, 0xFF, 0xE0, 0x03, 0xC1, 0xFF, 0xF0, 0x00,
  0xF0, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x1C, 0x03, 0xFF, 0xFC, 0x78, 0x0F, 0xE0, 0x3C, 0xF0, 0x3E,
  0x00, 0x1D, 0xE0, 0xF8, 0x00, 0x1B, 0xC1, 0xE0, 0x00, 0x17, 0x07, 0x80,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7E, 0x0F,
  0x00, 0x01, 0xBC, 0x0F, 0x00, 0x06, 0x70, 0x1F, 0x00, 0x1C, 0xE0, 0x1F,
  0x81, 0xF3, 0xC0, 0x1F, 0xFF, 0xC7, 0x80, 0x1F, 0xFE, 0x0F, 0x00, 0x0F,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0x7F, 0xFE, 0x3F,
  0xFF, 0x80, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3D, 0x80,
  0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x08,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE1, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x1F,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x20, 0x03, 0xC0, 0x00, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x0E, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x0E, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x05, 0xE1, 0xE0, 0x00, 0x6E, 0x0F, 0x00, 0x02,
  0xF0, 0x3C, 0x00, 0x37, 0x81, 0xF0, 0x07, 0x3C, 0x0F, 0xC0, 0xF1, 0xE0,
  0x3F, 0xFF, 0x0F, 0x00, 0xFF, 0xF0, 0x70, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1B, 0xFF, 0x80, 0x01, 0xEF, 0xFE, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x0E, 0x00, 0xFC, 0x00,
  0x38, 0x0F, 0xC0, 0x00, 0xE1, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x07,
  0x00, 0x3C, 0x07, 0x83, 0x80, 0x1E, 0x01, 0xC3, 0xC0, 0x0E, 0x00, 0xF1,
  0xE0, 0x07, 0x00, 0x78, 0xE0, 0x03, 0x80, 0x1C, 0x70, 0x01, 0xC0, 0x0E,
  0x38, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x03, 0x9E, 0x00, 0x70, 0x01,
  0xCF, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x00,
  0x39, 0xC0, 0x0F, 0x00, 0x1C, 0xE0, 0x07, 0x80, 0x0E, 0xF0, 0x03, 0x80,
  0x07, 0x78, 0x01, 0xC0, 0x03, 0xBC, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x70,
  0x01, 0xEE, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x3C, 0x00, 0x77, 0x80, 0x1E,
  0x00, 0x3B, 0xC0, 0x0E, 0x00, 0x3D, 0xC0, 0x07, 0x00, 0x1E, 0xE0, 0x07,
  0x80, 0x0E, 0x70, 0x03, 0xC0, 0x0F, 0x38, 0x01, 0xE0, 0x07, 0x9C, 0x01,
  0xF0, 0x07, 0x8E, 0x00, 0xB8, 0x03, 0xC7, 0x00, 0xDC, 0x03, 0xC3, 0xC0,
  0xCF, 0x03, 0xC1, 0xF0, 0xE3, 0xC3, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7E,
  0x78, 0x3C, 0x3E, 0x07, 0xF0, 0xE1, 0xE0, 0x78, 0x3F, 0x03, 0x87, 0x00,
  0xF3, 0xF0, 0x0F, 0x38, 0x03, 0xCF, 0x00, 0x1C, 0xC0, 0x0F, 0x10, 0x00,
  0x73, 0x00, 0x3C, 0x00, 0x01, 0xD8, 0x00, 0xF0, 0x00, 0x07, 0x60, 0x03,
  0xC0, 0x00, 0x1D, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x01, 0xB8, 0x00, 0x03, 0xC0, 0x06, 0xE0, 0x00, 0x0E,
  0x00, 0x1B, 0x80, 0x04, 0x38, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x38,
  0x01, 0xE3, 0xC0, 0x18, 0xF0, 0x1F, 0x4F, 0x00, 0xE3, 0xC0, 0xF8, 0x3C,
  0x07, 0x07, 0x0F, 0xC0, 0x78, 0x3C, 0x1E, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xFC, 0x03, 0xC0,
  0x00, 0x5E, 0x01, 0xE0, 0x00, 0x6E, 0x00, 0x78, 0x00, 0x6F, 0x00, 0x3E,
  0x00, 0x67, 0x80, 0x0F, 0x81, 0xE3, 0xC0, 0x07, 0xFF, 0xE1, 0xE0, 0x00,
  0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x10, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x38, 0x0F, 0x81, 0xFE, 0x1E, 0x07, 0x80,
  0x07, 0xE7, 0x81, 0xC0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x04, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x07,
  0x07, 0xFF, 0xF0, 0x01, 0xC1, 0xE3, 0xFF, 0xC0, 0x78, 0x70, 0x0F, 0xFF,
  0x9E, 0x1C, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x70, 0x3F,
  0xF0, 0x00, 0x1C, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x03, 0xC0, 0x03, 0x87,
  0x80, 0x78, 0x01, 0xE1, 0xC0, 0x1E, 0x00, 0x70, 0xE0, 0x03, 0xC0, 0x38,
  0x38, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x07, 0x00, 0x03, 0xFF,
  0x83, 0xC0, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 13, 46, 40, 14, -46 },
  { 76, 17, 18, 40, 15, -49 },
  { 115, 40, 46, 40, 1, -46 },
  { 345, 36, 62, 40, 2, -54 },
  { 624, 44, 48, 40, -1, -47 },
  { 888, 39, 48, 40, 0, -47 },
  { 1122, 7, 18, 40, 20, -49 },
  { 1138, 23, 59, 40, 14, -50 },
  { 1308, 23, 59, 40, 3, -50 },
  { 1478, 33, 33, 40, 4, -36 },
  { 1615, 32, 31, 40, 4, -36 },
  { 1739, 12, 17, 40, 10, -7 },
  { 1765, 19, 3, 40, 11, -22 },
  { 1773, 7, 7, 40, 14, -7 },
  { 1780, 37, 59, 40, 2, -50 },
  { 2053, 33, 48, 40, 4, -47 },
  { 2251, 31, 46, 40, 3, -46 },
  { 2430, 34, 47, 40, 2, -47 },
  { 2630, 34, 48, 40, 2, -47 },
  { 2834, 35, 46, 40, 1, -46 },
  { 3036, 34, 47, 40, 3, -46 },
  { 3236, 31, 47, 40, 4, -46 },
  { 3419, 32, 46, 40, 7, -46 },
  { 3603, 34, 48, 40, 3, -47 },
  { 3807, 31, 47, 40, 6, -47 },
  { 3990, 12, 35, 40, 14, -35 },
  { 4043, 16, 45, 40, 10, -35 },
  { 4133, 31, 37, 40, 6, -39 },
  { 4277, 34, 16, 40, 3, -28 },
  { 4345, 32, 37, 40, 3, -39 },
  { 4493, 27, 47, 40, 9, -47 },
  { 4652, 32, 54, 40, 4, -47 },
  { 4868, 34, 46, 40, 0, -46 },
  { 5064, 33, 46, 40, 3, -46 },
  { 5254, 33, 48, 40, 5, -47 },
  { 5452, 33, 46, 40, 4, -46 },
  { 5642, 35, 46, 40, 4, -46 },
  { 5844, 35, 46, 40, 4, -46 },
  { 6046, 32, 48, 40, 5, -47 },
  { 6238, 36, 46, 40, 3, -46 },
  { 6445, 36, 46, 40, 3, -46 },
  { 6652, 32, 47, 40, 4, -46 },
  { 6840, 39, 46, 40, 3, -46 },
  { 7065, 27, 46, 40, 6, -46 },
  { 7221, 37, 46, 40, 2, -46 },
  { 7434, 36, 46, 40, 3, -46 },
  { 7641, 33, 48, 40, 4, -47 },
  { 7839, 34, 46, 40, 4, -46 },
  { 8035, 33, 59, 40, 4, -47 },
  { 8279, 34, 46, 40, 4, -46 },
  { 8475, 36, 48, 40, 2, -47 },
  { 8691, 36, 46, 40, 6, -46 },
  { 8898, 34, 47, 40, 5, -46 },
  { 9098, 33, 46, 40, 8, -46 },
  { 9288, 37, 46, 40, 4, -46 },
  { 9501, 42, 46, 40, 0, -46 },
  { 9743, 37, 46, 40, 6, -46 },
  { 9956, 40, 46, 40, 0, -46 },
  { 10186, 27, 59, 40, 12, -50 },
  { 10386, 17, 59, 40, 12, -50 },
  { 10512, 27, 59, 40, 1, -50 },
  { 10712, 32, 26, 40, 5, -46 },
  { 10816, 32, 3, 40, 0, 7 },
  { 10828, 8, 12, 40, 15, -51 },
  { 10840, 31, 36, 40, 4, -35 },
  { 10980, 32, 50, 40, 4, -49 },
  { 11180, 29, 36, 40, 5, -35 },
  { 11311, 34, 50, 40, 4, -49 },
  { 11524, 29, 36, 40, 5, -35 },
  { 11655, 43, 63, 40, -1, -49 },
  { 11994, 32, 49, 40, 3, -35 },
  { 12190, 29, 49, 40, 5, -49 },
  { 12368, 29, 50, 40, 6, -49 },
  { 12550, 30, 63, 40, 5, -49 },
  { 12787, 34, 50, 40, 4, -49 },
  { 13000, 26, 50, 40, 8, -49 },
  { 13163, 35, 35, 40, 2, -35 },
  { 13317, 29, 35, 40, 5, -35 },
  { 13444, 30, 36, 40, 5, -35 },
  { 13579, 34, 48, 40, 2, -35 },
  { 13783, 31, 48, 40, 4, -35 },
  { 13969, 32, 34, 40, 7, -34 },
  { 14105, 31, 36, 40, 4, -35 },
  { 14245, 31, 47, 40, 5, -46 },
  { 14428, 29, 35, 40, 6, -34 },
  { 14555, 30, 34, 40, 5, -34 },
  { 14683, 33, 35, 40, 4, -34 },
  { 14828, 38, 36, 40, 1, -35 },
  { 14999, 33, 48, 40, 2, -34 },
  { 15197, 34, 36, 40, 3, -35 },
  { 15350, 30, 59, 40, 8, -50 },
  { 15572, 13, 59, 40, 14, -50 },
  { 15668, 30, 59, 40, 3, -50 },
  { 15890, 34, 13, 40, 3, -27 },
};

const GFXfont IBMPlexMono_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_LIGHTITALIC66PT7B_H_
