#ifndef _IBMPLEXMONO_LIGHTITALIC7PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x76, 0x7B, 0xC0, 0x27, 0xA6, 0x5E, 0x40, 0xDF,
  0x81, 0xEF, 0x00, 0x6A, 0x6C, 0xF0, 0xC0, 0xEA, 0xA0, 0x44, 0x95, 0x00,
  0x2D, 0x6A, 0x24, 0xF4, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x88, 0x79, 0xB9,
  0xE0, 0x6A, 0x24, 0xF0, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x16, 0x6A,
  0x70, 0x78, 0x61, 0xE0, 0x24, 0x69, 0xE0, 0xE5, 0x48, 0x79, 0x69, 0xE0,
  0xF6, 0xA8, 0x42, 0x42, 0x80, 0x3A, 0x20, 0x7F, 0x42, 0x3C, 0xE5, 0x48,
  0x79, 0xDD, 0xA6, 0x26, 0x66, 0x90, 0x79, 0x69, 0xE0, 0xF2, 0x4E, 0x69,
  0x99, 0xE0, 0x78, 0x78, 0xE0, 0x78, 0x78, 0x80, 0xF2, 0x7C, 0xD9, 0x79,
  0xA0, 0x72, 0x44, 0xE0, 0x71, 0x22, 0xE0, 0x5A, 0x4A, 0xB0, 0xAA, 0xC0,
  0x5F, 0xB9, 0xA0, 0x5D, 0xDB, 0xA0, 0x79, 0x99, 0xE0, 0x79, 0xF8, 0x80,
  0x79, 0x99, 0xA7, 0x79, 0xFA, 0xA0, 0x78, 0x61, 0xE0, 0xF4, 0x88, 0x80,
  0xB6, 0xDC, 0xB7, 0x68, 0x9B, 0xB7, 0xA0, 0x96, 0x46, 0xB0, 0xBC, 0x48,
  0x80, 0x72, 0x44, 0xF0, 0xF2, 0x49, 0x80, 0xA9, 0x50, 0x64, 0xA5, 0x80,
  0x26, 0x90, 0xE0, 0x80, 0x79, 0xAF, 0x4A, 0xD9, 0xE0, 0x56, 0x60, 0x17,
  0x9A, 0xE0, 0x57, 0x70, 0x37, 0x44, 0x4C, 0x79, 0xAA, 0xE0, 0x4A, 0xDA,
  0xA0, 0x52, 0x4E, 0x39, 0x25, 0x80, 0x4A, 0xDE, 0xB0, 0xD2, 0x6E, 0x5F,
  0xDD, 0xAD, 0xAA, 0x2D, 0x9E, 0xAD, 0x9A, 0xC0, 0x79, 0xAA, 0x60, 0xBA,
  0x40, 0x69, 0x6F, 0x9E, 0x4E, 0xB7, 0x60, 0xB6, 0xE0, 0xBD, 0xDF, 0x5F,
  0x4F, 0x99, 0xAA, 0xE0, 0x7A, 0x4F, 0x69, 0x69, 0x80, 0x5A, 0xA0, 0x64,
  0x47, 0x4C, 0x5A,
};

const GFXglyph IBMPlexMono_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 1, 2, 4, 2, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 2, 6, 4, 2, -5 },
  { 21, 3, 6, 4, 0, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 4, 4, 4, 0, -4 },
  { 28, 1, 2, 4, 1, -1 },
  { 29, 2, 1, 4, 1, -3 },
  { 30, 1, 1, 4, 1, -1 },
  { 31, 4, 6, 4, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 3, 5, 4, 1, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 3, 5, 4, 1, -5 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 5, 4, 1, -4 },
  { 65, 3, 4, 4, 1, -4 },
  { 67, 4, 2, 4, 0, -3 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 4, 6, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 2, 5, 4, 1, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 6, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 1, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 1, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 3, 6, 4, 1, -5 },
  { 151, 2, 6, 4, 1, -5 },
  { 153, 3, 6, 4, 0, -5 },
  { 156, 4, 3, 4, 0, -5 },
  { 158, 3, 1, 4, 0, 0 },
  { 159, 1, 1, 4, 2, -5 },
  { 160, 4, 4, 4, 0, -4 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 4, 4, 1, -4 },
  { 172, 4, 6, 4, 0, -5 },
  { 175, 4, 5, 4, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 3, 5, 4, 1, -5 },
  { 183, 3, 6, 4, 1, -5 },
  { 186, 4, 5, 4, 0, -5 },
  { 189, 3, 5, 4, 1, -5 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 5, 4, 0, -4 },
  { 200, 4, 5, 4, 0, -4 },
  { 203, 3, 4, 4, 1, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 3, 5, 4, 1, -5 },
  { 209, 3, 4, 4, 1, -4 },
  { 211, 3, 4, 4, 1, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 5, 4, 0, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 3, 6, 4, 1, -5 },
  { 225, 2, 6, 4, 1, -5 },
  { 227, 4, 6, 4, 0, -5 },
  { 230, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_LIGHTITALIC7PT7B_H_
