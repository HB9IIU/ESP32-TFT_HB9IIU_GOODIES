#ifndef _IBMPLEXMONO_LIGHTITALIC59PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x78, 0x00, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7, 0x81,
  0xCF, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7,
  0x81, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x39,
  0xFC, 0x01, 0xF0, 0x38, 0x3E, 0x03, 0xE0, 0x30, 0x1E, 0x03, 0xC0, 0x30,
  0x0F, 0x07, 0x80, 0x70, 0x06, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x07, 0xC0, 0xC0, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x01, 0xF8, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x8F, 0xC0, 0x00, 0x01, 0x83,
  0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x70, 0x20, 0x07, 0x00, 0xF0, 0xE0, 0x06, 0x00, 0xF0, 0xF0, 0x06, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0xE0, 0x3E, 0x0E, 0x07, 0xC0, 0x1F, 0xCE, 0x3F,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x01,
  0xFF, 0xE0, 0x00, 0x70, 0x07, 0x83, 0xE0, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x3C, 0x01,
  0xC0, 0x06, 0x00, 0x70, 0x07, 0x80, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0x03, 0xC1, 0xF0, 0x70, 0x00,
  0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x03, 0xFF, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0x00, 0x00, 0x70, 0x3C, 0x1E,
  0x00, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0x1E, 0x0F, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xDE, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0x00, 0xFC, 0x07, 0x38, 0x00, 0x13, 0x81, 0xC7, 0x00, 0x06, 0x78,
  0x38, 0xF0, 0x01, 0xC7, 0x0E, 0x0F, 0x00, 0x70, 0xF3, 0xC1, 0xF8, 0x3E,
  0x0E, 0x70, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x79, 0xC7,
  0x1C, 0x71, 0xCF, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x17, 0x80, 0x38, 0x01, 0xDF, 0xC0, 0xE0, 0x7F, 0xBF, 0xE3,
  0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x08, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x0F, 0x00, 0xF7, 0x00,
  0xFC, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xE0,
  0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x3F, 0x0E, 0x00, 0x0F, 0xC1,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x0F, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x82, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x1C, 0x7F, 0xF8, 0x00,
  0xF7, 0xFF, 0xF0, 0x03, 0xBC, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xF8,
  0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x0F, 0xF0, 0x03, 0xC7, 0xFF, 0x80, 0x73, 0xFF, 0xFC, 0x1E, 0xF0,
  0x0F, 0xC3, 0xB8, 0x00, 0x78, 0xFE, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFC,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xB8, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x7D, 0xC0, 0xFF, 0xFF, 0x38,
  0x0F, 0xFF, 0x8E, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xE1, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x61, 0xC0, 0x0F, 0x87, 0x0E, 0x01, 0xFF, 0x38, 0x70, 0x1F,
  0xFD, 0xC3, 0x81, 0xF0, 0x6E, 0x38, 0x0F, 0x01, 0xF1, 0xC0, 0xF0, 0x07,
  0x8E, 0x07, 0x00, 0x3C, 0x70, 0x78, 0x01, 0xC7, 0x83, 0x80, 0x0E, 0x38,
  0x1C, 0x00, 0x71, 0xC0, 0xE0, 0x03, 0x8E, 0x0F, 0x00, 0x1C, 0x70, 0x78,
  0x00, 0xE3, 0x83, 0x80, 0x0E, 0x3C, 0x1C, 0x00, 0x71, 0xC0, 0xE0, 0x03,
  0x8E, 0x07, 0x00, 0x1C, 0x70, 0x38, 0x01, 0xE3, 0x81, 0xC0, 0x0F, 0x1C,
  0x0E, 0x00, 0xF0, 0xE0, 0x78, 0x0F, 0x87, 0x01, 0xE0, 0xDC, 0x38, 0x0F,
  0xFC, 0xE1, 0xC0, 0x3F, 0xC7, 0x0E, 0x00, 0xFC, 0x38, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x78, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x38, 0x00, 0x1F, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x07, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xF8,
  0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0x8E, 0x00,
  0x3F, 0xFC, 0x70, 0x03, 0xFF, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xB8, 0x1E, 0x00, 0x0D, 0xC0, 0x78, 0x00, 0xDE, 0x03, 0xF0, 0x3C, 0xF0,
  0x0F, 0xFF, 0xC7, 0x00, 0x3F, 0xFC, 0x38, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xE1,
  0xF8, 0x00, 0x00, 0x38, 0xFE, 0x00, 0x00, 0x1E, 0x7B, 0xC0, 0x00, 0x07,
  0xBC, 0x70, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0x03, 0x80, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0E, 0xE0, 0x01, 0xDC, 0x0F, 0x70, 0x01,
  0xCE, 0x07, 0xB8, 0x00, 0xE7, 0x03, 0x8E, 0x00, 0xE7, 0x81, 0xC7, 0x00,
  0xF3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x78, 0x70,
  0x38, 0x70, 0x3C, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x3C, 0x3C, 0x0E, 0x0E,
  0x1C, 0x1C, 0x07, 0x03, 0x9C, 0x0E, 0x03, 0x81, 0xCE, 0x07, 0x03, 0xC0,
  0xEE, 0x03, 0x81, 0xE0, 0x7F, 0x01, 0xC0, 0xE0, 0x1F, 0x01, 0xE0, 0x70,
  0x0F, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x1C, 0x01, 0x80, 0x38, 0x1E,
  0x00, 0xC0, 0x1C, 0x0F, 0x00, 0x40, 0x0E, 0x07, 0x00, 0x40, 0x0F, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x0E, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xB8,
  0x00, 0x1E, 0x03, 0xB8, 0x00, 0x1E, 0x07, 0xB8, 0x00, 0x1C, 0x07, 0x3C,
  0x00, 0x1C, 0x07, 0x1C, 0x00, 0x1C, 0x07, 0x1C, 0x00, 0x1C, 0x07, 0x1C,
  0x00, 0x1C, 0x07, 0x1E, 0x00, 0x3C, 0x0F, 0x0E, 0x00, 0x38, 0x0E, 0x0E,
  0x00, 0x38, 0x0E, 0x0F, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07,
  0x00, 0x38, 0x0E, 0x07, 0x00, 0x78, 0x1E, 0x07, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x3C, 0x01,
  0xE0, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x38, 0x00,
  0xE0, 0xE0, 0x38, 0x00, 0xF1, 0xE0, 0x78, 0x00, 0x71, 0xC0, 0x78, 0x00,
  0x71, 0xC0, 0x70, 0x00, 0x79, 0xC0, 0x70, 0x00, 0x39, 0xC0, 0x70, 0x00,
  0x39, 0xC0, 0x70, 0x00, 0x3B, 0xC0, 0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x1F, 0x80, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x04,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x04, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x20, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x78, 0x03, 0x83, 0x80,
  0x7C, 0x01, 0xC1, 0xC0, 0x3E, 0x00, 0xE0, 0xE0, 0x1F, 0x00, 0xE0, 0x70,
  0x1D, 0x80, 0x70, 0x38, 0x0E, 0xC0, 0x38, 0x38, 0x0E, 0x70, 0x1C, 0x1C,
  0x07, 0x38, 0x1C, 0x0E, 0x03, 0x9C, 0x0E, 0x07, 0x03, 0x8E, 0x07, 0x03,
  0x81, 0xC7, 0x03, 0x81, 0xC1, 0xC3, 0x83, 0x80, 0xE0, 0xE1, 0xC1, 0xC0,
  0x70, 0x70, 0xE0, 0xE0, 0x38, 0x70, 0x70, 0x70, 0x1C, 0x38, 0x38, 0x70,
  0x0E, 0x38, 0x1C, 0x38, 0x07, 0x1C, 0x06, 0x1C, 0x07, 0x1C, 0x03, 0x0E,
  0x03, 0x8E, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x73, 0x80, 0x39, 0xC0, 0x3B, 0x80, 0x1D, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xB8, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x80, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0x21, 0xC3, 0xC3, 0x87, 0x87, 0x0E, 0x0E, 0x1C, 0x1C, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x1C, 0x07, 0xFF, 0xE3, 0x83, 0xF0,
  0x1E, 0x70, 0xF8, 0x00, 0xDE, 0x1E, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x05, 0xC1, 0xE0, 0x01, 0xB8, 0x3E, 0x00, 0xE7, 0x03, 0xE0,
  0x79, 0xFE, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0x81, 0xF8, 0x1F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1F,
  0x80, 0x07, 0x0F, 0xFE, 0x00, 0xF1, 0xFF, 0xF8, 0x0F, 0x3C, 0x0F, 0xC0,
  0xF7, 0x00, 0x3C, 0x0E, 0xE0, 0x01, 0xE0, 0xEC, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x78,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0xF6, 0x00, 0x3E, 0x0F,
  0x78, 0x0F, 0xC0, 0xE3, 0xFF, 0xF8, 0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7C, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x06, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x23, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x03, 0xC0, 0x0F,
  0xFF, 0x0E, 0x00, 0x7F, 0xFE, 0x38, 0x03, 0xE0, 0x3C, 0xE0, 0x1E, 0x00,
  0x3B, 0x80, 0xF0, 0x00, 0x6E, 0x07, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x02, 0xE0, 0x1E, 0x00, 0x1B, 0x80,
  0x7C, 0x00, 0xCE, 0x00, 0xF8, 0x1E, 0x38, 0x01, 0xFF, 0xF1, 0xE0, 0x03,
  0xFF, 0x87, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x3F, 0x8E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0,
  0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x02, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x07, 0xFF, 0xE3, 0x80, 0x7E, 0x03,
  0xCE, 0x03, 0xE0, 0x03, 0xB8, 0x0F, 0x00, 0x06, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x7C,
  0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x6F, 0x01,
  0xF0, 0x03, 0x38, 0x03, 0xE0, 0x3C, 0xE0, 0x07, 0xFF, 0xE3, 0x80, 0x0F,
  0xFE, 0x0E, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x02, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x7E, 0x00, 0x70, 0x7F, 0xE0, 0x1C, 0x7F, 0xFC, 0x07,
  0x3C, 0x0F, 0x81, 0xCC, 0x01, 0xE0, 0xF6, 0x00, 0x3C, 0x3F, 0x00, 0x0F,
  0x0E, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38,
  0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x06, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x01, 0xF0,
  0x03, 0x80, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x1C, 0x3E,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x80,
  0x38, 0x01, 0xF0, 0x0E, 0x00, 0x3E, 0x03, 0x80, 0x07, 0xC0, 0xE0, 0x00,
  0xF8, 0x38, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x7D, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x07, 0xF0, 0x00, 0x70, 0x7F, 0xF0, 0x01, 0xC7, 0xFF, 0xE0, 0x0F,
  0x3C, 0x0F, 0x80, 0x3D, 0xC0, 0x0F, 0x00, 0xF6, 0x00, 0x3C, 0x03, 0xB0,
  0x00, 0x70, 0x0E, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x00,
  0xF0, 0x0F, 0x80, 0x03, 0xC3, 0xF8, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x01, 0x1E, 0x03,
  0x80, 0x0E, 0x78, 0x0F, 0x00, 0x7D, 0xC0, 0x1C, 0x03, 0xC7, 0x00, 0x78,
  0x1E, 0x1C, 0x00, 0xE0, 0xF0, 0x70, 0x03, 0xC7, 0x83, 0xC0, 0x07, 0x3C,
  0x0F, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x02, 0x07, 0x80, 0x0C, 0x0F,
  0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0x70, 0x1F, 0x01, 0xE0,
  0x78, 0x03, 0xC3, 0xE0, 0x07, 0x0F, 0x80, 0x0E, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x07, 0x9F, 0xC1, 0xFE, 0x07, 0x3F, 0xE3, 0xFF, 0x07, 0x71,
  0xE7, 0x0F, 0x07, 0x40, 0xF6, 0x07, 0x07, 0x80, 0x7C, 0x07, 0x07, 0x80,
  0x78, 0x07, 0x0F, 0x00, 0x70, 0x07, 0x0F, 0x00, 0x70, 0x07, 0x0E, 0x00,
  0x70, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x0E, 0x00,
  0xE0, 0x0F, 0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x0E, 0x1C, 0x00,
  0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x1C, 0x01,
  0xC0, 0x1E, 0x38, 0x01, 0xC0, 0x1C, 0x38, 0x01, 0xC0, 0x1C, 0x38, 0x01,
  0xC0, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x78, 0x03,
  0x80, 0x3C, 0x70, 0x03, 0x80, 0x38, 0x70, 0x03, 0x80, 0x38, 0x70, 0x07,
  0x80, 0x38, 0x70, 0x07, 0x00, 0x38, 0x70, 0x07, 0x00, 0x38, 0xF0, 0x07,
  0x00, 0x78, 0x00, 0x01, 0xF8, 0x01, 0xE1, 0xFF, 0x80, 0x71, 0xFF, 0xF0,
  0x1C, 0xF0, 0x3E, 0x07, 0x30, 0x07, 0x83, 0xD8, 0x00, 0xF0, 0xFC, 0x00,
  0x3C, 0x3A, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x3C, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0x0F, 0xFE, 0x00, 0x1C, 0x7F, 0xFE, 0x00, 0xF3, 0xC0, 0xFC, 0x03, 0xDC,
  0x00, 0xF0, 0x0E, 0xE0, 0x01, 0xE0, 0x3B, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0x60, 0x03, 0xE0, 0x3D, 0xE0, 0x3F, 0x00, 0xE3, 0xFF, 0xF8, 0x03,
  0x83, 0xFF, 0x80, 0x0E, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0x01, 0xFF, 0xF8, 0xE0,
  0x3F, 0x03, 0xCE, 0x07, 0x80, 0x0E, 0xE0, 0xF0, 0x00, 0x6E, 0x1E, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x6E, 0x07,
  0xC0, 0x0C, 0xE0, 0x3E, 0x07, 0x8E, 0x01, 0xFF, 0xF0, 0xE0, 0x0F, 0xFE,
  0x1E, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0x3C, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x80, 0x3F, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0xC0, 0x78, 0x07, 0xC0, 0x0E, 0x01, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0x38,
  0x7E, 0x00, 0x07, 0x1F, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0xDC, 0x1C, 0x00, 0x27, 0x07, 0x80, 0x3B, 0xC1, 0xF8,
  0x3C, 0xF0, 0x3F, 0xFE, 0x38, 0x07, 0xFF, 0x0E, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC7, 0xFE, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0xEF, 0xFE,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0xE3,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x38, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x01,
  0xC3, 0x80, 0x38, 0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x70, 0x03, 0x80, 0x71,
  0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70,
  0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01, 0xCE, 0x00, 0x70, 0x07, 0x38, 0x03,
  0x80, 0x1C, 0xE0, 0x0E, 0x00, 0x73, 0x80, 0x38, 0x01, 0xCE, 0x00, 0xE0,
  0x07, 0x38, 0x03, 0x80, 0x1D, 0xC0, 0x0E, 0x00, 0x77, 0x00, 0x70, 0x03,
  0xDC, 0x01, 0xC0, 0x0E, 0x70, 0x07, 0x00, 0x39, 0xC0, 0x1C, 0x00, 0xE7,
  0x00, 0x70, 0x07, 0xB8, 0x03, 0xC0, 0x1C, 0xE0, 0x0F, 0x00, 0xF3, 0x80,
  0x7C, 0x03, 0x8E, 0x01, 0x70, 0x1E, 0x3C, 0x0D, 0xC0, 0xF0, 0x78, 0x67,
  0x87, 0x81, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xDE, 0x1E, 0x1E, 0x0F, 0xC3, 0x87, 0x03, 0x87, 0xC0,
  0xE3, 0x80, 0xF3, 0xC0, 0x1C, 0xC0, 0x1C, 0xE0, 0x07, 0x60, 0x07, 0x00,
  0x01, 0xD8, 0x01, 0xC0, 0x00, 0x74, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xB0, 0x00, 0x0E, 0x00,
  0x6C, 0x00, 0x03, 0x80, 0x1B, 0x80, 0x10, 0xE0, 0x0C, 0xE0, 0x0E, 0x38,
  0x03, 0x38, 0x07, 0xCE, 0x01, 0xCE, 0x07, 0xC3, 0xC0, 0xE3, 0xC7, 0xC0,
  0xF8, 0x70, 0x73, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x3F, 0x01, 0xC0, 0x01, 0x70, 0x0F, 0x00, 0x1B, 0x80,
  0x78, 0x01, 0x9C, 0x01, 0xF0, 0x39, 0xE0, 0x0F, 0xFF, 0x8F, 0x00, 0x3F,
  0xF8, 0x78, 0x00, 0x7F, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0xF0, 0x7F, 0xFF, 0x83, 0x81, 0xE0, 0x3F, 0x8E, 0x0F, 0x00, 0x1F, 0xB8,
  0x38, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x01, 0xF0, 0x03, 0x80,
  0x0F, 0x80, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x87, 0xFF, 0x00, 0x0E, 0x1D, 0xFF,
  0xE0, 0x38, 0xF0, 0x7F, 0xF8, 0xE3, 0xC0, 0x1F, 0xFF, 0x8E, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x08, 0x1F, 0xE0, 0x00, 0x70, 0xFF, 0xC0, 0x01, 0xC3, 0xC7,
  0x80, 0x0E, 0x1C, 0x0F, 0x00, 0x38, 0xE0, 0x1E, 0x01, 0xE3, 0x80, 0x38,
  0x07, 0x1C, 0x00, 0xF0, 0x38, 0x70, 0x01, 0xE1, 0xE3, 0x80, 0x03, 0xFF,
  0x0E, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 12, 41, 35, 12, -41 },
  { 63, 15, 16, 35, 14, -44 },
  { 93, 35, 41, 35, 1, -41 },
  { 273, 32, 55, 35, 2, -48 },
  { 493, 39, 43, 35, -1, -42 },
  { 703, 35, 43, 35, 0, -42 },
  { 892, 6, 16, 35, 18, -44 },
  { 904, 20, 53, 35, 13, -45 },
  { 1037, 21, 53, 35, 3, -45 },
  { 1177, 30, 29, 35, 3, -32 },
  { 1286, 28, 29, 35, 4, -32 },
  { 1388, 11, 16, 35, 9, -7 },
  { 1410, 17, 3, 35, 10, -19 },
  { 1417, 7, 6, 35, 12, -6 },
  { 1423, 33, 53, 35, 2, -45 },
  { 1642, 29, 43, 35, 4, -42 },
  { 1798, 27, 41, 35, 3, -41 },
  { 1937, 30, 42, 35, 2, -42 },
  { 2095, 30, 43, 35, 2, -42 },
  { 2257, 31, 41, 35, 1, -41 },
  { 2416, 30, 42, 35, 3, -41 },
  { 2574, 27, 42, 35, 4, -41 },
  { 2716, 29, 41, 35, 6, -41 },
  { 2865, 30, 43, 35, 3, -42 },
  { 3027, 27, 42, 35, 6, -42 },
  { 3169, 11, 31, 35, 12, -31 },
  { 3212, 14, 40, 35, 9, -31 },
  { 3282, 29, 33, 35, 5, -35 },
  { 3402, 30, 14, 35, 3, -25 },
  { 3455, 28, 33, 35, 3, -35 },
  { 3571, 25, 42, 35, 8, -42 },
  { 3703, 29, 48, 35, 4, -42 },
  { 3877, 31, 41, 35, 0, -41 },
  { 4036, 29, 41, 35, 3, -41 },
  { 4185, 29, 43, 35, 5, -42 },
  { 4341, 30, 41, 35, 3, -41 },
  { 4495, 32, 41, 35, 3, -41 },
  { 4659, 32, 41, 35, 3, -41 },
  { 4823, 29, 43, 35, 4, -42 },
  { 4979, 32, 41, 35, 3, -41 },
  { 5143, 32, 41, 35, 3, -41 },
  { 5307, 28, 42, 35, 4, -41 },
  { 5454, 34, 41, 35, 3, -41 },
  { 5629, 24, 41, 35, 5, -41 },
  { 5752, 33, 41, 35, 2, -41 },
  { 5922, 32, 41, 35, 3, -41 },
  { 6086, 29, 43, 35, 4, -42 },
  { 6242, 31, 41, 35, 3, -41 },
  { 6401, 29, 53, 35, 4, -42 },
  { 6594, 31, 41, 35, 3, -41 },
  { 6753, 32, 43, 35, 2, -42 },
  { 6925, 32, 41, 35, 6, -41 },
  { 7089, 30, 42, 35, 5, -41 },
  { 7247, 30, 41, 35, 7, -41 },
  { 7401, 33, 41, 35, 4, -41 },
  { 7571, 37, 41, 35, 0, -41 },
  { 7761, 32, 41, 35, 6, -41 },
  { 7925, 36, 41, 35, 0, -41 },
  { 8110, 25, 53, 35, 10, -45 },
  { 8276, 15, 53, 35, 11, -45 },
  { 8376, 24, 53, 35, 1, -45 },
  { 8535, 29, 23, 35, 4, -41 },
  { 8619, 29, 3, 35, 0, 6 },
  { 8630, 7, 11, 35, 14, -46 },
  { 8640, 27, 32, 35, 4, -31 },
  { 8748, 28, 45, 35, 4, -44 },
  { 8906, 25, 32, 35, 5, -31 },
  { 9006, 30, 45, 35, 4, -44 },
  { 9175, 26, 32, 35, 5, -31 },
  { 9279, 38, 57, 35, -1, -44 },
  { 9550, 30, 44, 35, 2, -31 },
  { 9715, 26, 44, 35, 4, -44 },
  { 9858, 26, 44, 35, 5, -43 },
  { 10001, 26, 57, 35, 5, -44 },
  { 10187, 30, 45, 35, 4, -44 },
  { 10356, 23, 45, 35, 7, -44 },
  { 10486, 32, 31, 35, 1, -31 },
  { 10610, 26, 31, 35, 4, -31 },
  { 10711, 27, 32, 35, 4, -31 },
  { 10819, 30, 43, 35, 2, -31 },
  { 10981, 28, 43, 35, 4, -31 },
  { 11132, 28, 30, 35, 7, -30 },
  { 11237, 28, 32, 35, 3, -31 },
  { 11349, 27, 42, 35, 5, -41 },
  { 11491, 26, 31, 35, 5, -30 },
  { 11592, 28, 31, 35, 4, -31 },
  { 11701, 30, 32, 35, 3, -31 },
  { 11821, 34, 32, 35, 1, -31 },
  { 11957, 29, 43, 35, 2, -30 },
  { 12113, 30, 32, 35, 3, -31 },
  { 12233, 27, 53, 35, 7, -45 },
  { 12412, 12, 53, 35, 12, -45 },
  { 12492, 27, 53, 35, 3, -45 },
  { 12671, 30, 12, 35, 3, -24 },
};

const GFXfont IBMPlexMono_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_LIGHTITALIC59PT7B_H_
