#ifndef _IBMPLEXMONO_LIGHTITALIC22PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x24, 0x44, 0x00, 0x0C, 0xC0, 0x4D, 0x24, 0xB2,
  0x8A, 0x20, 0x01, 0x10, 0x0C, 0xC0, 0x22, 0x00, 0x88, 0x06, 0x60, 0xF1,
  0xF0, 0x44, 0x03, 0x30, 0x08, 0x83, 0xE3, 0xC1, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x88, 0x02, 0x20, 0x00, 0x01, 0x00, 0x10, 0x0F, 0xC3, 0x26, 0x22,
  0x36, 0x20, 0x62, 0x02, 0x20, 0x3A, 0x00, 0xF8, 0x04, 0xC0, 0x44, 0x04,
  0x60, 0x44, 0x88, 0x4C, 0x98, 0x3F, 0x00, 0x80, 0x08, 0x00, 0x1E, 0x04,
  0xC4, 0x22, 0x11, 0x88, 0x44, 0x21, 0x20, 0x89, 0x01, 0xCC, 0x00, 0x00,
  0x08, 0xE0, 0x24, 0x41, 0x21, 0x08, 0x84, 0x62, 0x11, 0x08, 0xC8, 0x1C,
  0x00, 0x07, 0x80, 0x42, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x04, 0x20, 0x32,
  0x06, 0xE0, 0x46, 0x06, 0x10, 0x20, 0x41, 0x02, 0x1C, 0x29, 0x21, 0x68,
  0xF1, 0x80, 0x5E, 0xA0, 0x06, 0x18, 0x60, 0x82, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0x81, 0x80, 0x18, 0x04,
  0x06, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0F,
  0x4E, 0x3F, 0x03, 0x80, 0xD0, 0x11, 0x04, 0x21, 0x02, 0x00, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0xFF, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x00, 0x32, 0x64, 0xC0, 0xFC, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x07, 0x83, 0x0C, 0xC0, 0x90, 0x16, 0x02, 0x80, 0x51, 0x8A, 0x31,
  0x40, 0x38, 0x0F, 0x01, 0x20, 0x24, 0x08, 0xC3, 0x0F, 0x80, 0x03, 0x03,
  0x41, 0x90, 0xC4, 0x43, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x0F, 0xFC, 0x0F, 0x83, 0x08, 0xC1, 0x90, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x3F, 0xF0, 0x0F, 0x83, 0x08, 0x81, 0x80, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x78, 0x01, 0x80, 0x18, 0x01, 0x00, 0x68, 0x09, 0x83, 0x0F, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x46, 0x0C, 0x41, 0x84, 0x10,
  0x42, 0x04, 0x40, 0xC7, 0xFF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x1F, 0xE2,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0B, 0xE1, 0x86, 0x40, 0x40, 0x08,
  0x01, 0x00, 0x2C, 0x0C, 0xC3, 0x0F, 0x80, 0x01, 0xC0, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x0B, 0xE2, 0x86, 0x60, 0x48, 0x0D, 0x01, 0xE0, 0x24,
  0x0C, 0xC3, 0x0F, 0x80, 0x7F, 0xE8, 0x0D, 0x01, 0x60, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18,
  0x00, 0x07, 0xC3, 0x0C, 0xC0, 0x90, 0x12, 0x02, 0x40, 0x44, 0x30, 0x78,
  0x30, 0xC8, 0x0B, 0x01, 0xC0, 0x3C, 0x04, 0xC3, 0x0F, 0xC0, 0x1F, 0x0C,
  0x24, 0x07, 0x01, 0x80, 0x60, 0x1C, 0x0D, 0x87, 0x3E, 0x80, 0x60, 0x30,
  0x08, 0x0C, 0x06, 0x06, 0x00, 0x76, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x1C,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC2, 0x18, 0x43, 0x00, 0x00, 0x60,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0x40, 0x00, 0x3E, 0x30, 0xF0, 0x30, 0x10, 0x08, 0x0C, 0x0C, 0x3C,
  0x10, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x07, 0x83, 0x0C, 0x40,
  0x90, 0x12, 0x3A, 0xC8, 0xD3, 0x0A, 0x43, 0x48, 0x49, 0x09, 0x21, 0x64,
  0x6C, 0xF4, 0x80, 0x10, 0x03, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x30, 0x0A,
  0x01, 0x60, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x43, 0xFC, 0x81, 0x90,
  0x14, 0x02, 0x80, 0x70, 0x08, 0x1F, 0xC6, 0x0C, 0xC0, 0x90, 0x12, 0x02,
  0x40, 0xC8, 0x33, 0xF8, 0x60, 0xC8, 0x09, 0x01, 0x20, 0x24, 0x05, 0x81,
  0x3F, 0xC0, 0x0F, 0x82, 0x18, 0x81, 0x30, 0x34, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x4C, 0x18, 0x86, 0x0F, 0x80, 0x1F,
  0x82, 0x18, 0xC1, 0x98, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x60, 0x2C,
  0x0D, 0x01, 0x20, 0x24, 0x08, 0x83, 0x3F, 0x80, 0x1F, 0xF3, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFE, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xC0, 0x1F, 0xF3, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFC, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x8C, 0x32, 0x05, 0x02, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x87, 0xE0, 0x28, 0x0A, 0x02, 0x81, 0x90, 0xA3,
  0xD8, 0x30, 0x33, 0x03, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x60, 0x67,
  0xFE, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0xC0, 0xCC, 0x0C, 0x80, 0x80,
  0x3F, 0xF0, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0xFF, 0xC0, 0x0F,
  0xE0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x4C, 0x18, 0xC6, 0x0F, 0x80, 0x10, 0x19, 0x81, 0x0C,
  0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0xB0, 0x0F, 0xC0, 0x72, 0x03, 0x18,
  0x10, 0x40, 0x83, 0x04, 0x08, 0x60, 0x63, 0x01, 0x00, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0xFE, 0x30, 0x33, 0x03, 0x38, 0x52, 0x8F, 0x68, 0xA6, 0x92, 0x4D,
  0x24, 0x62, 0x46, 0x24, 0x46, 0xC0, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0xC0, 0x38, 0x13, 0x83, 0x28, 0x22, 0x82, 0x2C, 0x22, 0x42, 0x64, 0x24,
  0x66, 0x42, 0x44, 0x24, 0x42, 0x44, 0x34, 0xC1, 0x48, 0x1C, 0x81, 0x80,
  0x07, 0x83, 0x0C, 0xC0, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x38, 0x0F, 0x01, 0x20, 0x24, 0x08, 0xC3, 0x0F, 0x80, 0x1F, 0xC3, 0x02,
  0x30, 0x32, 0x03, 0x20, 0x32, 0x02, 0x20, 0x67, 0xF8, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x83, 0x0C, 0xC0,
  0x90, 0x16, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x38, 0x0F, 0x01, 0x20,
  0x24, 0x08, 0xC3, 0x0F, 0x80, 0x20, 0x06, 0x60, 0x58, 0x04, 0x00, 0x1F,
  0xC3, 0x02, 0x30, 0x32, 0x03, 0x20, 0x32, 0x02, 0x20, 0x67, 0xF8, 0x62,
  0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x8C, 0x08, 0xC0, 0xC0, 0x0F, 0xC3,
  0x06, 0x20, 0x36, 0x00, 0x60, 0x02, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x80, 0x4E, 0x18, 0x3F, 0x00, 0xFF, 0xF0, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x60, 0x6C, 0x0D, 0x01,
  0x20, 0x24, 0x04, 0x80, 0xB0, 0x36, 0x06, 0x80, 0x90, 0x12, 0x02, 0x40,
  0xC8, 0x11, 0x86, 0x1F, 0x80, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x48, 0x19,
  0x82, 0x10, 0xC2, 0x10, 0x46, 0x08, 0x81, 0x30, 0x24, 0x07, 0x80, 0x60,
  0x0C, 0x00, 0x20, 0x0B, 0x00, 0x98, 0x04, 0x80, 0x24, 0x61, 0x23, 0x11,
  0x18, 0x89, 0x44, 0x49, 0x62, 0xCA, 0x14, 0x50, 0xA2, 0x86, 0x1C, 0x70,
  0xC3, 0x06, 0x00, 0x10, 0x0C, 0x60, 0x60, 0x83, 0x03, 0x08, 0x04, 0x40,
  0x1A, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x36, 0x00, 0x88, 0x04, 0x30,
  0x20, 0x41, 0x81, 0x8C, 0x03, 0x00, 0xC0, 0x34, 0x02, 0x40, 0x42, 0x0C,
  0x21, 0x83, 0x10, 0x12, 0x01, 0xE0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0xFF, 0x80, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x1F, 0x80, 0x82, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x82, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x83, 0x0F, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x1F, 0x80, 0x06, 0x03, 0xC0, 0x90, 0x44,
  0x30, 0x88, 0x24, 0x0E, 0x01, 0x80, 0x40, 0xFF, 0xE0, 0xC9, 0x10, 0x1F,
  0x66, 0x19, 0x81, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x36, 0x04, 0x41, 0x8C,
  0x50, 0xF3, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x4F, 0x0A,
  0x11, 0x83, 0x20, 0x24, 0x05, 0x81, 0xA0, 0x34, 0x04, 0x81, 0x98, 0x66,
  0xF8, 0x1F, 0x10, 0xD0, 0x38, 0x08, 0x04, 0x02, 0x01, 0x01, 0x81, 0x21,
  0x8F, 0x00, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF6, 0x30,
  0xE6, 0x04, 0x40, 0x44, 0x04, 0xC0, 0x4C, 0x0C, 0xC0, 0x84, 0x18, 0x62,
  0x83, 0xC8, 0x1F, 0x10, 0x50, 0x30, 0x18, 0x37, 0xE2, 0x01, 0x01, 0x81,
  0xE1, 0x8F, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x7F, 0xE0, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x21, 0x00, 0xC4, 0x01, 0x90, 0x03, 0x40,
  0x07, 0x00, 0x0F, 0x66, 0x1C, 0x81, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x36,
  0x04, 0x41, 0x8C, 0x50, 0xF2, 0x00, 0x40, 0x11, 0x86, 0x1F, 0x00, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x79, 0x46, 0xC1, 0x40, 0xA0, 0x70, 0x38,
  0x18, 0x1C, 0x0A, 0x05, 0x02, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x42, 0x11, 0xC4, 0xC3, 0x40,
  0x60, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xC4, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x62, 0x18, 0xC4, 0x19, 0x03,
  0x40, 0x70, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x78, 0x28,
  0x43, 0x04, 0x20, 0x42, 0x08, 0x63, 0x04, 0xC0, 0x44, 0x24, 0x67, 0x42,
  0xCC, 0x38, 0xF8, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x21, 0x62, 0x44, 0x58, 0x60, 0x7C, 0xEC, 0xE5, 0x08, 0xA1, 0x14,
  0x43, 0x88, 0x61, 0x0C, 0x23, 0x84, 0x51, 0x8A, 0x21, 0x00, 0x6F, 0x28,
  0xD8, 0x28, 0x14, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x40, 0xA0, 0x40, 0x1F,
  0x08, 0x64, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0A, 0x02, 0x81, 0xB0, 0xC3,
  0xC0, 0x37, 0x85, 0x08, 0xC1, 0x90, 0x12, 0x02, 0xC0, 0xD0, 0x1A, 0x02,
  0x40, 0xCC, 0x33, 0x7C, 0x60, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x66,
  0x1D, 0x81, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x36, 0x04, 0x41, 0x8C, 0x50,
  0xF2, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x79, 0xF1, 0x40, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x0F,
  0x86, 0x0C, 0x80, 0x10, 0x03, 0x00, 0x1F, 0x00, 0x30, 0x02, 0x80, 0x4C,
  0x10, 0xFC, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC6, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC2, 0x23, 0x0B, 0x03, 0x00, 0x40, 0xD0,
  0x24, 0x09, 0x02, 0xC0, 0xB0, 0x68, 0x1A, 0x04, 0x83, 0x31, 0x47, 0x90,
  0xF0, 0x88, 0x32, 0x04, 0x81, 0x20, 0xD8, 0x26, 0x09, 0x04, 0x43, 0x13,
  0x87, 0x80, 0x22, 0x2C, 0x45, 0x08, 0xA1, 0x14, 0x62, 0x88, 0x51, 0x0C,
  0x21, 0x84, 0x5B, 0x99, 0xCE, 0x00, 0x0C, 0x71, 0x94, 0x50, 0xC2, 0x06,
  0x10, 0x20, 0x01, 0x00, 0x08, 0x18, 0xC0, 0x86, 0x16, 0x5B, 0x1C, 0x60,
  0x20, 0x64, 0x08, 0x81, 0x10, 0x26, 0x04, 0xC1, 0x90, 0x32, 0x04, 0x41,
  0x8C, 0x50, 0xF2, 0x00, 0xC0, 0x11, 0x06, 0x1F, 0x00, 0x1E, 0x24, 0x3D,
  0x83, 0x20, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x86, 0x60, 0x5F, 0x8A, 0x1F,
  0x00, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x0C,
  0x3C, 0x01, 0x80, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0xF0, 0x11, 0x32, 0x22, 0x22, 0x64, 0x44, 0x44, 0x48, 0x88, 0x88,
  0x1F, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x04, 0x00,
  0xF0, 0xC0, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x43,
  0xE0, 0x38, 0x28, 0x85, 0x19, 0x41, 0xC0,
};

const GFXglyph IBMPlexMono_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 5, -15 },
  { 9, 6, 6, 13, 5, -16 },
  { 14, 14, 15, 13, 0, -15 },
  { 41, 12, 19, 13, 1, -17 },
  { 70, 14, 15, 13, 0, -15 },
  { 97, 13, 15, 13, 0, -15 },
  { 122, 2, 6, 13, 7, -16 },
  { 124, 7, 20, 13, 5, -17 },
  { 142, 8, 20, 13, 1, -17 },
  { 162, 11, 11, 13, 1, -12 },
  { 178, 11, 11, 13, 1, -12 },
  { 194, 4, 5, 13, 3, -2 },
  { 197, 6, 1, 13, 4, -7 },
  { 198, 2, 2, 13, 5, -2 },
  { 199, 12, 20, 13, 1, -17 },
  { 229, 11, 15, 13, 1, -15 },
  { 250, 10, 15, 13, 1, -15 },
  { 269, 11, 15, 13, 1, -15 },
  { 290, 11, 15, 13, 1, -15 },
  { 311, 12, 15, 13, 0, -15 },
  { 334, 11, 15, 13, 1, -15 },
  { 355, 11, 15, 13, 1, -15 },
  { 376, 11, 15, 13, 2, -15 },
  { 397, 11, 15, 13, 1, -15 },
  { 418, 10, 15, 13, 2, -15 },
  { 437, 4, 11, 13, 5, -11 },
  { 443, 6, 14, 13, 3, -11 },
  { 454, 11, 12, 13, 2, -13 },
  { 471, 11, 5, 13, 1, -9 },
  { 478, 11, 12, 13, 1, -13 },
  { 495, 9, 15, 13, 3, -15 },
  { 512, 11, 17, 13, 1, -15 },
  { 536, 11, 15, 13, 0, -15 },
  { 557, 11, 15, 13, 1, -15 },
  { 578, 11, 15, 13, 2, -15 },
  { 599, 11, 15, 13, 1, -15 },
  { 620, 12, 15, 13, 1, -15 },
  { 643, 12, 15, 13, 1, -15 },
  { 666, 10, 15, 13, 2, -15 },
  { 685, 12, 15, 13, 1, -15 },
  { 708, 12, 15, 13, 1, -15 },
  { 731, 11, 15, 13, 1, -15 },
  { 752, 13, 15, 13, 1, -15 },
  { 777, 9, 15, 13, 2, -15 },
  { 794, 12, 15, 13, 1, -15 },
  { 817, 12, 15, 13, 1, -15 },
  { 840, 11, 15, 13, 1, -15 },
  { 861, 12, 15, 13, 1, -15 },
  { 884, 11, 19, 13, 1, -15 },
  { 911, 12, 15, 13, 1, -15 },
  { 934, 12, 15, 13, 1, -15 },
  { 957, 12, 15, 13, 2, -15 },
  { 980, 11, 15, 13, 2, -15 },
  { 1001, 11, 15, 13, 3, -15 },
  { 1022, 13, 15, 13, 1, -15 },
  { 1047, 14, 15, 13, 0, -15 },
  { 1074, 12, 15, 13, 2, -15 },
  { 1097, 13, 15, 13, 0, -15 },
  { 1122, 9, 20, 13, 4, -17 },
  { 1145, 6, 20, 13, 4, -17 },
  { 1160, 9, 20, 13, 0, -17 },
  { 1183, 10, 9, 13, 2, -15 },
  { 1195, 11, 1, 13, 0, 2 },
  { 1197, 3, 4, 13, 5, -17 },
  { 1199, 11, 11, 13, 1, -11 },
  { 1215, 11, 16, 13, 1, -16 },
  { 1237, 9, 11, 13, 2, -11 },
  { 1250, 12, 16, 13, 1, -16 },
  { 1274, 9, 11, 13, 2, -11 },
  { 1287, 14, 20, 13, 0, -16 },
  { 1322, 11, 15, 13, 1, -11 },
  { 1343, 9, 16, 13, 2, -16 },
  { 1361, 10, 16, 13, 2, -16 },
  { 1381, 10, 20, 13, 2, -16 },
  { 1406, 12, 16, 13, 1, -16 },
  { 1430, 8, 16, 13, 3, -16 },
  { 1446, 11, 11, 13, 1, -11 },
  { 1462, 9, 11, 13, 2, -11 },
  { 1475, 10, 11, 13, 2, -11 },
  { 1489, 11, 15, 13, 1, -11 },
  { 1510, 11, 15, 13, 1, -11 },
  { 1531, 11, 11, 13, 2, -11 },
  { 1547, 11, 11, 13, 1, -11 },
  { 1563, 10, 15, 13, 2, -15 },
  { 1582, 10, 11, 13, 2, -11 },
  { 1596, 10, 11, 13, 2, -11 },
  { 1610, 11, 11, 13, 1, -11 },
  { 1626, 13, 11, 13, 0, -11 },
  { 1644, 11, 15, 13, 1, -11 },
  { 1665, 11, 11, 13, 1, -11 },
  { 1681, 10, 20, 13, 3, -17 },
  { 1706, 4, 20, 13, 5, -17 },
  { 1716, 10, 20, 13, 1, -17 },
  { 1741, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_LIGHTITALIC22PT7B_H_
