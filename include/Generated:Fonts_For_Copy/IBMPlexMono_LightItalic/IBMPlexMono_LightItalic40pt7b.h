#ifndef _IBMPLEXMONO_LIGHTITALIC40PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0x70, 0x30, 0xCC, 0x33, 0x0D, 0xC3, 0x60, 0xD8,
  0x76, 0x19, 0x86, 0x61, 0xB8, 0x6C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x1F, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFE, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x01, 0x83, 0x00, 0x03, 0x83, 0x00, 0x03, 0x06, 0x00, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3C, 0x4F, 0x81, 0xC3, 0x0F, 0x0E, 0x0C, 0x0C, 0x30, 0x30, 0x41, 0xC0,
  0xC0, 0x07, 0x02, 0x00, 0x1C, 0x08, 0x00, 0x30, 0x60, 0x00, 0xE1, 0x80,
  0x03, 0xC6, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x0C, 0xF0, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x08,
  0x1C, 0x00, 0x60, 0x70, 0x01, 0x81, 0xC4, 0x06, 0x06, 0x38, 0x18, 0x38,
  0x70, 0x61, 0xC0, 0xF1, 0x1E, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0x60, 0x3F, 0x80, 0x18, 0x0C, 0x38, 0x06, 0x03, 0x03, 0x01, 0xC0,
  0xE0, 0x20, 0x30, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC3, 0x00, 0x60, 0x30,
  0x60, 0x0C, 0x06, 0x18, 0x01, 0x80, 0xC6, 0x00, 0x30, 0x31, 0xC0, 0x07,
  0x0E, 0x30, 0x00, 0x7F, 0x88, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE3, 0x0E, 0x00, 0x18, 0xC0, 0xC0, 0x06,
  0x30, 0x08, 0x01, 0x86, 0x01, 0x00, 0x30, 0xC0, 0x60, 0x0C, 0x18, 0x0C,
  0x03, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x01,
  0xC3, 0x81, 0x80, 0x1F, 0xE0, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xC3, 0x80,
  0x0F, 0xEF, 0x00, 0x1C, 0x78, 0x00, 0x30, 0x30, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x06, 0xE0, 0x0B, 0x07, 0x60, 0x0B, 0x8C, 0x70, 0x19, 0x8C,
  0x78, 0x31, 0xD8, 0x3F, 0xE0, 0xF8, 0x0F, 0xC0, 0x70, 0x33, 0x33, 0x76,
  0x66, 0x66, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x02, 0x00, 0xC0, 0x4E, 0x06, 0x0F, 0xFE, 0x73, 0xF0, 0x7F, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xCC, 0x00, 0x1C, 0x70,
  0x01, 0xC1, 0x80, 0x1C, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x20,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x61, 0xC3, 0x00,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xE1, 0x80, 0x06,
  0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07, 0x60, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0xE0, 0x6E, 0x0F, 0x06, 0xC0, 0xE0, 0x6C, 0x0E,
  0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07,
  0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xE7, 0x00, 0x38, 0xC0, 0x1E, 0x18, 0x07, 0x83, 0x01,
  0xE0, 0x60, 0x10, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00,
  0xE0, 0x60, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x3C,
  0x0E, 0x00, 0xE0, 0x60, 0x03, 0x82, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x71, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x70, 0x03, 0x81, 0xE0, 0x78,
  0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x71,
  0x80, 0x07, 0x1C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x81, 0x80, 0x38, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x61, 0xC0, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x31, 0xFC, 0x01, 0x9F, 0xF0, 0x0F, 0x83, 0xC0, 0x70, 0x07, 0x05,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x70,
  0x03, 0x81, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE3,
  0xF0, 0x73, 0xFF, 0x1F, 0x81, 0xE6, 0x80, 0x3B, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C,
  0x00, 0x3B, 0x80, 0x0C, 0x60, 0x07, 0x1E, 0x07, 0x83, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x60,
  0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x8E, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x38, 0x1C, 0x00, 0xE0, 0xC0, 0x03,
  0x0E, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xE0,
  0x03, 0x03, 0x00, 0x38, 0x0E, 0x07, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x38, 0x0E, 0x07, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00,
  0x19, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x03, 0x1C,
  0x00, 0x38, 0x70, 0x03, 0x83, 0xE0, 0x78, 0x0F, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xE0, 0x70, 0xE0, 0x0E, 0x70, 0x01,
  0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xDC, 0x01, 0x67, 0x81, 0xF8, 0xFF,
  0xCC, 0x0F, 0xC7, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0x70, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0x67, 0x00, 0x3B, 0x00,
  0x0F, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0x60, 0xC0, 0x0E,
  0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x3E, 0x66, 0x0F, 0xED,
  0x83, 0x85, 0xB0, 0xE0, 0x76, 0x18, 0x0C, 0xC3, 0x01, 0x98, 0xE0, 0x37,
  0x18, 0x06, 0xC3, 0x00, 0xD8, 0x60, 0x3B, 0x0C, 0x06, 0x61, 0x80, 0xCC,
  0x30, 0x39, 0x86, 0x0B, 0x30, 0xE3, 0x66, 0x0F, 0xDC, 0xC0, 0x70, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC7, 0x00, 0x06,
  0x38, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80,
  0x1C, 0x0C, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x0C, 0x07, 0x00,
  0x60, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x0C,
  0x00, 0x38, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01,
  0x98, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0E,
  0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0C,
  0x18, 0x03, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x38, 0x30, 0x00,
  0xC3, 0x00, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x8E, 0x00, 0x78, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xC1, 0xC0,
  0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x43, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x06, 0x00, 0x1C, 0x60,
  0x01, 0x87, 0x00, 0x30, 0x30, 0x07, 0x03, 0xC1, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x03, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x31, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x33, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x30,
  0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01, 0xC6,
  0x00, 0x38, 0x60, 0x07, 0x06, 0x01, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0x81, 0xC0, 0xE0, 0x0E, 0x0C, 0x00, 0x61, 0xC0,
  0x07, 0x38, 0x00, 0x43, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x3F, 0xCE,
  0x07, 0xFC, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x86, 0x00, 0x58, 0x70, 0x0F,
  0x83, 0x81, 0xB0, 0x1F, 0xF3, 0x00, 0xFC, 0x30, 0x0E, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x1C,
  0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xE3, 0x80, 0x06, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xE0, 0x1C, 0x0E,
  0x0F, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xC0, 0x0E, 0x01, 0x80, 0x38,
  0x03, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0x60, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x3E, 0x00, 0x0E,
  0xCC, 0x00, 0x1F, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xD8, 0x07, 0xC1, 0xB0, 0x0D, 0x83, 0x70, 0x33, 0x06, 0x60, 0x6E, 0x1C,
  0xC1, 0x98, 0x39, 0x87, 0x30, 0x61, 0x8C, 0x60, 0xC3, 0x30, 0xC1, 0x86,
  0x61, 0x83, 0x0D, 0x87, 0x0E, 0x0F, 0x0C, 0x1C, 0x1C, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0xC0, 0x80, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x18,
  0x78, 0x00, 0xC3, 0xE0, 0x06, 0x1B, 0x00, 0x30, 0xD8, 0x03, 0x86, 0xC0,
  0x1C, 0x77, 0x00, 0xC3, 0x18, 0x06, 0x18, 0xC0, 0x30, 0xC6, 0x01, 0x86,
  0x18, 0x1C, 0x30, 0xC0, 0xE3, 0x86, 0x06, 0x18, 0x38, 0x30, 0xC0, 0xC1,
  0x86, 0x06, 0x0C, 0x30, 0x30, 0xE1, 0x81, 0xC7, 0x1C, 0x06, 0x30, 0xC0,
  0x31, 0x86, 0x01, 0x8C, 0x30, 0x06, 0x61, 0x80, 0x37, 0x0C, 0x01, 0xB8,
  0xE0, 0x0F, 0x86, 0x00, 0x3C, 0x30, 0x01, 0xE1, 0x80, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xE1,
  0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07,
  0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0x70,
  0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC6,
  0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xE1,
  0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07,
  0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0x70,
  0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x08, 0x00, 0xE0, 0xC0, 0x06, 0x38, 0x00, 0x37, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80,
  0x07, 0x0C, 0x00, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x30, 0x30, 0x01,
  0x81, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3C,
  0x0F, 0x81, 0xC0, 0x0F, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x41, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC4, 0x00, 0x06, 0x38, 0x00, 0x38, 0x70,
  0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x07, 0x18, 0x00, 0x73, 0x80, 0x06, 0x38, 0x00, 0x63, 0x80, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x00, 0xC7,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x18,
  0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8C, 0x00, 0x38, 0xE0, 0x03,
  0x0E, 0x00, 0x70, 0x60, 0x0E, 0x07, 0x81, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xE0,
  0x00, 0xCE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06,
  0x00, 0x70, 0x60, 0x06, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x03, 0x01, 0xC0,
  0x30, 0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x38, 0x60,
  0x03, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x38,
  0x18, 0x60, 0x70, 0x30, 0xC1, 0xE0, 0xC1, 0x83, 0xC1, 0x83, 0x0D, 0x83,
  0x06, 0x1B, 0x06, 0x1C, 0x62, 0x18, 0x30, 0xC6, 0x30, 0x61, 0x8C, 0x60,
  0xC6, 0x18, 0xC1, 0x8C, 0x33, 0x03, 0x30, 0x66, 0x06, 0x60, 0xCC, 0x0C,
  0xC1, 0x98, 0x1B, 0x03, 0x60, 0x36, 0x06, 0xC0, 0x78, 0x0D, 0x80, 0xF0,
  0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xE0, 0x07, 0x01, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x06,
  0x00, 0x30, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x1C, 0x60, 0x03, 0x0E,
  0x00, 0xC0, 0xC0, 0x38, 0x18, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x60, 0x07,
  0x1C, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x1C, 0x63, 0x0C, 0x60, 0x01, 0xF8,
  0x60, 0xFF, 0xCC, 0x3C, 0x1D, 0x8E, 0x00, 0xF1, 0x80, 0x0E, 0x70, 0x01,
  0x8C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x07,
  0x30, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C,
  0x60, 0x07, 0x8E, 0x01, 0x60, 0xE0, 0xCC, 0x0F, 0xF1, 0xF0, 0xFC, 0x1E,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x0F, 0xC0,
  0x67, 0xFC, 0x0D, 0xC1, 0xC3, 0xA0, 0x1C, 0x78, 0x01, 0x8E, 0x00, 0x31,
  0xC0, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0x66,
  0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x0C, 0xE0, 0x03, 0x9C,
  0x00, 0x63, 0x40, 0x1C, 0x6C, 0x0F, 0x0C, 0xFF, 0xC1, 0x87, 0xE0, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC1, 0xC3, 0x80, 0x73, 0x80, 0x19, 0x80,
  0x09, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x06, 0x60, 0x07,
  0x38, 0x07, 0x0E, 0x0F, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xC3, 0x01,
  0xFF, 0x98, 0x1E, 0x06, 0xC1, 0xC0, 0x16, 0x0C, 0x00, 0x70, 0xE0, 0x03,
  0x86, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x70,
  0x60, 0x03, 0x83, 0x00, 0x3C, 0x1C, 0x03, 0xE0, 0x70, 0x76, 0x01, 0xFF,
  0x30, 0x07, 0xE1, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x38, 0x70,
  0x07, 0x38, 0x01, 0xCC, 0x00, 0x37, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x07,
  0xB8, 0x1F, 0x8F, 0xFF, 0x83, 0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x13, 0x80, 0x06, 0x60, 0x03, 0x1C, 0x01, 0xC3, 0x81, 0xE0, 0x7F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x10, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF,
  0xCC, 0x3C, 0x1D, 0x8E, 0x00, 0xB1, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00,
  0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0xEE, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x07,
  0x8E, 0x01, 0x70, 0xE0, 0xEC, 0x0F, 0xF9, 0x80, 0xFC, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x18, 0x03, 0x83, 0xC0, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x3E, 0x06, 0x3F, 0xC3, 0x30, 0xF1, 0xA0, 0x38, 0xE0, 0x0C, 0xF0,
  0x06, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x37,
  0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0xB8, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x02, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x20, 0x30,
  0x1C, 0x0C, 0x0E, 0x03, 0x0E, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x1B, 0xC0,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x10, 0x0C,
  0x0E, 0x03, 0x01, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xE7, 0x00,
  0x1D, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x87, 0xE0, 0x18, 0xFF, 0x01, 0x98,
  0x38, 0x1A, 0x01, 0x83, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x30, 0x30, 0x0E, 0x07, 0x03, 0x80, 0x73, 0xE0, 0x06,
  0x38, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x02, 0x60, 0xC0, 0x7E, 0x06, 0x1C,
  0xE0, 0x63, 0x8C, 0x03, 0x70, 0xC0, 0x3E, 0x0C, 0x01, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x02, 0x1C, 0x0F, 0x18, 0x1C, 0x18, 0x38,
  0x18, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x1C, 0x00, 0x18, 0xF0,
  0xF0, 0x67, 0xE7, 0xE1, 0xA3, 0xB1, 0xC7, 0x07, 0x87, 0x18, 0x1C, 0x1C,
  0xE0, 0x60, 0x73, 0x81, 0x81, 0x8C, 0x06, 0x06, 0x30, 0x18, 0x18, 0xC0,
  0xC0, 0x63, 0x03, 0x01, 0x9C, 0x0C, 0x0E, 0x60, 0x30, 0x31, 0x80, 0xC0,
  0xC6, 0x03, 0x03, 0x18, 0x18, 0x0C, 0x60, 0x60, 0x31, 0x81, 0x81, 0xCC,
  0x06, 0x06, 0x30, 0x18, 0x18, 0xC0, 0xE0, 0x60, 0x18, 0x7C, 0x0C, 0x7F,
  0x86, 0x61, 0xE3, 0x40, 0x73, 0xC0, 0x19, 0xE0, 0x0C, 0xE0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x76, 0x00, 0x3B,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x03, 0xB0, 0x01,
  0xD8, 0x00, 0xCC, 0x00, 0x60, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xE0, 0x70,
  0x70, 0x0E, 0x38, 0x01, 0xDC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xE0, 0x07, 0x1C, 0x03, 0x83, 0x81, 0xC0,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x06, 0x1F, 0x80, 0x33, 0xFE, 0x01, 0xB8,
  0x38, 0x1D, 0x00, 0xE0, 0xF0, 0x03, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1,
  0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xC1, 0xA0, 0x0E, 0x0D, 0x81, 0xE0, 0x67, 0xFE, 0x03, 0x0F, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x60, 0xFF, 0xCC, 0x3C, 0x0D, 0x8E, 0x00, 0xB1, 0x80, 0x0E, 0x70, 0x01,
  0xCC, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07,
  0x30, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C,
  0x60, 0x07, 0x8E, 0x01, 0x70, 0xE0, 0xEC, 0x0F, 0xF9, 0x80, 0xFC, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0xFF, 0x0F, 0xFF, 0xE7, 0xF8,
  0x0D, 0xC0, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x3C, 0x07, 0x86, 0x00, 0x31, 0xC0, 0x04, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x40,
  0x01, 0xDE, 0x00, 0x71, 0xF0, 0x1C, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x08, 0x0C, 0x07, 0x81, 0x83, 0xC0, 0x70, 0xE0, 0x0E, 0x78, 0x01, 0x9C,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00,
  0x6E, 0x00, 0x76, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0,
  0x03, 0x70, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x39, 0x80, 0x3C, 0xC0, 0x2E, 0x70, 0x16, 0x3C, 0x33, 0x0F, 0xF1,
  0x81, 0xF0, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0x70, 0x60, 0x0C, 0x38, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80,
  0x70, 0x60, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x03, 0x1F, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x18, 0x18, 0x30, 0xC0, 0xC1, 0x8C, 0x06, 0x0C, 0x60,
  0x30, 0x63, 0x03, 0x01, 0x98, 0x18, 0x0C, 0xC0, 0xC0, 0x66, 0x06, 0x03,
  0x60, 0x30, 0x1B, 0x01, 0x81, 0xD8, 0x18, 0x0C, 0xC0, 0xC0, 0x66, 0x06,
  0x03, 0x30, 0x30, 0x1B, 0x01, 0x81, 0x98, 0x1C, 0x0C, 0xC0, 0xE0, 0xE6,
  0x0B, 0x06, 0x38, 0xD8, 0xE0, 0xFC, 0x7E, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xC0, 0xF8, 0x0F, 0xC3, 0xF8, 0x79, 0x8C, 0x31, 0xE3, 0x30, 0x67, 0x03,
  0x40, 0xE8, 0x06, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x18, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x78, 0x08, 0xC0, 0xB8, 0x39,
  0x83, 0x31, 0xE3, 0x8C, 0x67, 0x07, 0xF0, 0xFC, 0x03, 0xC0, 0xE0, 0x00,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0,
  0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18,
  0x01, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0x81, 0xC0, 0x58, 0x1E, 0x19, 0x80,
  0xFF, 0x18, 0x03, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x06, 0x00, 0xE0, 0xF0, 0x3C, 0x03, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x30, 0xFF, 0xE3, 0x1C, 0x1F, 0xF1, 0x80, 0x3F, 0x30,
  0x00, 0xC3, 0x00, 0x38, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x80, 0x70, 0x18,
  0x0E, 0x01, 0x81, 0xC0, 0x0C, 0x30, 0x00, 0xC7, 0xF8, 0x0C, 0xFF, 0xFC,
  0xCE, 0x1F, 0xFC, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0x00, 0x18, 0xFE, 0x01, 0x8E, 0x38, 0x0C, 0x60, 0xC0, 0xC6, 0x07,
  0x06, 0x30, 0x1C, 0x63, 0x00, 0x7E, 0x18, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 28, 24, 8, -28 },
  { 29, 10, 11, 24, 9, -30 },
  { 43, 24, 28, 24, 1, -28 },
  { 127, 22, 36, 24, 1, -32 },
  { 226, 27, 28, 24, -1, -28 },
  { 321, 24, 28, 24, 0, -28 },
  { 405, 4, 11, 24, 12, -30 },
  { 411, 14, 36, 24, 9, -30 },
  { 474, 14, 36, 24, 2, -30 },
  { 537, 21, 20, 24, 2, -22 },
  { 590, 19, 20, 24, 3, -22 },
  { 638, 7, 11, 24, 6, -5 },
  { 648, 11, 2, 24, 7, -13 },
  { 651, 5, 4, 24, 8, -4 },
  { 654, 22, 36, 24, 1, -30 },
  { 753, 20, 28, 24, 3, -28 },
  { 823, 19, 28, 24, 2, -28 },
  { 890, 21, 28, 24, 1, -28 },
  { 964, 21, 28, 24, 1, -28 },
  { 1038, 21, 28, 24, 1, -28 },
  { 1112, 21, 28, 24, 2, -28 },
  { 1186, 18, 28, 24, 3, -28 },
  { 1249, 20, 28, 24, 4, -28 },
  { 1319, 21, 28, 24, 2, -28 },
  { 1393, 18, 28, 24, 4, -28 },
  { 1456, 8, 21, 24, 8, -21 },
  { 1477, 10, 27, 24, 6, -21 },
  { 1511, 19, 22, 24, 4, -23 },
  { 1564, 21, 10, 24, 2, -17 },
  { 1591, 19, 22, 24, 2, -23 },
  { 1644, 17, 28, 24, 5, -28 },
  { 1704, 19, 32, 24, 3, -28 },
  { 1780, 21, 28, 24, 0, -28 },
  { 1854, 20, 28, 24, 2, -28 },
  { 1924, 20, 28, 24, 3, -28 },
  { 1994, 20, 28, 24, 2, -28 },
  { 2064, 22, 28, 24, 2, -28 },
  { 2141, 22, 28, 24, 2, -28 },
  { 2218, 20, 28, 24, 3, -28 },
  { 2288, 21, 28, 24, 2, -28 },
  { 2362, 21, 28, 24, 2, -28 },
  { 2436, 19, 28, 24, 3, -28 },
  { 2503, 23, 28, 24, 2, -28 },
  { 2584, 16, 28, 24, 4, -28 },
  { 2640, 23, 28, 24, 1, -28 },
  { 2721, 21, 28, 24, 2, -28 },
  { 2795, 20, 28, 24, 3, -28 },
  { 2865, 21, 28, 24, 2, -28 },
  { 2939, 20, 35, 24, 3, -28 },
  { 3027, 21, 28, 24, 2, -28 },
  { 3101, 22, 28, 24, 1, -28 },
  { 3178, 22, 28, 24, 4, -28 },
  { 3255, 20, 28, 24, 3, -28 },
  { 3325, 20, 28, 24, 5, -28 },
  { 3395, 23, 28, 24, 2, -28 },
  { 3476, 25, 28, 24, 0, -28 },
  { 3564, 22, 28, 24, 4, -28 },
  { 3641, 24, 28, 24, 0, -28 },
  { 3725, 16, 36, 24, 7, -30 },
  { 3797, 9, 36, 24, 8, -30 },
  { 3838, 16, 36, 24, 1, -30 },
  { 3910, 19, 16, 24, 3, -28 },
  { 3948, 19, 2, 24, 0, 4 },
  { 3953, 5, 7, 24, 9, -31 },
  { 3958, 19, 21, 24, 2, -21 },
  { 4008, 19, 30, 24, 3, -30 },
  { 4080, 17, 21, 24, 3, -21 },
  { 4125, 21, 30, 24, 2, -30 },
  { 4204, 18, 21, 24, 3, -21 },
  { 4252, 26, 38, 24, -1, -30 },
  { 4376, 19, 29, 24, 2, -21 },
  { 4445, 17, 30, 24, 3, -30 },
  { 4509, 18, 30, 24, 3, -30 },
  { 4577, 18, 38, 24, 3, -30 },
  { 4663, 20, 30, 24, 3, -30 },
  { 4738, 16, 30, 24, 5, -30 },
  { 4798, 22, 21, 24, 1, -21 },
  { 4856, 17, 21, 24, 3, -21 },
  { 4901, 18, 21, 24, 3, -21 },
  { 4949, 21, 29, 24, 1, -21 },
  { 5026, 19, 29, 24, 2, -21 },
  { 5095, 19, 21, 24, 5, -21 },
  { 5145, 19, 21, 24, 2, -21 },
  { 5195, 19, 28, 24, 3, -28 },
  { 5262, 17, 21, 24, 4, -21 },
  { 5307, 18, 21, 24, 3, -21 },
  { 5355, 21, 21, 24, 2, -21 },
  { 5411, 23, 21, 24, 1, -21 },
  { 5472, 20, 29, 24, 1, -21 },
  { 5545, 20, 21, 24, 2, -21 },
  { 5598, 18, 36, 24, 5, -30 },
  { 5679, 8, 36, 24, 8, -30 },
  { 5715, 18, 36, 24, 2, -30 },
  { 5796, 21, 8, 24, 2, -16 },
};

const GFXfont IBMPlexMono_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_LIGHTITALIC40PT7B_H_
