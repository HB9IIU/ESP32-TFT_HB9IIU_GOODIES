#ifndef _IBMPLEXMONO_LIGHTITALIC23PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x33, 0x32, 0x22, 0x24, 0x40, 0x00, 0xCC, 0x65, 0x14, 0x53,
  0x4B, 0x20, 0x01, 0x98, 0x04, 0x40, 0x31, 0x00, 0x88, 0x02, 0x20, 0xF8,
  0xF0, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x22, 0x0F, 0x8F, 0x86, 0x20, 0x11,
  0x00, 0x44, 0x03, 0x30, 0x08, 0x80, 0x01, 0x00, 0x10, 0x0F, 0xC1, 0x93,
  0x21, 0x12, 0x20, 0x22, 0x02, 0x20, 0x32, 0x01, 0xE0, 0x03, 0xC0, 0x46,
  0x04, 0x20, 0x42, 0x04, 0x68, 0x44, 0x64, 0xC3, 0xF0, 0x08, 0x00, 0x80,
  0x0E, 0x06, 0x22, 0x08, 0x84, 0x21, 0x08, 0x82, 0x11, 0x04, 0x24, 0x08,
  0x90, 0x0E, 0x00, 0x00, 0xF0, 0x1A, 0x30, 0x24, 0x20, 0x90, 0x42, 0x20,
  0x8C, 0x42, 0x10, 0xC4, 0x40, 0xF0, 0x07, 0xC0, 0x31, 0x80, 0x82, 0x06,
  0x08, 0x18, 0x20, 0x20, 0x80, 0xC4, 0x07, 0x20, 0x67, 0x01, 0x08, 0x0C,
  0x30, 0x20, 0x40, 0x81, 0x8F, 0x0B, 0x24, 0x25, 0x0F, 0x1C, 0x55, 0xE0,
  0x03, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x30, 0xC0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0xE2, 0x71,
  0xFC, 0x06, 0x00, 0xA0, 0x19, 0x03, 0x18, 0x60, 0x80, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xC3, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x39, 0x8C, 0xC6, 0x23, 0x00, 0xFC, 0xF0, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x0F, 0x82, 0x18, 0x81, 0xA0, 0x34, 0x03, 0x80, 0x60, 0x0C,
  0x63, 0x8C, 0x70, 0x0A, 0x01, 0x40, 0x68, 0x09, 0x03, 0x10, 0xC1, 0xE0,
  0x03, 0x80, 0xF0, 0x64, 0x18, 0x86, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x07, 0xFF, 0x0F, 0x81,
  0x86, 0x30, 0x22, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x0F, 0xFC, 0x0F, 0xC3,
  0x0C, 0xC0, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x78, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x05, 0x01, 0xB0, 0x61, 0xF0, 0x00, 0x30, 0x03, 0x80,
  0x3C, 0x03, 0x40, 0x12, 0x01, 0x10, 0x10, 0x81, 0x84, 0x18, 0x61, 0x82,
  0x08, 0x10, 0x80, 0x87, 0xFF, 0xC0, 0x20, 0x03, 0x00, 0x10, 0x1F, 0xF1,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x2F, 0x83, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x4C, 0x0C, 0x61, 0x83, 0xF0, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0xF3, 0xC6, 0xC0, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x2C, 0x30, 0xF8, 0x7F, 0xF4, 0x02, 0x40, 0x64, 0x04,
  0x80, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x07, 0xC1, 0x82, 0x30, 0x32, 0x01,
  0x20, 0x32, 0x02, 0x10, 0x40, 0xF8, 0x30, 0xC4, 0x06, 0xC0, 0x2C, 0x02,
  0xC0, 0x6C, 0x04, 0x60, 0xC3, 0xF0, 0x0F, 0x86, 0x19, 0x81, 0x20, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x06, 0x61, 0x47, 0xD0, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x03, 0x80, 0x37, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x0C, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x0C, 0x61, 0x84, 0x30, 0x00, 0x20,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x08, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x20, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x08, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x18, 0x64, 0x0B, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x0C, 0x1E, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x0F, 0x82, 0x18, 0x81, 0x30, 0x34, 0x02, 0x8E, 0xF3,
  0x34, 0x42, 0x98, 0x52, 0x0A, 0x41, 0x48, 0x69, 0x99, 0x1D, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0x40, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x40, 0x86, 0x08, 0x61, 0x02, 0x1F, 0xE3, 0x02,
  0x20, 0x26, 0x03, 0x40, 0x3C, 0x03, 0x1F, 0xC1, 0x06, 0x30, 0x23, 0x03,
  0x20, 0x22, 0x02, 0x20, 0x43, 0xF8, 0x60, 0x46, 0x06, 0x40, 0x24, 0x02,
  0x40, 0x64, 0x04, 0xC0, 0xCF, 0xF0, 0x0F, 0x83, 0x08, 0xC0, 0x90, 0x24,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x0D,
  0x81, 0x18, 0x41, 0xF0, 0x1F, 0x81, 0x06, 0x10, 0x23, 0x03, 0x30, 0x12,
  0x01, 0x20, 0x12, 0x03, 0x20, 0x36, 0x02, 0x60, 0x24, 0x02, 0x40, 0x44,
  0x0C, 0x41, 0x8F, 0xE0, 0x1F, 0xF8, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x07, 0xFC, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFC, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x0F, 0x83, 0x18, 0x81,
  0xB0, 0x24, 0x01, 0x80, 0x30, 0x04, 0x00, 0x87, 0xD0, 0x0A, 0x01, 0x40,
  0x68, 0x0D, 0x83, 0x10, 0xA1, 0xE4, 0x10, 0x13, 0x01, 0x30, 0x12, 0x03,
  0x20, 0x32, 0x03, 0x20, 0x27, 0xFE, 0x60, 0x24, 0x06, 0x40, 0x64, 0x06,
  0x40, 0x4C, 0x04, 0xC0, 0x48, 0x0C, 0x1F, 0xF8, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x1F, 0xF8, 0x0F, 0xF0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x40, 0x8C, 0x08, 0x61, 0x03, 0xE0, 0x10, 0x1C, 0x40, 0xC3,
  0x06, 0x0C, 0x30, 0x21, 0x80, 0x8C, 0x02, 0x60, 0x0B, 0x80, 0x7A, 0x01,
  0xCC, 0x06, 0x10, 0x10, 0x60, 0x40, 0x81, 0x03, 0x0C, 0x04, 0x30, 0x18,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0xFF, 0x30, 0x19, 0x81, 0x8A, 0x1C, 0x50,
  0xA2, 0x8D, 0x36, 0x49, 0x94, 0xC8, 0xA4, 0x46, 0x22, 0x31, 0x11, 0x09,
  0x80, 0x4C, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x18, 0x13, 0x81, 0x38,
  0x12, 0xC1, 0x24, 0x32, 0x43, 0x24, 0x26, 0x62, 0x62, 0x24, 0x22, 0x43,
  0x64, 0x16, 0x41, 0x4C, 0x14, 0xC1, 0xC8, 0x0C, 0x0F, 0x82, 0x18, 0x81,
  0xA0, 0x34, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0A, 0x01, 0x40,
  0x68, 0x09, 0x03, 0x10, 0xC1, 0xE0, 0x1F, 0xE1, 0x03, 0x30, 0x13, 0x01,
  0x30, 0x12, 0x01, 0x20, 0x32, 0x06, 0x7F, 0xC6, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x82, 0x18, 0x81, 0xA0, 0x34,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0A, 0x01, 0x40, 0x68, 0x09,
  0x03, 0x30, 0xC1, 0xE0, 0x08, 0x01, 0x88, 0x1A, 0x01, 0x80, 0x1F, 0xE1,
  0x03, 0x30, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x32, 0x06, 0x7F, 0xC6,
  0x20, 0x63, 0x04, 0x10, 0x41, 0x84, 0x08, 0xC0, 0xCC, 0x04, 0x0F, 0xC1,
  0x83, 0x20, 0x12, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0xE0, 0x01, 0xC0,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x68, 0x04, 0x60, 0xC3, 0xF0, 0xFF, 0xF8,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x20, 0x2C, 0x05, 0x80, 0xA0, 0x14, 0x06, 0x80, 0xD0, 0x16, 0x02, 0xC0,
  0x50, 0x0A, 0x03, 0x40, 0x48, 0x09, 0x03, 0x30, 0xC3, 0xF0, 0x80, 0x30,
  0x0E, 0x01, 0x40, 0x6C, 0x09, 0x83, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41,
  0x10, 0x32, 0x06, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x20, 0x09, 0x00, 0x58,
  0x02, 0xC0, 0x36, 0x31, 0x21, 0x89, 0x14, 0x48, 0xA6, 0x49, 0x22, 0x49,
  0x12, 0x48, 0xA2, 0xC5, 0x14, 0x30, 0xA3, 0x85, 0x1C, 0x38, 0x10, 0x06,
  0x10, 0x10, 0x20, 0x60, 0x61, 0x80, 0x46, 0x00, 0xC8, 0x00, 0xA0, 0x01,
  0x80, 0x03, 0x00, 0x0D, 0x00, 0x32, 0x00, 0x46, 0x01, 0x04, 0x04, 0x0C,
  0x18, 0x08, 0x60, 0x18, 0xC0, 0x1A, 0x01, 0x98, 0x18, 0x40, 0x83, 0x08,
  0x08, 0xC0, 0x4C, 0x03, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFC, 0x1F, 0x88,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x1F, 0x80, 0x81, 0x04, 0x10,
  0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x41,
  0x0F, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23,
  0xF8, 0x03, 0x00, 0xA0, 0x24, 0x0C, 0x41, 0x08, 0x41, 0x90, 0x16, 0x02,
  0x80, 0x20, 0xFF, 0xE0, 0xC9, 0x90, 0x0F, 0x26, 0x14, 0x81, 0xB0, 0x34,
  0x04, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xC8, 0x19, 0x8F, 0x1E, 0x70, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x6F, 0x8E, 0x19, 0x81, 0x20, 0x24,
  0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0xD8, 0x13, 0x0C, 0xDF, 0x00, 0x1F,
  0x0C, 0x24, 0x0D, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0xB0, 0x64,
  0x30, 0xF8, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0xF2, 0x10,
  0xA2, 0x06, 0x60, 0x64, 0x06, 0x40, 0x4C, 0x04, 0xC0, 0x4C, 0x0C, 0x40,
  0xC6, 0x3C, 0x3C, 0x80, 0x0F, 0x0C, 0x36, 0x05, 0x01, 0xC0, 0xE0, 0xEF,
  0xC2, 0x00, 0x80, 0xA0, 0x34, 0x10, 0xF8, 0x00, 0x7C, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x7F, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x02, 0x18, 0x04, 0x40, 0x09, 0x00, 0x14, 0x00, 0x30, 0x00, 0x0F, 0x22,
  0x14, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xC8, 0x19,
  0x87, 0x1F, 0x40, 0x08, 0x01, 0x00, 0x66, 0x18, 0x7C, 0x00, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x09, 0xC7, 0x89, 0x83, 0x60, 0xD0, 0x34, 0x09,
  0x02, 0xC0, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x11, 0x18, 0x4C, 0x14, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x20, 0x84, 0x60, 0x90, 0x14, 0x03, 0x00, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xCF, 0x1E, 0x33, 0x06, 0x60, 0xC8,
  0x11, 0x04, 0x67, 0x0D, 0x81, 0x10, 0x61, 0x14, 0x34, 0x83, 0x00, 0xFC,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x02, 0x19, 0x19, 0x90, 0xD0, 0x70, 0x00, 0x6C, 0x67, 0x39, 0x63, 0x14,
  0x21, 0x42, 0x14, 0x23, 0xC6, 0x2C, 0x42, 0x84, 0x28, 0x42, 0x84, 0x28,
  0xC6, 0x27, 0x1E, 0x26, 0x0D, 0x83, 0x40, 0xD0, 0x24, 0x0B, 0x02, 0x80,
  0xA0, 0x28, 0x1A, 0x04, 0x1F, 0x0C, 0x24, 0x0F, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xA0, 0x64, 0x30, 0xF8, 0x37, 0xC5, 0x0C, 0xC0, 0x90,
  0x12, 0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x6C, 0x09, 0x86, 0x2F, 0x8C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0x22, 0x14, 0x81, 0xB0,
  0x34, 0x06, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xC8, 0x19, 0x87, 0x1F, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0xFB, 0xE2, 0x80, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x00,
  0x0F, 0xC2, 0x0C, 0x81, 0x10, 0x02, 0x00, 0x3C, 0x00, 0x70, 0x02, 0x00,
  0x48, 0x0B, 0x83, 0x1F, 0x80, 0x04, 0x01, 0x80, 0x20, 0x04, 0x0F, 0xFE,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x43, 0x0C, 0x66,
  0x0B, 0x01, 0xC0, 0x60, 0x50, 0x14, 0x0D, 0x03, 0x40, 0xB0, 0x2C, 0x0A,
  0x02, 0x81, 0xA0, 0xEC, 0x51, 0xE4, 0xF0, 0xCC, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x0D, 0x82, 0x61, 0x90, 0xC4, 0x61, 0xE0, 0x23, 0x32, 0x21,
  0x62, 0x14, 0x21, 0x42, 0x14, 0x21, 0x46, 0x14, 0x43, 0xC4, 0x28, 0x42,
  0xCE, 0x47, 0x38, 0x0E, 0x38, 0xC9, 0x26, 0x28, 0xC0, 0xC3, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0xC5, 0x03, 0x14, 0x6C, 0x96, 0x1C, 0x70,
  0x30, 0x24, 0x04, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x12, 0x02, 0x40,
  0xCC, 0x19, 0x8E, 0x1E, 0x40, 0x08, 0x01, 0x00, 0x46, 0x18, 0x7C, 0x00,
  0x1F, 0x32, 0x1E, 0x20, 0x66, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x84,
  0x30, 0x46, 0x06, 0xFE, 0x6C, 0x3C, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x3C, 0x01, 0x80, 0x30, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0xF8, 0x11, 0x11, 0x32, 0x22, 0x22,
  0x64, 0x44, 0x44, 0xC8, 0x88, 0x1F, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x7C, 0x38, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7C, 0x00, 0x38, 0x16, 0x42,
  0x42, 0x28, 0x1C,
};

const GFXglyph IBMPlexMono_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 6, 6, 14, 5, -17 },
  { 14, 14, 16, 14, 0, -16 },
  { 42, 12, 20, 14, 1, -18 },
  { 72, 15, 16, 14, 0, -16 },
  { 102, 14, 16, 14, 0, -16 },
  { 130, 2, 6, 14, 7, -17 },
  { 132, 8, 20, 14, 5, -17 },
  { 152, 8, 20, 14, 1, -17 },
  { 172, 12, 11, 14, 1, -13 },
  { 189, 11, 11, 14, 2, -13 },
  { 205, 5, 7, 14, 3, -3 },
  { 210, 6, 1, 14, 4, -7 },
  { 211, 2, 2, 14, 5, -2 },
  { 212, 12, 20, 14, 1, -17 },
  { 242, 11, 16, 14, 2, -16 },
  { 264, 11, 16, 14, 1, -16 },
  { 286, 12, 16, 14, 1, -16 },
  { 310, 11, 16, 14, 1, -16 },
  { 332, 13, 16, 14, 0, -16 },
  { 358, 12, 16, 14, 1, -16 },
  { 382, 10, 16, 14, 2, -16 },
  { 402, 12, 16, 14, 2, -16 },
  { 426, 12, 16, 14, 1, -16 },
  { 450, 11, 16, 14, 2, -16 },
  { 472, 4, 12, 14, 5, -12 },
  { 478, 6, 16, 14, 3, -12 },
  { 490, 11, 13, 14, 2, -14 },
  { 508, 12, 6, 14, 1, -10 },
  { 517, 11, 13, 14, 1, -14 },
  { 535, 10, 16, 14, 3, -16 },
  { 555, 11, 19, 14, 2, -16 },
  { 582, 12, 16, 14, 0, -16 },
  { 606, 12, 16, 14, 1, -16 },
  { 630, 11, 16, 14, 2, -16 },
  { 652, 12, 16, 14, 1, -16 },
  { 676, 13, 16, 14, 1, -16 },
  { 702, 13, 16, 14, 1, -16 },
  { 728, 11, 16, 14, 2, -16 },
  { 750, 12, 16, 14, 1, -16 },
  { 774, 13, 16, 14, 1, -16 },
  { 800, 12, 16, 14, 1, -16 },
  { 824, 14, 16, 14, 1, -16 },
  { 852, 9, 16, 14, 2, -16 },
  { 870, 13, 16, 14, 1, -16 },
  { 896, 12, 16, 14, 1, -16 },
  { 920, 11, 16, 14, 2, -16 },
  { 942, 12, 16, 14, 1, -16 },
  { 966, 11, 20, 14, 2, -16 },
  { 994, 12, 16, 14, 1, -16 },
  { 1018, 12, 16, 14, 1, -16 },
  { 1042, 13, 16, 14, 2, -16 },
  { 1068, 11, 16, 14, 2, -16 },
  { 1090, 11, 16, 14, 3, -16 },
  { 1112, 13, 16, 14, 1, -16 },
  { 1138, 15, 16, 14, 0, -16 },
  { 1168, 13, 16, 14, 2, -16 },
  { 1194, 14, 16, 14, 0, -16 },
  { 1222, 9, 20, 14, 4, -17 },
  { 1245, 6, 20, 14, 4, -17 },
  { 1260, 10, 20, 14, 0, -17 },
  { 1285, 11, 9, 14, 2, -16 },
  { 1298, 11, 1, 14, 0, 3 },
  { 1300, 3, 4, 14, 5, -18 },
  { 1302, 11, 12, 14, 1, -12 },
  { 1319, 11, 17, 14, 1, -17 },
  { 1343, 10, 12, 14, 2, -12 },
  { 1358, 12, 17, 14, 1, -17 },
  { 1384, 10, 12, 14, 2, -12 },
  { 1399, 14, 22, 14, 0, -17 },
  { 1438, 11, 17, 14, 1, -12 },
  { 1462, 10, 17, 14, 2, -17 },
  { 1484, 10, 18, 14, 2, -18 },
  { 1507, 10, 22, 14, 2, -17 },
  { 1535, 11, 17, 14, 2, -17 },
  { 1559, 9, 17, 14, 3, -17 },
  { 1579, 12, 12, 14, 1, -12 },
  { 1597, 10, 12, 14, 2, -12 },
  { 1612, 10, 12, 14, 2, -12 },
  { 1627, 11, 17, 14, 1, -12 },
  { 1651, 11, 17, 14, 1, -12 },
  { 1675, 11, 12, 14, 3, -12 },
  { 1692, 11, 12, 14, 1, -12 },
  { 1709, 11, 16, 14, 2, -16 },
  { 1731, 10, 12, 14, 2, -12 },
  { 1746, 10, 12, 14, 2, -12 },
  { 1761, 12, 12, 14, 1, -12 },
  { 1779, 14, 12, 14, 0, -12 },
  { 1800, 11, 17, 14, 1, -12 },
  { 1824, 12, 12, 14, 1, -12 },
  { 1842, 10, 20, 14, 3, -17 },
  { 1867, 4, 20, 14, 5, -17 },
  { 1877, 11, 20, 14, 1, -17 },
  { 1905, 12, 4, 14, 1, -9 },
};

const GFXfont IBMPlexMono_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_LIGHTITALIC23PT7B_H_
