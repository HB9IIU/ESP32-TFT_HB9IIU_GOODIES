#ifndef _IBMPLEXMONO_LIGHTITALIC26PT7B_H_
#define _IBMPLEXMONO_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x04, 0x10, 0x42, 0x08, 0x00, 0x00,
  0x18, 0xE3, 0x80, 0x66, 0x89, 0x12, 0x2C, 0xD9, 0xA3, 0x00, 0x00, 0xC4,
  0x00, 0x8C, 0x01, 0x8C, 0x01, 0x08, 0x01, 0x18, 0x03, 0x18, 0x3E, 0x1F,
  0x02, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0xFC, 0x7C, 0x08, 0x40,
  0x08, 0xC0, 0x18, 0x80, 0x10, 0x80, 0x11, 0x80, 0x31, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x01, 0xFC, 0x1C, 0x98, 0xC2, 0x33, 0x18, 0x08, 0x40,
  0x21, 0x00, 0xC4, 0x01, 0x90, 0x03, 0xC0, 0x03, 0xE0, 0x08, 0xC0, 0x21,
  0x00, 0x86, 0x02, 0x1A, 0x08, 0x4C, 0x63, 0x19, 0x18, 0x1F, 0x80, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x07, 0x80, 0xC3, 0x10, 0x61, 0x84, 0x10, 0x41,
  0x08, 0x10, 0x46, 0x04, 0x11, 0x01, 0x04, 0x80, 0x62, 0x60, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x26, 0x20, 0x19, 0x0C, 0x0C, 0xC3, 0x02, 0x20, 0xC1,
  0x08, 0x20, 0xC2, 0x08, 0x20, 0xC4, 0x30, 0x1E, 0x00, 0x03, 0xE0, 0x0C,
  0x60, 0x30, 0x40, 0x40, 0xC0, 0x81, 0x81, 0x82, 0x03, 0x04, 0x02, 0x10,
  0x0E, 0xC0, 0x66, 0x01, 0x04, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30,
  0x30, 0xE0, 0x92, 0x61, 0x2C, 0x7C, 0x30, 0x69, 0x2D, 0xB0, 0x03, 0x83,
  0x03, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0xC1, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x08, 0x21,
  0xFB, 0x78, 0x7E, 0x01, 0xC0, 0x0B, 0x00, 0x88, 0x0C, 0x60, 0xC1, 0x0C,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0xFF,
  0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x39, 0x98,
  0xC4, 0x62, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x07, 0xC0, 0xC3, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0xA0, 0x0F, 0x00, 0x78,
  0x03, 0xC6, 0x16, 0x30, 0xA0, 0x0D, 0x00, 0x68, 0x03, 0x40, 0x12, 0x01,
  0x98, 0x18, 0x61, 0x81, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x0C, 0xC1, 0x8C,
  0x30, 0x82, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x0F, 0xFF, 0x07, 0xE0, 0x61,
  0x86, 0x06, 0x60, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xE0, 0x61, 0x84, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x0C, 0x0F, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xD8, 0x0C, 0x60, 0xC1, 0xF8, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x34, 0x01, 0x20, 0x13, 0x01, 0x98, 0x18, 0xC1, 0x84, 0x18, 0x21,
  0x81, 0x08, 0x18, 0x80, 0xCC, 0x04, 0x7F, 0xFC, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0D, 0xF0, 0x38, 0x60, 0x80, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x30, 0x08, 0x70, 0xC0, 0x7E, 0x00, 0x00,
  0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0xF8, 0x50,
  0x6E, 0x02, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x02, 0x80, 0x6C, 0x04, 0x61,
  0x83, 0xF0, 0x7F, 0xFC, 0x03, 0xC0, 0x38, 0x06, 0x80, 0x40, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x03,
  0x30, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0C, 0x07, 0xC0, 0x60, 0xC6, 0x01,
  0x10, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x10, 0x0C, 0x60, 0xE0, 0x7E,
  0x00, 0x07, 0xC1, 0x86, 0x20, 0x36, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x14,
  0x03, 0x60, 0x77, 0x0A, 0x1F, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x07, 0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCE,
  0x70, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x31, 0x86,
  0x10, 0xC2, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x20, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x1F, 0x18, 0x7C, 0x0E, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x0E, 0x1E, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x18, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x12, 0x01, 0x20, 0x16, 0x3D,
  0x46, 0x34, 0x43, 0xCC, 0x3C, 0x83, 0xC8, 0x28, 0x82, 0x88, 0x28, 0x86,
  0x8C, 0xE8, 0x76, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x1A, 0x00, 0x48, 0x01, 0x20, 0x0C, 0xC0, 0x23, 0x01,
  0x8C, 0x04, 0x10, 0x30, 0x40, 0x81, 0x07, 0xFE, 0x10, 0x18, 0xC0, 0x62,
  0x01, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x30, 0x1F, 0xE0, 0xC0, 0xC4, 0x06,
  0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x3F, 0xC1, 0x01, 0x88,
  0x04, 0xC0, 0x36, 0x01, 0xB0, 0x09, 0x00, 0x48, 0x06, 0x40, 0x67, 0xFC,
  0x00, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x60, 0x32, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x13,
  0x00, 0xC8, 0x0C, 0x60, 0xC0, 0xF8, 0x00, 0x3F, 0x81, 0x83, 0x0C, 0x0C,
  0x40, 0x22, 0x01, 0x10, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x12, 0x00, 0x90,
  0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x18, 0x81, 0x87, 0xF0,
  0x00, 0x1F, 0xFC, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x3F, 0xF0, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x61, 0x84, 0x04,
  0x60, 0x36, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x1F, 0xB0,
  0x0D, 0x00, 0x48, 0x02, 0x60, 0x33, 0x01, 0x88, 0x1C, 0x61, 0x61, 0xF2,
  0x00, 0x18, 0x04, 0x40, 0x31, 0x00, 0xC4, 0x03, 0x30, 0x08, 0xC0, 0x23,
  0x00, 0x88, 0x06, 0x3F, 0xF8, 0x80, 0x66, 0x01, 0x18, 0x04, 0x60, 0x11,
  0x00, 0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x23, 0x00, 0x80, 0x1F, 0xFC, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x80, 0xCC, 0x18, 0xC3, 0x03, 0xE0, 0x18, 0x06, 0x30, 0x18,
  0x60, 0x60, 0x81, 0x81, 0x06, 0x06, 0x18, 0x0C, 0x60, 0x19, 0x80, 0x27,
  0x00, 0x5A, 0x00, 0xE6, 0x03, 0x84, 0x06, 0x0C, 0x0C, 0x08, 0x10, 0x18,
  0x20, 0x10, 0x40, 0x31, 0x80, 0x30, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0x18, 0x0E, 0x30, 0x18, 0xE0,
  0x51, 0xE1, 0xA3, 0x42, 0xC4, 0x8D, 0x89, 0x92, 0x13, 0x44, 0x63, 0x88,
  0xC6, 0x11, 0x8C, 0x62, 0x10, 0xC4, 0x01, 0x08, 0x02, 0x30, 0x04, 0x60,
  0x08, 0xC0, 0x31, 0x00, 0x60, 0x1C, 0x04, 0x70, 0x11, 0x40, 0xC5, 0x03,
  0x36, 0x08, 0xD8, 0x23, 0x20, 0x88, 0x82, 0x23, 0x18, 0x84, 0x66, 0x11,
  0x18, 0x64, 0x61, 0x91, 0x02, 0x44, 0x0B, 0x10, 0x3C, 0xC0, 0x63, 0x01,
  0x80, 0x07, 0xC0, 0xC3, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0xA0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x16, 0x00, 0xA0, 0x0D, 0x00, 0x68, 0x03, 0x40, 0x12,
  0x01, 0x98, 0x18, 0x61, 0x81, 0xF0, 0x00, 0x1F, 0xF0, 0x60, 0x61, 0x00,
  0xC4, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xFF,
  0x82, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0xC3, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0xA0,
  0x0D, 0x00, 0x78, 0x03, 0xC0, 0x16, 0x00, 0xA0, 0x0D, 0x00, 0x68, 0x03,
  0x40, 0x12, 0x01, 0x98, 0x18, 0x61, 0x81, 0xF0, 0x01, 0x00, 0x0C, 0x60,
  0x34, 0x00, 0xC0, 0x1F, 0xF0, 0x60, 0x61, 0x00, 0xC4, 0x03, 0x10, 0x0C,
  0xC0, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x10, 0xFF, 0x82, 0x10, 0x18, 0x60,
  0x60, 0x81, 0x83, 0x06, 0x04, 0x10, 0x18, 0x40, 0x63, 0x00, 0xC0, 0x07,
  0xE0, 0x70, 0x61, 0x00, 0xCC, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x68,
  0x01, 0x30, 0x0C, 0x60, 0x60, 0xFE, 0x00, 0x7F, 0xFF, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x09, 0x00, 0xC8, 0x06, 0x40, 0x36,
  0x01, 0x30, 0x09, 0x80, 0x48, 0x06, 0x40, 0x32, 0x01, 0xB0, 0x09, 0x80,
  0x4C, 0x02, 0x60, 0x33, 0x01, 0x18, 0x18, 0x61, 0x81, 0xF8, 0x00, 0xC0,
  0x1E, 0x00, 0xF0, 0x04, 0x80, 0x64, 0x02, 0x20, 0x31, 0x01, 0x0C, 0x18,
  0x60, 0x83, 0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x13, 0x00, 0xD0, 0x07,
  0x80, 0x38, 0x00, 0xC0, 0x00, 0x40, 0x05, 0x00, 0x14, 0x00, 0xD0, 0x02,
  0x40, 0x09, 0x0C, 0x2C, 0x71, 0xB1, 0x44, 0xCD, 0x13, 0x24, 0x4C, 0x93,
  0x26, 0x48, 0x91, 0x22, 0xC4, 0x8A, 0x16, 0x28, 0x70, 0xE1, 0xC3, 0x07,
  0x00, 0x18, 0x03, 0x08, 0x06, 0x0C, 0x04, 0x04, 0x0C, 0x06, 0x18, 0x02,
  0x30, 0x03, 0x60, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0x40, 0x0C, 0x60, 0x08, 0x20, 0x10, 0x30, 0x30, 0x10, 0x60, 0x18, 0xC0,
  0x0C, 0xC0, 0x06, 0xC0, 0x18, 0x80, 0x61, 0x81, 0x83, 0x02, 0x02, 0x0C,
  0x06, 0x30, 0x04, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0F,
  0xFF, 0x10, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x1F,
  0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xF8, 0x82, 0x0C, 0x10, 0x41, 0x06, 0x08, 0x20,
  0x82, 0x0C, 0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x0F,
  0xE0, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC7, 0xF0, 0x01, 0x80, 0x14, 0x01,
  0xB0, 0x18, 0x80, 0x84, 0x08, 0x30, 0xC0, 0x8C, 0x06, 0x40, 0x14, 0x00,
  0x80, 0xFF, 0xF8, 0x59, 0x32, 0x1F, 0x33, 0x0B, 0x60, 0x64, 0x02, 0xC0,
  0x28, 0x06, 0x80, 0x68, 0x06, 0x80, 0x48, 0x0C, 0xC1, 0x4C, 0x2C, 0x3C,
  0x70, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x27, 0xC2,
  0x86, 0x70, 0x36, 0x03, 0x60, 0x14, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x2C,
  0x06, 0xC0, 0x4A, 0x1C, 0x9F, 0x00, 0x0F, 0x82, 0x0C, 0x80, 0xB0, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x18, 0x0D, 0x03, 0x30, 0xC1, 0xF0,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x3C, 0xC6,
  0x1E, 0x60, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48, 0x06, 0x40, 0x32, 0x01,
  0x10, 0x18, 0xC1, 0x42, 0x1A, 0x0F, 0x30, 0x0F, 0xC1, 0x86, 0x20, 0x24,
  0x03, 0x40, 0x6C, 0x1C, 0xFE, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x40, 0x46,
  0x18, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x1F, 0xFE, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x82, 0x00, 0x62, 0x00, 0x32, 0x00, 0x1A,
  0x00, 0x0C, 0x00, 0x07, 0x98, 0xC3, 0xCC, 0x0E, 0x40, 0x26, 0x01, 0x30,
  0x09, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x03, 0x18, 0x28, 0x43, 0x41, 0xE6,
  0x00, 0x30, 0x01, 0x00, 0x18, 0xC1, 0x83, 0xF0, 0x00, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xF1, 0x63, 0x30, 0x2C, 0x05, 0x80,
  0xB0, 0x14, 0x06, 0x80, 0xD0, 0x1E, 0x02, 0xC0, 0x58, 0x0A, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x30, 0x8C,
  0x19, 0x81, 0xA0, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x0C, 0x30, 0x63,
  0x03, 0x30, 0x1A, 0x00, 0x60, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x8F, 0x05, 0x8C, 0x70, 0x23, 0x01, 0x18, 0x18, 0xC1,
  0x84, 0x18, 0x27, 0x03, 0x30, 0x18, 0xC3, 0xC2, 0x24, 0x1A, 0x20, 0x60,
  0xFE, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x13, 0x0C, 0xC6, 0x22, 0x0B, 0x03, 0x00,
  0x2E, 0x38, 0xC5, 0x36, 0x18, 0xD8, 0x43, 0x41, 0x09, 0x0C, 0x24, 0x30,
  0x90, 0x82, 0xC2, 0x1B, 0x08, 0x68, 0x21, 0x21, 0x84, 0x86, 0x10, 0x33,
  0xC5, 0x8C, 0xC0, 0xB0, 0x16, 0x02, 0xC0, 0x50, 0x1A, 0x03, 0x40, 0x78,
  0x0B, 0x01, 0x60, 0x28, 0x0C, 0x0F, 0x83, 0x06, 0x60, 0x24, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x02, 0x80, 0x28, 0x06, 0xC0, 0x46, 0x18, 0x3F,
  0x00, 0x13, 0xE0, 0xA1, 0x8E, 0x06, 0x60, 0x33, 0x00, 0x90, 0x0C, 0x80,
  0x64, 0x03, 0x60, 0x13, 0x01, 0x98, 0x08, 0xA1, 0xC4, 0xF8, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0x33, 0x0F, 0x60, 0x34,
  0x02, 0xC0, 0x28, 0x02, 0x80, 0x68, 0x06, 0x80, 0x48, 0x0C, 0xC1, 0x44,
  0x3C, 0x3C, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0xFC, 0xF0,
  0xB0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x07, 0xE0, 0xC1, 0x8C, 0x06, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x30, 0x01, 0x90, 0x0D,
  0xC0, 0xC1, 0xF8, 0x00, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x0F,
  0xFF, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x82, 0x10, 0xD1, 0x18, 0x16, 0x01, 0xC0, 0x20, 0x32, 0x03, 0x60, 0x26,
  0x02, 0x60, 0x24, 0x06, 0x40, 0x64, 0x04, 0xC0, 0x4C, 0x1C, 0xC1, 0xC6,
  0x2C, 0x3C, 0xC0, 0xF8, 0x21, 0x03, 0x10, 0x31, 0x03, 0x30, 0x33, 0x03,
  0x30, 0x22, 0x02, 0x20, 0x62, 0x0C, 0x21, 0x86, 0x70, 0x3C, 0x00, 0x21,
  0x88, 0x86, 0x22, 0x10, 0xC8, 0x43, 0x61, 0x0D, 0x84, 0x34, 0x30, 0xD0,
  0xC2, 0x42, 0x0B, 0x08, 0x6C, 0x61, 0x12, 0xCC, 0x71, 0xC0, 0x0E, 0x1C,
  0x36, 0x45, 0x85, 0x08, 0x0C, 0x10, 0x18, 0x20, 0x30, 0x00, 0x60, 0x00,
  0x80, 0xC1, 0x01, 0x87, 0x0B, 0x0E, 0x32, 0x25, 0xC7, 0x8E, 0x00, 0x10,
  0x18, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x01, 0x10, 0x18, 0x80, 0xC4, 0x04,
  0x60, 0x23, 0x07, 0x18, 0x38, 0x62, 0xC1, 0xE6, 0x00, 0x20, 0x01, 0x00,
  0x18, 0xC1, 0x83, 0xF0, 0x00, 0x1F, 0x89, 0x87, 0x48, 0x04, 0x40, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x31, 0x81, 0x9C, 0x04, 0xBE,
  0x2C, 0x1F, 0x00, 0x03, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x06, 0x0F, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x03, 0xF0, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0C,
  0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0x0F, 0xC0, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x1F, 0x07, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x0F, 0xC0, 0x1C, 0x0C, 0x98,
  0x24, 0x31, 0x90, 0x44, 0xC0, 0xE0,
};

const GFXglyph IBMPlexMono_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 18, 16, 5, -18 },
  { 15, 7, 7, 16, 6, -19 },
  { 22, 16, 18, 16, 0, -18 },
  { 58, 14, 24, 16, 1, -21 },
  { 100, 18, 18, 16, -1, -18 },
  { 141, 15, 18, 16, 0, -18 },
  { 175, 3, 7, 16, 8, -19 },
  { 178, 9, 24, 16, 6, -20 },
  { 205, 9, 24, 16, 1, -20 },
  { 232, 13, 13, 16, 2, -14 },
  { 254, 12, 13, 16, 2, -14 },
  { 274, 5, 7, 16, 4, -3 },
  { 279, 8, 1, 16, 4, -8 },
  { 280, 3, 3, 16, 5, -3 },
  { 282, 14, 24, 16, 1, -20 },
  { 324, 13, 18, 16, 2, -18 },
  { 354, 12, 18, 16, 1, -18 },
  { 381, 13, 18, 16, 1, -18 },
  { 411, 13, 18, 16, 1, -18 },
  { 441, 13, 18, 16, 1, -18 },
  { 471, 14, 18, 16, 1, -18 },
  { 503, 12, 18, 16, 2, -18 },
  { 530, 12, 18, 16, 3, -18 },
  { 557, 14, 18, 16, 1, -18 },
  { 589, 12, 18, 16, 2, -18 },
  { 616, 5, 14, 16, 5, -14 },
  { 625, 6, 18, 16, 4, -14 },
  { 639, 13, 15, 16, 2, -15 },
  { 664, 14, 6, 16, 1, -11 },
  { 675, 13, 15, 16, 1, -15 },
  { 700, 10, 18, 16, 4, -18 },
  { 723, 12, 21, 16, 2, -18 },
  { 755, 14, 18, 16, 0, -18 },
  { 787, 13, 18, 16, 1, -18 },
  { 817, 13, 18, 16, 2, -18 },
  { 847, 13, 18, 16, 2, -18 },
  { 877, 14, 18, 16, 1, -18 },
  { 909, 15, 18, 16, 1, -18 },
  { 943, 13, 18, 16, 2, -18 },
  { 973, 14, 18, 16, 1, -18 },
  { 1005, 14, 18, 16, 1, -18 },
  { 1037, 12, 18, 16, 2, -18 },
  { 1064, 15, 18, 16, 1, -18 },
  { 1098, 11, 18, 16, 2, -18 },
  { 1123, 15, 18, 16, 1, -18 },
  { 1157, 14, 18, 16, 1, -18 },
  { 1189, 13, 18, 16, 2, -18 },
  { 1219, 14, 18, 16, 1, -18 },
  { 1251, 13, 22, 16, 2, -18 },
  { 1287, 14, 18, 16, 1, -18 },
  { 1319, 14, 18, 16, 1, -18 },
  { 1351, 15, 18, 16, 2, -18 },
  { 1385, 13, 18, 16, 2, -18 },
  { 1415, 13, 18, 16, 3, -18 },
  { 1445, 14, 18, 16, 2, -18 },
  { 1477, 16, 18, 16, 0, -18 },
  { 1513, 15, 18, 16, 2, -18 },
  { 1547, 16, 18, 16, 0, -18 },
  { 1583, 10, 24, 16, 5, -20 },
  { 1613, 6, 24, 16, 5, -20 },
  { 1631, 11, 24, 16, 0, -20 },
  { 1664, 13, 10, 16, 2, -18 },
  { 1681, 13, 1, 16, 0, 3 },
  { 1683, 3, 5, 16, 6, -20 },
  { 1685, 12, 13, 16, 2, -13 },
  { 1705, 12, 19, 16, 2, -19 },
  { 1734, 11, 13, 16, 2, -13 },
  { 1752, 13, 19, 16, 2, -19 },
  { 1783, 12, 13, 16, 2, -13 },
  { 1803, 16, 24, 16, 0, -19 },
  { 1851, 13, 18, 16, 1, -13 },
  { 1881, 11, 19, 16, 2, -19 },
  { 1908, 12, 19, 16, 2, -19 },
  { 1937, 12, 24, 16, 2, -19 },
  { 1973, 13, 19, 16, 2, -19 },
  { 2004, 10, 19, 16, 3, -19 },
  { 2028, 14, 13, 16, 1, -13 },
  { 2051, 11, 13, 16, 2, -13 },
  { 2069, 12, 13, 16, 2, -13 },
  { 2089, 13, 18, 16, 1, -13 },
  { 2119, 12, 18, 16, 2, -13 },
  { 2146, 12, 13, 16, 3, -13 },
  { 2166, 13, 13, 16, 1, -13 },
  { 2188, 12, 18, 16, 2, -18 },
  { 2215, 12, 13, 16, 2, -13 },
  { 2235, 12, 13, 16, 2, -13 },
  { 2255, 14, 13, 16, 1, -13 },
  { 2278, 15, 13, 16, 0, -13 },
  { 2303, 13, 18, 16, 1, -13 },
  { 2333, 13, 13, 16, 1, -13 },
  { 2355, 12, 24, 16, 3, -20 },
  { 2391, 6, 24, 16, 5, -20 },
  { 2409, 12, 24, 16, 1, -20 },
  { 2445, 14, 5, 16, 1, -10 },
};

const GFXfont IBMPlexMono_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_LightItalic26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_LIGHTITALIC26PT7B_H_
