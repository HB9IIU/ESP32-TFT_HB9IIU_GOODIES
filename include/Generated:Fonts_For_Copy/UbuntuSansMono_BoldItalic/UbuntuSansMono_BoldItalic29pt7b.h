#ifndef _UBUNTUSANSMONO_BOLDITALIC29PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x00,
  0x79, 0xF7, 0x9E, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x18,
  0xE3, 0x80, 0x00, 0xE3, 0x80, 0xF3, 0x80, 0x71, 0xC0, 0x79, 0xE0, 0x38,
  0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0x3C, 0x07, 0x1C, 0x03,
  0x8E, 0x03, 0xCE, 0x2F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x71, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x20, 0x3C, 0x7F,
  0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x10, 0x7C, 0x0E, 0x0F, 0xC1, 0xC0, 0xCC, 0x18, 0x1C,
  0xC3, 0x81, 0x8C, 0x70, 0x19, 0xCE, 0x01, 0x9D, 0xC0, 0x1F, 0xB8, 0x01,
  0xF3, 0x00, 0x04, 0x70, 0x00, 0x0E, 0x60, 0x01, 0xDF, 0x00, 0x3B, 0xF8,
  0x07, 0x3B, 0x80, 0xE3, 0x38, 0x0E, 0x73, 0x81, 0xC7, 0x30, 0x38, 0x77,
  0x07, 0x07, 0xE0, 0xE0, 0x3E, 0x00, 0x00, 0x20, 0x01, 0xF8, 0x07, 0xFC,
  0x07, 0xBC, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0F, 0xF0,
  0x07, 0xE0, 0x0F, 0xC6, 0x1F, 0xCF, 0x3F, 0xCE, 0x79, 0xEE, 0x70, 0xFC,
  0xF0, 0xFC, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0x1E,
  0x7B, 0xDF, 0xFF, 0x7B, 0xDC, 0xE6, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x18, 0x00, 0x80, 0x00, 0x00, 0x80, 0x0E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x07, 0x00, 0x38, 0x21, 0xC0,
  0xCE, 0x6F, 0xFF, 0xFF, 0xFD, 0xFF, 0xC1, 0xF0, 0x1D, 0xC1, 0xEF, 0x1F,
  0x7C, 0x31, 0x80, 0x88, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E, 0x3F, 0x3F, 0x3F,
  0x1E, 0x0E, 0x1E, 0xFC, 0xF8, 0xE0, 0x7F, 0xDF, 0xF7, 0xFB, 0xFE, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x9E, 0xF7, 0xBD, 0xCF, 0x7F, 0x9C, 0xFF,
  0x11, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF0, 0x79, 0xF1, 0xE1, 0xFF,
  0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x1F, 0xE3,
  0xFF, 0x0F, 0x78, 0x67, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE0, 0x00, 0x20, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F,
  0x04, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x40, 0x07, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x04, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xEE,
  0x01, 0xDE, 0x03, 0x9E, 0x07, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C,
  0x78, 0x3C, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x60, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x79, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFC, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x07, 0x8F, 0x0F, 0x1E, 0x3C,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xCF, 0x8F, 0x0F, 0x3C, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x00,
  0x80, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE3, 0xC3, 0xE7, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0x07, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xFC, 0xFC, 0xFC, 0x78, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x38, 0x1E, 0x3F, 0x0F, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x7C, 0x07,
  0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xFC, 0x1C, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xC3, 0xFE,
  0x03, 0xE0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x02, 0x03, 0xFE, 0x7F, 0xE7,
  0xFF, 0x61, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9F, 0x1E,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x70, 0xFF, 0x71, 0xFF, 0xF3, 0xFE, 0xE7,
  0x8E, 0xE7, 0x1E, 0xE7, 0x1E, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x3C, 0xE7,
  0xBC, 0xE7, 0xF8, 0xE3, 0xF8, 0xE1, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x7F,
  0x60, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x3C,
  0x3C, 0x78, 0x70, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9E, 0x0F, 0x78,
  0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x3E, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x3C, 0x1E, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00,
  0x70, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xF1, 0xF0, 0x47, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x41, 0xFF, 0xC3, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x3E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x79,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x82, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3E, 0x78, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0x78, 0x7C, 0x78, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x40, 0xF0, 0x70, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x1F,
  0x3E, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x7C, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0x70, 0xFD, 0xD8,
  0x7F, 0x6E, 0x1C, 0xFB, 0x87, 0x3C, 0xE1, 0xCF, 0x78, 0xF3, 0x9E, 0x38,
  0xE7, 0x0E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C, 0x03,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF8, 0x38,
  0x3E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xC1, 0xDC, 0x70, 0x77, 0x3C, 0x3D,
  0xCF, 0x0F, 0x33, 0xC3, 0x8E, 0xE0, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F,
  0x87, 0x07, 0xC1, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0x83,
  0x80, 0xE0, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE7,
  0xC3, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xF1, 0xE1,
  0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x1E,
  0x0F, 0x0F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE7, 0xC3,
  0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xF1, 0xE1, 0xFF,
  0xC3, 0xFF, 0x03, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F,
  0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0x78, 0x78,
  0x78, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0x20, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC7, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x3E, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF8, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0, 0x71, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x01, 0xE1, 0xE7, 0x38, 0x39, 0xE7,
  0x07, 0x3C, 0xE0, 0xEF, 0xBC, 0x3D, 0xB7, 0x07, 0x76, 0xE0, 0xEC, 0xDC,
  0x1F, 0x9B, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0,
  0x78, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x78, 0x03, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0,
  0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x7C, 0x78, 0x78, 0x78, 0xF0, 0x38, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xF0, 0xE1, 0xC3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x7C, 0x1F, 0xF0,
  0x3C, 0xC0, 0x70, 0x80, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x61,
  0xE3, 0xE3, 0xF1, 0xC0, 0x80, 0x00, 0xE0, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xBC, 0x00,
  0x40, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x90, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xE1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC7,
  0xC7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC1, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF8, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFD, 0xE0, 0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xEF,
  0x03, 0xDE, 0x0F, 0x78, 0x7E, 0xFF, 0xF9, 0xFF, 0xC3, 0xE0, 0x07, 0x80,
  0x07, 0x81, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x8F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC7, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1E, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x20, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x40, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xB0, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF8,
  0xF1, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78,
  0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x00, 0x01,
  0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0xFF, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF1, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x06,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x43, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0x3D, 0xF0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0xC0, 0x7B, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0x7F, 0xCF, 0xF3, 0xFE, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xF1, 0x1F, 0xE3, 0xFE, 0x3F,
  0x80, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0x9E, 0x71, 0xCE, 0x78,
  0xE7, 0x3C, 0xF3, 0x9C, 0x79, 0xCE, 0x39, 0xE7, 0x1C, 0x07, 0x8E, 0x03,
  0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x70, 0x00, 0x60, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xE3, 0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x78, 0x7C, 0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3C, 0x3D,
  0xE0, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E,
  0xF8, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x60, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x7C, 0x3F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xE0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x60, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xE3, 0xCF, 0x87,
  0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF,
  0x8F, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x20, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE1, 0xF0, 0x43, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xF0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC2, 0x07, 0x8F,
  0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x00, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x30, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x3E, 0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7,
  0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3,
  0xC7, 0xCF, 0x8F, 0xFF, 0x0F, 0xFF, 0x0F, 0xDE, 0x00, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0,
  0x7B, 0xE0, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x79, 0xCF, 0x3C,
  0xE7, 0x9E, 0x73, 0x9F, 0x71, 0xCF, 0xB8, 0xEF, 0xDC, 0x76, 0xFC, 0x3F,
  0x7E, 0x1F, 0x3E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0x83, 0x80, 0x1F, 0x07,
  0xC3, 0xC3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7D,
  0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x3C,
  0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x1F, 0x87,
  0x3F, 0xEF, 0x7F, 0xFE, 0x73, 0xFC, 0xF0, 0xF8,
};

const GFXglyph UbuntuSansMono_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 20, 16, 4, -20 },
  { 24, 12, 9, 16, 5, -22 },
  { 38, 17, 20, 16, 0, -20 },
  { 81, 16, 26, 16, 0, -23 },
  { 133, 20, 21, 16, -1, -21 },
  { 186, 16, 21, 16, 0, -21 },
  { 228, 5, 10, 16, 8, -22 },
  { 235, 13, 29, 16, 3, -23 },
  { 283, 13, 29, 16, 0, -23 },
  { 331, 13, 13, 16, 3, -20 },
  { 353, 14, 15, 16, 1, -16 },
  { 380, 8, 10, 16, 2, -5 },
  { 390, 10, 4, 16, 3, -10 },
  { 395, 6, 5, 16, 4, -5 },
  { 399, 20, 28, 16, -2, -23 },
  { 469, 15, 21, 16, 1, -21 },
  { 509, 13, 20, 16, 1, -20 },
  { 542, 16, 21, 16, 0, -21 },
  { 584, 16, 21, 16, 0, -21 },
  { 626, 16, 20, 16, 0, -20 },
  { 666, 17, 20, 16, 0, -20 },
  { 709, 16, 20, 16, 1, -20 },
  { 749, 15, 20, 16, 3, -20 },
  { 787, 15, 21, 16, 1, -21 },
  { 827, 15, 21, 16, 1, -21 },
  { 867, 8, 15, 16, 4, -15 },
  { 882, 10, 20, 16, 2, -15 },
  { 907, 15, 14, 16, 1, -15 },
  { 934, 16, 9, 16, 0, -13 },
  { 952, 15, 14, 16, 0, -15 },
  { 979, 12, 21, 16, 4, -21 },
  { 1011, 16, 25, 16, 1, -21 },
  { 1061, 15, 20, 16, -1, -20 },
  { 1099, 16, 20, 16, 0, -20 },
  { 1139, 15, 21, 16, 2, -21 },
  { 1179, 16, 20, 16, 0, -20 },
  { 1219, 17, 20, 16, 0, -20 },
  { 1262, 17, 20, 16, 1, -20 },
  { 1305, 16, 21, 16, 1, -21 },
  { 1347, 18, 20, 16, 0, -20 },
  { 1392, 17, 20, 16, 0, -20 },
  { 1435, 17, 20, 16, 0, -20 },
  { 1478, 18, 20, 16, 0, -20 },
  { 1523, 13, 20, 16, 0, -20 },
  { 1556, 18, 20, 16, -1, -20 },
  { 1601, 18, 20, 16, 0, -20 },
  { 1646, 15, 21, 16, 1, -21 },
  { 1686, 17, 20, 16, 0, -20 },
  { 1729, 15, 27, 16, 1, -21 },
  { 1780, 16, 20, 16, 0, -20 },
  { 1820, 16, 21, 16, 0, -21 },
  { 1862, 15, 20, 16, 3, -20 },
  { 1900, 17, 20, 16, 1, -20 },
  { 1943, 16, 20, 16, 3, -20 },
  { 1983, 19, 20, 16, 0, -20 },
  { 2031, 20, 20, 16, -1, -20 },
  { 2081, 16, 20, 16, 3, -20 },
  { 2121, 17, 20, 16, 0, -20 },
  { 2164, 15, 28, 16, 2, -23 },
  { 2217, 7, 28, 16, 5, -23 },
  { 2242, 16, 28, 16, -1, -23 },
  { 2298, 15, 12, 16, 1, -20 },
  { 2321, 15, 3, 16, -2, 2 },
  { 2327, 7, 6, 16, 7, -22 },
  { 2333, 15, 16, 16, 1, -16 },
  { 2363, 15, 23, 16, 0, -23 },
  { 2407, 15, 16, 16, 1, -16 },
  { 2437, 17, 23, 16, 1, -23 },
  { 2486, 15, 16, 16, 1, -16 },
  { 2516, 20, 28, 16, -2, -23 },
  { 2586, 17, 21, 16, -1, -16 },
  { 2631, 15, 23, 16, 0, -23 },
  { 2675, 12, 23, 16, 2, -23 },
  { 2710, 16, 29, 16, -1, -23 },
  { 2768, 16, 23, 16, 1, -23 },
  { 2814, 11, 22, 16, 3, -22 },
  { 2845, 17, 15, 16, -1, -15 },
  { 2877, 15, 16, 16, 0, -16 },
  { 2907, 14, 16, 16, 1, -16 },
  { 2935, 16, 21, 16, -1, -16 },
  { 2977, 15, 21, 16, 1, -16 },
  { 3017, 15, 16, 16, 1, -16 },
  { 3047, 15, 16, 16, 0, -16 },
  { 3077, 14, 20, 16, 2, -20 },
  { 3112, 15, 15, 16, 1, -15 },
  { 3141, 15, 15, 16, 2, -15 },
  { 3170, 17, 15, 16, 1, -15 },
  { 3202, 18, 15, 16, -1, -15 },
  { 3236, 20, 20, 16, -3, -15 },
  { 3286, 16, 15, 16, 0, -15 },
  { 3316, 16, 28, 16, 2, -23 },
  { 3372, 11, 28, 16, 3, -23 },
  { 3411, 15, 28, 16, -1, -23 },
  { 3464, 16, 6, 16, 0, -12 },
};

const GFXfont UbuntuSansMono_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_BOLDITALIC29PT7B_H_
