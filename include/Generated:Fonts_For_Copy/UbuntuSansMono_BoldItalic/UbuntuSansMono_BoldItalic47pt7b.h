#ifndef _UBUNTUSANSMONO_BOLDITALIC47PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x40,
  0x00, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF1,
  0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x82, 0x00, 0x1F, 0xC3, 0xC0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFF,
  0x00, 0x1E, 0x01, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE7,
  0x80, 0xF8, 0x03, 0xC7, 0x81, 0xF0, 0x07, 0xC7, 0x83, 0xE0, 0x07, 0x87,
  0x83, 0xC0, 0x07, 0x87, 0x87, 0x80, 0x07, 0x8F, 0x8F, 0x80, 0x07, 0x8F,
  0x1F, 0x00, 0x07, 0x9F, 0x3E, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x07, 0xFE,
  0x78, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x0F,
  0x3F, 0xE0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0x7C,
  0xF9, 0xF0, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xF0, 0xF1, 0xE0, 0x03, 0xE1,
  0xF1, 0xE0, 0x03, 0xC1, 0xE1, 0xE0, 0x07, 0xC1, 0xE1, 0xE0, 0x0F, 0x81,
  0xE3, 0xC0, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x07, 0xC7,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xC1, 0xFF, 0xC3, 0xE0, 0xFF, 0xF0, 0xF8,
  0x7E, 0xFE, 0x7E, 0x3F, 0x1F, 0xDF, 0x1F, 0x83, 0xFF, 0xC7, 0xE0, 0xFF,
  0xE1, 0xF0, 0x1F, 0xF8, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xF7, 0xE0, 0xFF, 0xF9, 0xF8, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0x9F,
  0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x38, 0x7C, 0x39, 0xF3, 0xE7,
  0xDF, 0xDE, 0x7E, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x7E, 0x03, 0xFB, 0xF0,
  0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xC3, 0xE0, 0x0E, 0x0E, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F,
  0x80, 0xE0, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7E, 0x1E, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x7E, 0x3F, 0xFE, 0x7E, 0x3F,
  0xFC, 0x7E, 0x7E, 0xFC, 0x7C, 0x7E, 0xFC, 0x10, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0x7C, 0x7E, 0x01, 0xC3, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1E, 0x01, 0xFC, 0x06, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x08, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0x83, 0xFC, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x2F, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x10, 0x00, 0x7F, 0x8E, 0x00,
  0x7F, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x07, 0xF0, 0x1C, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x20,
  0x01, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xFB, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xEF, 0xE0, 0x07, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x07,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xE0, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xE0, 0xFF, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00,
  0xF8, 0x7C, 0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xE3, 0xE0, 0xFF, 0xFC, 0x7C,
  0x3F, 0xFF, 0x9F, 0x0F, 0xFF, 0xE3, 0xE1, 0xF8, 0x7C, 0x7C, 0x7E, 0x1F,
  0x8F, 0x0F, 0x83, 0xF3, 0xE1, 0xF0, 0x7C, 0x7C, 0x7E, 0x0F, 0x8F, 0x8F,
  0x83, 0xF1, 0xF1, 0xF0, 0x7E, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC1, 0xF0,
  0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x8F, 0xC3, 0xE3, 0xFF, 0xF0, 0x7C, 0x3F,
  0xFE, 0x0F, 0x87, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3F, 0x03, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFD, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0xF0, 0x3F, 0xC0, 0x18,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x08, 0x0F, 0xF0, 0x1C, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFE, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0x7F, 0xC1, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xC0, 0x7F, 0x80, 0x30,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x7F, 0x00, 0x60, 0x1F, 0xE0, 0x1E,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xF9, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0x78, 0x07, 0xFC, 0x3F, 0xE0,
  0x1E, 0xF1, 0xEF, 0x80, 0xFB, 0xC7, 0xBE, 0x03, 0xEF, 0x3C, 0xF0, 0x0F,
  0x9C, 0xF7, 0xC0, 0x7E, 0x77, 0x9F, 0x01, 0xF1, 0xFE, 0x7C, 0x07, 0xC7,
  0xF1, 0xF0, 0x1F, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x3E, 0x03, 0xE1, 0xF8,
  0xF8, 0x0F, 0x87, 0xC7, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x07,
  0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x03, 0xF0,
  0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF8, 0x3E, 0x00, 0xFB, 0xE1, 0xF8, 0x07,
  0xEF, 0x87, 0xE0, 0x1F, 0x9E, 0x1F, 0x80, 0x7E, 0x7C, 0x7C, 0x01, 0xF1,
  0xF3, 0xF0, 0x0F, 0xC7, 0xCF, 0xC0, 0x3F, 0x0F, 0x3F, 0x00, 0xFC, 0x3E,
  0xFC, 0x03, 0xE0, 0xFB, 0xE0, 0x1F, 0x83, 0xFF, 0x80, 0x7E, 0x07, 0xFE,
  0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3F, 0x01, 0xFF, 0x00,
  0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFD, 0xFF,
  0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x0F, 0xF0,
  0x7F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0x00, 0xFE, 0x00, 0x40, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0xC0, 0x03, 0xF0, 0x1E, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x87, 0x87, 0xE0, 0x7E, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x7C,
  0x07, 0xC7, 0xF1, 0xF0, 0x1F, 0x1F, 0xCF, 0xC0, 0x7C, 0xFF, 0x3E, 0x03,
  0xF7, 0xFC, 0xF8, 0x0F, 0x9E, 0xF3, 0xE0, 0x3E, 0xFB, 0xCF, 0x80, 0xFB,
  0xCF, 0x7C, 0x03, 0xFE, 0x3D, 0xF0, 0x0F, 0x78, 0xF7, 0xC0, 0x7F, 0xC3,
  0xDE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x01, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF9, 0xFC,
  0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x3C, 0x00, 0x3E,
  0x0C, 0x00, 0x38, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x30, 0x07,
  0x01, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0xC7, 0xF8, 0x3E, 0x01, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xC3, 0xF8, 0x7F, 0x81, 0xF8, 0x7F, 0x80, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xF8, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF7, 0xF0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x07, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1C, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x60, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x50, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xF0,
  0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x20, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC1,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x02, 0x00, 0xFE, 0x00, 0xC0, 0x7F, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x07, 0xF3, 0xF8, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x87, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x00, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x8F, 0x8F, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF8,
  0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF0, 0xF8, 0xF8, 0x3E,
  0x3F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01,
  0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8,
  0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xE4, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF0, 0x7E, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0x04, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x1C, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x20,
  0x03, 0xF8, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x1C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF1, 0xF8, 0x01, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x7E,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x1E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3F, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF1, 0xFC,
  0x7C, 0x3E, 0x3F, 0x8F, 0x87, 0xCF, 0xF1, 0xE0, 0xF9, 0xFE, 0x7C, 0x1E,
  0x7F, 0xCF, 0x83, 0xCF, 0x39, 0xE0, 0x7B, 0xE7, 0x7C, 0x0F, 0x78, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x08, 0x07, 0xF8, 0x07, 0x87, 0xFF, 0x07, 0xE7,
  0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xF1,
  0xF0, 0x7F, 0xF8, 0xF8, 0x0F, 0xF0, 0x08, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 14, 34, 26, 7, -33 },
  { 61, 19, 15, 26, 8, -36 },
  { 97, 28, 33, 26, 0, -33 },
  { 213, 25, 41, 26, 1, -36 },
  { 342, 32, 34, 26, -2, -33 },
  { 478, 26, 33, 26, 0, -33 },
  { 586, 9, 16, 26, 13, -36 },
  { 604, 21, 46, 26, 5, -37 },
  { 725, 21, 46, 26, 0, -37 },
  { 846, 21, 21, 26, 5, -33 },
  { 902, 23, 24, 26, 2, -26 },
  { 971, 13, 17, 26, 3, -9 },
  { 999, 16, 7, 26, 5, -17 },
  { 1013, 9, 10, 26, 7, -9 },
  { 1025, 32, 46, 26, -3, -37 },
  { 1209, 24, 34, 26, 2, -33 },
  { 1311, 22, 33, 26, 1, -33 },
  { 1402, 26, 33, 26, 0, -33 },
  { 1510, 25, 34, 26, 0, -33 },
  { 1617, 27, 33, 26, 0, -33 },
  { 1729, 27, 34, 26, 0, -33 },
  { 1844, 25, 34, 26, 2, -33 },
  { 1951, 25, 33, 26, 4, -33 },
  { 2055, 25, 34, 26, 1, -33 },
  { 2162, 25, 33, 26, 1, -33 },
  { 2266, 13, 26, 26, 7, -25 },
  { 2309, 17, 33, 26, 3, -25 },
  { 2380, 24, 23, 26, 2, -25 },
  { 2449, 26, 16, 26, 0, -22 },
  { 2501, 24, 23, 26, 1, -25 },
  { 2570, 20, 34, 26, 6, -33 },
  { 2655, 27, 40, 26, 1, -33 },
  { 2790, 25, 33, 26, -2, -33 },
  { 2894, 26, 33, 26, 0, -33 },
  { 3002, 25, 34, 26, 3, -33 },
  { 3109, 26, 33, 26, 0, -33 },
  { 3217, 27, 33, 26, 1, -33 },
  { 3329, 28, 33, 26, 1, -33 },
  { 3445, 26, 34, 26, 2, -33 },
  { 3556, 30, 33, 26, -1, -33 },
  { 3680, 28, 33, 26, 0, -33 },
  { 3796, 27, 34, 26, 0, -33 },
  { 3911, 30, 33, 26, 0, -33 },
  { 4035, 22, 33, 26, 0, -33 },
  { 4126, 30, 33, 26, -2, -33 },
  { 4250, 30, 33, 26, -1, -33 },
  { 4374, 24, 34, 26, 2, -33 },
  { 4476, 27, 33, 26, 0, -33 },
  { 4588, 24, 42, 26, 2, -33 },
  { 4714, 26, 33, 26, 0, -33 },
  { 4822, 27, 34, 26, 0, -33 },
  { 4937, 25, 33, 26, 5, -33 },
  { 5041, 26, 34, 26, 2, -33 },
  { 5152, 26, 33, 26, 5, -33 },
  { 5260, 30, 33, 26, 0, -33 },
  { 5384, 32, 33, 26, -2, -33 },
  { 5516, 26, 33, 26, 5, -33 },
  { 5624, 29, 33, 26, -1, -33 },
  { 5744, 25, 46, 26, 3, -37 },
  { 5888, 10, 46, 26, 9, -37 },
  { 5946, 25, 46, 26, -1, -37 },
  { 6090, 24, 19, 26, 2, -33 },
  { 6147, 25, 6, 26, -4, 3 },
  { 6166, 11, 9, 26, 11, -36 },
  { 6179, 25, 26, 26, 1, -25 },
  { 6261, 24, 38, 26, 0, -37 },
  { 6375, 24, 26, 26, 2, -25 },
  { 6453, 28, 38, 26, 1, -37 },
  { 6586, 24, 26, 26, 2, -25 },
  { 6664, 33, 45, 26, -4, -36 },
  { 6850, 28, 34, 26, -2, -25 },
  { 6969, 24, 37, 26, 0, -37 },
  { 7080, 18, 38, 26, 4, -37 },
  { 7166, 26, 46, 26, -2, -37 },
  { 7316, 27, 37, 26, 1, -37 },
  { 7441, 16, 37, 26, 6, -36 },
  { 7515, 27, 25, 26, -1, -25 },
  { 7600, 24, 25, 26, 0, -25 },
  { 7675, 24, 26, 26, 1, -25 },
  { 7753, 27, 34, 26, -2, -25 },
  { 7868, 24, 34, 26, 2, -25 },
  { 7970, 24, 25, 26, 2, -25 },
  { 8045, 24, 26, 26, 1, -25 },
  { 8123, 22, 33, 26, 4, -32 },
  { 8214, 24, 26, 26, 2, -25 },
  { 8292, 23, 25, 26, 4, -25 },
  { 8364, 27, 25, 26, 1, -25 },
  { 8449, 28, 25, 26, -1, -25 },
  { 8537, 31, 34, 26, -4, -25 },
  { 8669, 25, 25, 26, 1, -25 },
  { 8748, 25, 46, 26, 3, -37 },
  { 8892, 17, 46, 26, 5, -37 },
  { 8990, 25, 46, 26, -2, -37 },
  { 9134, 25, 10, 26, 1, -19 },
};

const GFXfont UbuntuSansMono_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic47pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUSANSMONO_BOLDITALIC47PT7B_H_
