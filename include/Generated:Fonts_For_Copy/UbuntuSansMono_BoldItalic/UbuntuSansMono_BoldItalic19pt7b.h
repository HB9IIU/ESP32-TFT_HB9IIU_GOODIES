#ifndef _UBUNTUSANSMONO_BOLDITALIC19PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x00, 0x0E, 0x38, 0xE0, 0x77,
  0x67, 0x66, 0xE6, 0xC4, 0xCC, 0x06, 0x60, 0xDC, 0x33, 0x3F, 0xF7, 0xFE,
  0x33, 0x06, 0xE1, 0x98, 0xFF, 0xDF, 0xF9, 0x98, 0x77, 0x0C, 0xC0, 0x01,
  0x80, 0x60, 0x1E, 0x0F, 0xF3, 0xCC, 0x70, 0x0E, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x0E, 0x00, 0xC6, 0x39, 0xFE, 0x0F, 0x80, 0xC0, 0x18, 0x00, 0x1E,
  0x18, 0xB1, 0x8D, 0x98, 0x6D, 0x83, 0xD8, 0x0E, 0x80, 0x0C, 0x00, 0xDC,
  0x0D, 0xA0, 0xC9, 0x0C, 0xD8, 0x46, 0xCE, 0x1C, 0x00, 0x0F, 0x87, 0x61,
  0x98, 0x66, 0x1B, 0x07, 0x83, 0xCD, 0xFB, 0x67, 0xF0, 0xEE, 0x3B, 0xFE,
  0x7D, 0xC0, 0x76, 0xEE, 0xCC, 0x01, 0x03, 0xC3, 0xC3, 0x83, 0x81, 0xC1,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x1C, 0x04, 0x00, 0x04, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x10,
  0x00, 0x18, 0x0C, 0x3E, 0xDF, 0xF1, 0x81, 0xF1, 0xDC, 0x4C, 0x0E, 0x06,
  0x03, 0x1F, 0xFF, 0xFF, 0xFC, 0x60, 0x70, 0x38, 0x00, 0x11, 0xCE, 0x71,
  0xBB, 0x80, 0x7F, 0xFB, 0xF0, 0x5F, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x1F, 0x8F, 0xE7, 0x1D, 0x87, 0xE1, 0xFB, 0x6D, 0xDB, 0x26,
  0xC3, 0xB0, 0xCC, 0x73, 0xF8, 0x7C, 0x00, 0x07, 0x1F, 0x7E, 0x76, 0x4E,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x1F, 0xC7, 0xF8, 0x43,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x01, 0x80, 0x7F,
  0xCF, 0xF8, 0x1F, 0x87, 0xF0, 0x0C, 0x03, 0x01, 0xC3, 0xE1, 0xF0, 0x0E,
  0x01, 0x80, 0x68, 0x3B, 0xFC, 0xFE, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07,
  0xE1, 0xDC, 0x33, 0x0C, 0x63, 0x1C, 0xFF, 0xDF, 0xF8, 0x0C, 0x03, 0x80,
  0x70, 0x0F, 0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x7E, 0x0F, 0xE0, 0x1C,
  0x01, 0x80, 0x32, 0x0E, 0x7F, 0x8F, 0xE0, 0x07, 0xC7, 0xF3, 0xC1, 0xC0,
  0x60, 0x3F, 0xCF, 0xFB, 0x0E, 0xC3, 0xB0, 0xEE, 0x31, 0xFC, 0x7E, 0x00,
  0x7F, 0xFF, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0x8F, 0xF3, 0x1D, 0xC7, 0x31, 0x8F,
  0xC3, 0xE1, 0x9C, 0xC3, 0xB0, 0xEC, 0x33, 0xFC, 0x7E, 0x00, 0x1F, 0x87,
  0xF8, 0xC3, 0x18, 0x77, 0x0E, 0x61, 0x8F, 0xF0, 0xFE, 0x01, 0xC0, 0x70,
  0x3C, 0x3F, 0x0F, 0x80, 0x13, 0xDE, 0xE0, 0x01, 0x1C, 0xE7, 0x00, 0x04,
  0x3C, 0x78, 0xE0, 0x00, 0x04, 0x1C, 0x38, 0x70, 0x63, 0x8E, 0x00, 0x00,
  0x81, 0xF1, 0xFB, 0xF0, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x3F, 0xE0, 0x30, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xC3, 0xF7, 0xE3, 0xE0, 0xC0, 0x00, 0x7F, 0x3F, 0x90,
  0xE0, 0xE0, 0xF0, 0xF0, 0xE0, 0x60, 0x40, 0x00, 0x1C, 0x1E, 0x07, 0x00,
  0x0F, 0xC3, 0x9C, 0xE1, 0x98, 0x36, 0x7E, 0xCF, 0xDB, 0x32, 0x66, 0xCC,
  0xD9, 0xBB, 0x3E, 0x77, 0xC6, 0x00, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xC0,
  0xF0, 0x7C, 0x1B, 0x0E, 0xC3, 0x31, 0xCC, 0x63, 0x3F, 0xCF, 0xF7, 0x0D,
  0x83, 0xE0, 0xC0, 0x1F, 0xC3, 0xF8, 0xE3, 0x9C, 0x73, 0x9C, 0x7F, 0x0F,
  0xE3, 0x8E, 0x71, 0xCC, 0x39, 0x8F, 0x7F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF3,
  0x85, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x11, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xF3, 0x9C, 0xE3, 0x30, 0xCC, 0x37, 0x0D, 0xC7,
  0x71, 0xD8, 0xEE, 0x7B, 0xFC, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x0C,
  0x03, 0x80, 0x7F, 0x0F, 0xE1, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xCF,
  0xF8, 0x1F, 0xF1, 0xFE, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0x83,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0xCF, 0xF3,
  0x85, 0xC0, 0x60, 0x38, 0x0E, 0x3B, 0x8E, 0xC3, 0xB8, 0xCE, 0x33, 0xFC,
  0x7F, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x30, 0xE3, 0xFC, 0x7F,
  0xC7, 0x1C, 0x61, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xC3, 0x80, 0x1F, 0xE3,
  0xFC, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x7F, 0xCF, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x71, 0x1C, 0x7F, 0x87, 0xE0, 0x1C, 0x71,
  0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x06,
  0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x80, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0F, 0xFF, 0xF0, 0x0C, 0x30, 0xE7,
  0x1E, 0x71, 0xEF, 0x1E, 0xB3, 0x7B, 0x37, 0x63, 0x76, 0x30, 0x67, 0x0E,
  0x60, 0xE6, 0x0C, 0xE0, 0xC0, 0x18, 0x71, 0xC6, 0x3C, 0x63, 0xCE, 0x34,
  0xE3, 0x6C, 0x76, 0xC6, 0x6C, 0x63, 0xC6, 0x38, 0xE3, 0x8C, 0x38, 0xC3,
  0x80, 0x1F, 0x8F, 0xE7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1B, 0x06, 0xC3,
  0xB0, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xFC, 0x63, 0x9C, 0x73,
  0x8E, 0x61, 0xCF, 0xF3, 0xFC, 0x78, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00,
  0x1F, 0x8F, 0xE7, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1B, 0x06, 0xC3, 0xB0,
  0xCE, 0x73, 0xF8, 0x7C, 0x0C, 0x03, 0x80, 0x78, 0x04, 0x00, 0x1F, 0x83,
  0xF8, 0xE3, 0x9C, 0x73, 0x8C, 0x63, 0x9F, 0xE3, 0xF8, 0x77, 0x0C, 0x61,
  0x8E, 0x71, 0xCE, 0x18, 0x0F, 0xE3, 0xF8, 0xE1, 0x1C, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x31, 0x0E, 0x7F, 0xC7, 0xE0, 0xFF, 0xFF,
  0xF1, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x00, 0x30, 0xEE, 0x39, 0xC7, 0x38, 0xE6, 0x19, 0xC3, 0x38,
  0xE7, 0x1C, 0xC3, 0x18, 0xE3, 0x1C, 0x7F, 0x07, 0xC0, 0xE1, 0xF8, 0x7E,
  0x1B, 0x8E, 0xE3, 0x39, 0xCE, 0x63, 0xB8, 0xEC, 0x3F, 0x07, 0x81, 0xE0,
  0x70, 0x00, 0x38, 0x33, 0x07, 0x30, 0x63, 0x06, 0x36, 0x66, 0x6E, 0x6E,
  0xC6, 0xAC, 0x7A, 0xC5, 0x28, 0xF3, 0x8E, 0x38, 0xE3, 0x80, 0x1C, 0x38,
  0x73, 0x83, 0x98, 0x0D, 0x80, 0x7C, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x0D,
  0x80, 0xEE, 0x0E, 0x70, 0xE3, 0x8F, 0x0C, 0x00, 0xE1, 0xF8, 0x66, 0x39,
  0x9C, 0x76, 0x1F, 0x83, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x00, 0x1F, 0xE3, 0xFC, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xC3, 0xF0, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x7E, 0x3F, 0x0F, 0xC0, 0xCC, 0xCC, 0xCE, 0xEE, 0xEE,
  0x66, 0x66, 0x67, 0x77, 0x70, 0x0F, 0xC3, 0xF1, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0xFC, 0x3F, 0x0F, 0x80, 0x07, 0x03, 0xC1, 0xF0, 0xEE, 0x73, 0xB8,
  0x6E, 0x1C, 0x04, 0x7F, 0xEF, 0xFB, 0xFF, 0x00, 0x43, 0x3E, 0x20, 0x1F,
  0x9F, 0xDC, 0xFC, 0x7C, 0x36, 0x1B, 0x1D, 0x8E, 0xFF, 0x3D, 0x80, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0F, 0xE3, 0xFC, 0xC7, 0x31, 0xDC, 0x77,
  0x1D, 0x86, 0x63, 0xBF, 0xCF, 0xE0, 0x1F, 0xCF, 0xE7, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x84, 0xFF, 0x1F, 0xC0, 0x00, 0x60, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x3F, 0x0F, 0xE3, 0x9C, 0xE3, 0x98, 0x63, 0x0C, 0x63, 0x8C,
  0x71, 0xFE, 0x1E, 0xC0, 0x1F, 0x1F, 0xDC, 0x7C, 0x3C, 0xFF, 0xF3, 0x01,
  0xC0, 0xFF, 0x3F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x80, 0x60, 0x03,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x7C, 0x01, 0xF0, 0x0B,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x39,
  0xC3, 0xFC, 0x1F, 0xC0, 0x18, 0x03, 0x87, 0xF0, 0xFF, 0x03, 0x80, 0x04,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0F, 0xE3, 0xFC, 0xE7, 0x31, 0xDC, 0x77,
  0x19, 0xCE, 0x63, 0x98, 0xEE, 0x30, 0x1C, 0x38, 0x70, 0x00, 0x1F, 0x3E,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0F, 0xCF, 0x80, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x7E, 0x1F, 0xC0, 0xE0, 0x00, 0x06,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x31, 0xCE, 0x71, 0xDC, 0x3F, 0x07,
  0xC1, 0xF8, 0x3B, 0x87, 0x70, 0xC7, 0x38, 0xE0, 0x7C, 0xFB, 0xF0, 0xC1,
  0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0F, 0xCF, 0x80, 0x3D, 0xCF,
  0xF7, 0x6D, 0x9B, 0x6E, 0xDB, 0x3E, 0x1F, 0x06, 0xC1, 0xB0, 0x60, 0x3F,
  0x8F, 0xF3, 0x9C, 0xC7, 0x71, 0xDC, 0x67, 0x39, 0x8E, 0x63, 0xB8, 0xC0,
  0x1F, 0x3F, 0xDC, 0xFC, 0x7C, 0x3E, 0x1F, 0x0D, 0xCE, 0xFE, 0x3E, 0x00,
  0x1F, 0xC3, 0xFC, 0x63, 0x8C, 0x73, 0x8E, 0x71, 0xCC, 0x31, 0x9E, 0x7F,
  0x8F, 0xE1, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x1F, 0xCF, 0xE7, 0x3B,
  0x8E, 0xE3, 0xB0, 0xCC, 0x73, 0x9C, 0xFF, 0x1F, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0x3F, 0xCF, 0xE7, 0x09, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x00, 0x1F, 0xC7, 0xE3, 0x80, 0xE0, 0x3E, 0x03, 0xC0, 0x39,
  0x0E, 0x7F, 0x3F, 0x80, 0x18, 0x38, 0x38, 0xFF, 0xFF, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE2, 0x7E, 0x7E, 0x71, 0xB9, 0xD8, 0xFC, 0x7E, 0x37, 0x3B,
  0x1D, 0xCE, 0xFF, 0x3D, 0x80, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x67, 0x1D,
  0x87, 0xE1, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0xF8, 0x1B, 0x33, 0x6E, 0xCD,
  0xD9, 0xFB, 0x3F, 0xC7, 0x38, 0xE6, 0x18, 0xC0, 0x1C, 0x71, 0xCE, 0x0D,
  0xC0, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0xB8, 0x39, 0xCF, 0x1C, 0x0C,
  0x38, 0x61, 0x83, 0x1C, 0x1C, 0xC0, 0xEE, 0x07, 0x60, 0x3F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0x80, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x1F, 0xCF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7F, 0xBF, 0xC0, 0x03,
  0xE0, 0xF8, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x1E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x7E, 0x07, 0xC0,
  0x30, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1,
  0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x80, 0x0F, 0x03, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0xC0, 0x70, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x7C, 0x1E, 0x0E, 0x00, 0x18, 0x8F, 0x37, 0xFF, 0x1E,
};

const GFXglyph UbuntuSansMono_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 13, 11, 3, -13 },
  { 11, 8, 6, 11, 3, -14 },
  { 17, 11, 13, 11, 0, -13 },
  { 35, 11, 17, 11, 0, -15 },
  { 59, 13, 13, 11, -1, -13 },
  { 81, 10, 13, 11, 0, -13 },
  { 98, 4, 6, 11, 5, -14 },
  { 101, 9, 19, 11, 2, -15 },
  { 123, 9, 19, 11, 0, -15 },
  { 145, 9, 8, 11, 2, -13 },
  { 154, 9, 9, 11, 1, -10 },
  { 165, 5, 7, 11, 1, -4 },
  { 170, 7, 3, 11, 2, -7 },
  { 173, 3, 4, 11, 3, -4 },
  { 175, 13, 19, 11, -1, -15 },
  { 206, 10, 13, 11, 1, -13 },
  { 223, 8, 13, 11, 1, -13 },
  { 236, 11, 13, 11, 0, -13 },
  { 254, 10, 13, 11, 0, -13 },
  { 271, 11, 13, 11, 0, -13 },
  { 289, 11, 13, 11, 0, -13 },
  { 307, 10, 13, 11, 1, -13 },
  { 324, 10, 13, 11, 2, -13 },
  { 341, 10, 13, 11, 1, -13 },
  { 358, 11, 13, 11, 0, -13 },
  { 376, 5, 10, 11, 3, -10 },
  { 383, 7, 13, 11, 1, -10 },
  { 395, 10, 9, 11, 1, -10 },
  { 407, 11, 7, 11, 0, -9 },
  { 417, 10, 9, 11, 0, -10 },
  { 429, 9, 13, 11, 2, -13 },
  { 444, 11, 16, 11, 0, -13 },
  { 466, 10, 13, 11, -1, -13 },
  { 483, 11, 13, 11, 0, -13 },
  { 501, 10, 13, 11, 1, -13 },
  { 518, 10, 13, 11, 0, -13 },
  { 535, 11, 13, 11, 0, -13 },
  { 553, 12, 13, 11, 0, -13 },
  { 573, 10, 13, 11, 1, -13 },
  { 590, 12, 13, 11, 0, -13 },
  { 610, 11, 13, 11, 0, -13 },
  { 628, 11, 13, 11, 0, -13 },
  { 646, 12, 13, 11, 0, -13 },
  { 666, 9, 13, 11, 0, -13 },
  { 681, 12, 13, 11, -1, -13 },
  { 701, 12, 13, 11, 0, -13 },
  { 721, 10, 13, 11, 1, -13 },
  { 738, 11, 13, 11, 0, -13 },
  { 756, 10, 17, 11, 1, -13 },
  { 778, 11, 13, 11, 0, -13 },
  { 796, 11, 13, 11, 0, -13 },
  { 814, 10, 13, 11, 2, -13 },
  { 831, 11, 13, 11, 1, -13 },
  { 849, 10, 13, 11, 2, -13 },
  { 866, 12, 13, 11, 0, -13 },
  { 886, 13, 13, 11, -1, -13 },
  { 908, 10, 13, 11, 2, -13 },
  { 925, 11, 13, 11, 0, -13 },
  { 943, 10, 19, 11, 1, -15 },
  { 967, 4, 19, 11, 4, -15 },
  { 977, 10, 19, 11, 0, -15 },
  { 1001, 10, 8, 11, 1, -13 },
  { 1011, 11, 3, 11, -2, 1 },
  { 1016, 5, 4, 11, 4, -15 },
  { 1019, 9, 10, 11, 1, -10 },
  { 1031, 10, 15, 11, 0, -15 },
  { 1050, 10, 10, 11, 1, -10 },
  { 1063, 11, 15, 11, 1, -15 },
  { 1084, 9, 10, 11, 1, -10 },
  { 1096, 14, 19, 11, -2, -15 },
  { 1130, 12, 14, 11, -1, -10 },
  { 1151, 10, 15, 11, 0, -15 },
  { 1170, 7, 15, 11, 2, -15 },
  { 1184, 11, 19, 11, -1, -15 },
  { 1211, 11, 15, 11, 0, -15 },
  { 1232, 7, 15, 11, 2, -15 },
  { 1246, 10, 10, 11, 0, -10 },
  { 1259, 10, 10, 11, 0, -10 },
  { 1272, 9, 10, 11, 1, -10 },
  { 1284, 11, 14, 11, -1, -10 },
  { 1304, 10, 14, 11, 1, -10 },
  { 1322, 10, 10, 11, 1, -10 },
  { 1335, 10, 10, 11, 0, -10 },
  { 1348, 8, 13, 11, 2, -13 },
  { 1361, 9, 10, 11, 1, -10 },
  { 1373, 10, 10, 11, 1, -10 },
  { 1386, 11, 10, 11, 1, -10 },
  { 1400, 12, 10, 11, -1, -10 },
  { 1415, 13, 14, 11, -2, -10 },
  { 1438, 10, 10, 11, 0, -10 },
  { 1451, 11, 19, 11, 1, -15 },
  { 1478, 7, 19, 11, 2, -15 },
  { 1495, 10, 19, 11, -1, -15 },
  { 1519, 10, 4, 11, 0, -8 },
};

const GFXfont UbuntuSansMono_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_BOLDITALIC19PT7B_H_
