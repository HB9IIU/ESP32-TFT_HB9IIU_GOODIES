#ifndef _UBUNTUSANSMONO_BOLDITALIC31PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x3C, 0xFB, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xC7, 0x8E, 0x3C, 0xF1, 0xC7, 0x0E, 0x00, 0x00, 0xF3, 0xC0,
  0x38, 0xE0, 0x1E, 0x38, 0x07, 0x1E, 0x03, 0xC7, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x07, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x38, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x38, 0xE0, 0x1E,
  0x38, 0x07, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1E, 0x02, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x84, 0x07, 0xC7, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x08, 0x3F, 0x03,
  0x83, 0xF8, 0x38, 0x19, 0xC3, 0x81, 0xCE, 0x3C, 0x0E, 0x71, 0xC0, 0x73,
  0x9C, 0x03, 0xB9, 0xC0, 0x1F, 0xDC, 0x00, 0xFD, 0xC0, 0x01, 0xDE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0xF8, 0x00, 0xEF, 0xE0, 0x0E, 0x77, 0x00, 0xE7,
  0x38, 0x0F, 0x39, 0xC0, 0x71, 0x8E, 0x07, 0x0C, 0x60, 0x70, 0x77, 0x07,
  0x03, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x78, 0x1E,
  0x38, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xF9, 0x01, 0xF8, 0xF1, 0xFE, 0x71,
  0xEF, 0x39, 0xE3, 0xFC, 0xE1, 0xFC, 0xF0, 0x7C, 0x78, 0x1E, 0x3E, 0x3F,
  0x0F, 0xFF, 0xC7, 0xFD, 0xE1, 0xFC, 0x78, 0x3C, 0xF7, 0xDF, 0x79, 0xE7,
  0x9C, 0x73, 0x8E, 0x00, 0x00, 0x08, 0x00, 0x60, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x04, 0x78, 0x9C,
  0xEE, 0xFB, 0x7F, 0xFF, 0xF7, 0xFF, 0x81, 0xF0, 0x1F, 0xE0, 0xFB, 0xC7,
  0xCF, 0x87, 0x3C, 0x08, 0x40, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x1F, 0x1F, 0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0xFC, 0xF8, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x19, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x79, 0xCF, 0x7B,
  0xCF, 0x7B, 0xCF, 0xF1, 0x8F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3F, 0xF8, 0x7F, 0xC1, 0xCF, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0xF8, 0x20,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x01,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x40, 0xF8, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x4F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x18, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0,
  0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x78, 0x3C, 0x1F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x18, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x60, 0x3D, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xCF,
  0x83, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF8, 0x1E, 0x3C, 0x1F,
  0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x1E, 0x0F, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3E, 0xF8, 0x78, 0x7C, 0xF8, 0x3C, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x01,
  0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x3F, 0x3F, 0xFF, 0x1F,
  0xFE, 0x07, 0x9E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0xC3, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x01, 0xE0, 0x38, 0x7E, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x38, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x80, 0x3F, 0x03, 0xFE, 0x3F, 0xF3, 0xFF, 0x07, 0xF8, 0x0F, 0x80,
  0x18, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF2, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF0, 0xF1,
  0xE0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xF0, 0xFF, 0x71, 0xFF, 0xB8, 0xFF,
  0xBC, 0xF1, 0xDC, 0x71, 0xEE, 0x78, 0xF7, 0x3C, 0x7B, 0x9C, 0x39, 0xCE,
  0x3C, 0xE7, 0x9E, 0x73, 0xFF, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xFE, 0x20, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x78,
  0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x78, 0x01, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x9E, 0x3F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x70, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0,
  0x7C, 0xF8, 0x3E, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0x10,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x4F, 0x03, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8,
  0x3C, 0x3C, 0x1E, 0x1F, 0x9F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x3E, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xC0, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x20, 0x7C, 0x1E, 0x3E, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x07, 0x83, 0xF0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0xF0, 0xF8, 0x0F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xDF, 0x00, 0x3D, 0xF0,
  0x03, 0xCF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x83,
  0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0xEC,
  0x6E, 0x0E, 0xCF, 0xE0, 0xEC, 0xDC, 0x1E, 0xFD, 0xC1, 0xCF, 0x9C, 0x1C,
  0xFB, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0x83, 0xC0, 0x38, 0x38, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xE1,
  0xE0, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xE0, 0xF7, 0x3C, 0x1C, 0xE7,
  0x87, 0x9C, 0xF0, 0xF3, 0x9C, 0x1E, 0x7F, 0x83, 0x87, 0xF0, 0xF0, 0xFE,
  0x1E, 0x1F, 0x83, 0xC3, 0xF0, 0x70, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0xFF, 0x1F, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x07,
  0xC3, 0xC1, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0x81, 0xE1,
  0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x60, 0x01,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0x78, 0x3C,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x9F, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xF3, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x01, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x10, 0x0F, 0x87, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x3E,
  0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xF8, 0x0F, 0xFC,
  0x07, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0xC3,
  0xCF, 0x3C, 0x3C, 0xF3, 0x83, 0x9F, 0x38, 0x39, 0xF7, 0x83, 0xBF, 0x78,
  0x7B, 0x77, 0x07, 0x77, 0x70, 0x76, 0x7F, 0x07, 0xE7, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0xF8, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF8, 0x78, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF3, 0xE3, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xBE, 0x1F, 0x1E, 0x3E, 0x1E, 0x3C, 0x1F, 0xFC, 0x0F, 0x78, 0x0F,
  0x10, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0x70,
  0xF8, 0xFE, 0x3F, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF9, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xBC, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x30, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1F, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x02,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7F, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xBC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF8, 0x78, 0x7C, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF9, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFE, 0xF0, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x1F, 0x78, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x3E, 0x0F, 0x8F,
  0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x04, 0x07, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E,
  0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0xFF, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x31, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x10, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x08, 0x3E, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x0F, 0x8F, 0x0F,
  0x87, 0x8F, 0x83, 0xCF, 0x83, 0xEF, 0x81, 0xEF, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x87,
  0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xCC, 0xFF,
  0x9F, 0xF1, 0xFF, 0x0F, 0xEF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x79, 0xC7,
  0x1E, 0x73, 0xC7, 0x1C, 0xF1, 0xCF, 0x38, 0xF3, 0xCE, 0x3C, 0xE7, 0x8E,
  0x39, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x00,
  0xF3, 0xC0, 0x38, 0x00, 0x70, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8,
  0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF, 0x83,
  0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF,
  0x87, 0xDF, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x70, 0x03,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE7, 0xC3, 0xE3, 0xC3,
  0xF1, 0xE7, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E,
  0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x7C,
  0xFC, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x86, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0x02, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x38, 0x7C, 0x7F, 0xFC,
  0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF9, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x1E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8,
  0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0x3C, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x7D, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xDE,
  0x00, 0xE7, 0x00, 0x79, 0xC7, 0x1E, 0x71, 0xC7, 0x3C, 0xF1, 0xCF, 0x3C,
  0xF3, 0xDF, 0x38, 0xE7, 0xCE, 0x3B, 0xB7, 0x0E, 0xEF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x1F, 0x03, 0xE1,
  0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xDE, 0x01, 0xF3, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xF8, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0x83, 0x9F, 0xE3,
  0xCF, 0xFF, 0xCF, 0xFF, 0xEF, 0x0F, 0xE1, 0x83, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 21, 17, 4, -21 },
  { 28, 13, 10, 17, 5, -24 },
  { 45, 18, 21, 17, 0, -21 },
  { 93, 17, 27, 17, 0, -24 },
  { 151, 21, 23, 17, -1, -22 },
  { 212, 17, 22, 17, 0, -22 },
  { 259, 6, 11, 17, 8, -24 },
  { 268, 14, 31, 17, 3, -25 },
  { 323, 14, 31, 17, 0, -25 },
  { 378, 14, 13, 17, 3, -21 },
  { 401, 15, 16, 17, 1, -17 },
  { 431, 8, 11, 17, 2, -6 },
  { 442, 10, 4, 17, 4, -11 },
  { 447, 6, 6, 17, 4, -6 },
  { 452, 21, 30, 17, -2, -24 },
  { 531, 16, 22, 17, 1, -22 },
  { 575, 14, 21, 17, 1, -21 },
  { 612, 17, 22, 17, 0, -22 },
  { 659, 17, 22, 17, 0, -22 },
  { 706, 18, 21, 17, 0, -21 },
  { 754, 18, 21, 17, 0, -21 },
  { 802, 17, 22, 17, 1, -22 },
  { 849, 16, 21, 17, 3, -21 },
  { 891, 16, 22, 17, 1, -22 },
  { 935, 16, 22, 17, 1, -22 },
  { 979, 9, 17, 17, 4, -17 },
  { 999, 11, 22, 17, 2, -17 },
  { 1030, 16, 14, 17, 1, -16 },
  { 1058, 17, 10, 17, 0, -14 },
  { 1080, 15, 14, 17, 1, -16 },
  { 1107, 13, 22, 17, 4, -22 },
  { 1143, 17, 27, 17, 1, -22 },
  { 1201, 17, 21, 17, -2, -21 },
  { 1246, 17, 22, 17, 0, -22 },
  { 1293, 16, 22, 17, 2, -22 },
  { 1337, 17, 22, 17, 0, -22 },
  { 1384, 17, 21, 17, 1, -21 },
  { 1429, 18, 21, 17, 1, -21 },
  { 1477, 17, 22, 17, 1, -22 },
  { 1524, 19, 21, 17, 0, -21 },
  { 1574, 19, 21, 17, 0, -21 },
  { 1624, 18, 21, 17, 0, -21 },
  { 1672, 20, 21, 17, 0, -21 },
  { 1725, 14, 21, 17, 0, -21 },
  { 1762, 20, 21, 17, -1, -21 },
  { 1815, 19, 21, 17, 0, -21 },
  { 1865, 16, 22, 17, 1, -22 },
  { 1909, 18, 22, 17, 0, -22 },
  { 1959, 16, 28, 17, 1, -22 },
  { 2015, 17, 22, 17, 0, -22 },
  { 2062, 18, 22, 17, 0, -22 },
  { 2112, 17, 21, 17, 3, -21 },
  { 2157, 18, 21, 17, 1, -21 },
  { 2205, 17, 21, 17, 3, -21 },
  { 2250, 20, 21, 17, 0, -21 },
  { 2303, 21, 21, 17, -1, -21 },
  { 2359, 16, 21, 17, 4, -21 },
  { 2401, 19, 21, 17, 0, -21 },
  { 2451, 17, 30, 17, 2, -24 },
  { 2515, 7, 30, 17, 6, -24 },
  { 2542, 17, 30, 17, -1, -24 },
  { 2606, 16, 12, 17, 1, -21 },
  { 2630, 16, 4, 17, -2, 2 },
  { 2638, 8, 6, 17, 7, -24 },
  { 2644, 16, 17, 17, 1, -17 },
  { 2678, 16, 24, 17, 0, -24 },
  { 2726, 16, 17, 17, 1, -17 },
  { 2760, 18, 24, 17, 1, -24 },
  { 2814, 16, 17, 17, 1, -17 },
  { 2848, 22, 30, 17, -3, -24 },
  { 2931, 18, 23, 17, -1, -17 },
  { 2983, 16, 24, 17, 0, -24 },
  { 3031, 12, 24, 17, 3, -24 },
  { 3067, 18, 30, 17, -2, -24 },
  { 3135, 17, 24, 17, 1, -24 },
  { 3186, 11, 24, 17, 4, -24 },
  { 3219, 18, 16, 17, -1, -16 },
  { 3255, 16, 17, 17, 0, -17 },
  { 3289, 15, 17, 17, 1, -17 },
  { 3321, 17, 23, 17, -1, -17 },
  { 3370, 16, 23, 17, 1, -17 },
  { 3416, 16, 17, 17, 1, -17 },
  { 3450, 16, 17, 17, 0, -17 },
  { 3484, 14, 21, 17, 3, -21 },
  { 3521, 16, 16, 17, 1, -16 },
  { 3553, 16, 16, 17, 2, -16 },
  { 3585, 18, 16, 17, 1, -16 },
  { 3621, 19, 16, 17, -1, -16 },
  { 3659, 21, 22, 17, -3, -16 },
  { 3717, 17, 16, 17, 0, -16 },
  { 3751, 17, 30, 17, 2, -24 },
  { 3815, 12, 30, 17, 3, -24 },
  { 3860, 16, 30, 17, -1, -24 },
  { 3920, 17, 6, 17, 0, -12 },
};

const GFXfont UbuntuSansMono_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_BOLDITALIC31PT7B_H_
