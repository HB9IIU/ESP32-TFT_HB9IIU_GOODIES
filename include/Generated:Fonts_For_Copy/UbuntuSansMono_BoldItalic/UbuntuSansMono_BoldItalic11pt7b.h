#ifndef _UBUNTUSANSMONO_BOLDITALIC11PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xAC, 0x26, 0xDB, 0xA0, 0x14, 0x29, 0xF9, 0x46, 0x9F, 0x94,
  0x58, 0x08, 0x23, 0xD8, 0x70, 0xE0, 0xA6, 0x71, 0x80, 0x22, 0xA9, 0xA3,
  0x81, 0x86, 0x95, 0x4C, 0x18, 0xA6, 0x8C, 0x77, 0x69, 0xBF, 0xF8, 0x08,
  0xCC, 0xC4, 0x63, 0x18, 0xC2, 0x18, 0x11, 0x86, 0x30, 0x8C, 0x62, 0x33,
  0x30, 0x25, 0x7E, 0xE5, 0x80, 0x10, 0x47, 0xEC, 0x20, 0x80, 0x6D, 0x40,
  0x7F, 0xF0, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x18, 0xF6, 0x55, 0x57, 0x3C, 0x9C, 0x09, 0xDE, 0x31, 0x08, 0xDF,
  0x39, 0xF0, 0x43, 0x39, 0x8C, 0x3E, 0x38, 0xB0, 0xCE, 0x38, 0x28, 0xBE,
  0x04, 0x31, 0xCA, 0x4B, 0xF1, 0x86, 0x3C, 0xF2, 0x1C, 0x18, 0x28, 0xBE,
  0x0C, 0xF6, 0x1E, 0x4F, 0x34, 0xDE, 0x7F, 0xF1, 0x8C, 0x21, 0x84, 0x30,
  0x18, 0xB6, 0x4F, 0x7B, 0x3C, 0x9E, 0x39, 0xB4, 0x51, 0x7C, 0x21, 0xB8,
  0x78, 0x0D, 0x80, 0x36, 0x00, 0x66, 0x48, 0x04, 0x76, 0x3C, 0x18, 0x7C,
  0x0F, 0xFE, 0x41, 0xC1, 0xCE, 0xE0, 0x72, 0xC6, 0x66, 0x01, 0x18, 0x1C,
  0x94, 0x57, 0xB6, 0xBB, 0xB6, 0x68, 0xE0, 0x0C, 0x31, 0xC5, 0x34, 0xF6,
  0x71, 0x38, 0xF6, 0x5F, 0x79, 0x3C, 0xFE, 0x3D, 0xEC, 0x20, 0x82, 0x0D,
  0x3C, 0x39, 0xF6, 0xD9, 0x4D, 0x3D, 0xBC, 0x3E, 0x78, 0x83, 0xC7, 0x88,
  0x10, 0x7C, 0x3E, 0x78, 0x83, 0xE7, 0x88, 0x10, 0x60, 0x1E, 0x79, 0x82,
  0x04, 0xD9, 0x92, 0x3C, 0x26, 0xC9, 0x93, 0xE7, 0xD9, 0xB2, 0x4C, 0x3E,
  0xF8, 0x40, 0x83, 0x06, 0x0C, 0x7C, 0x3C, 0xF0, 0xC3, 0x08, 0x29, 0xBC,
  0x26, 0xD9, 0xA3, 0x87, 0x0B, 0x36, 0x64, 0x21, 0x18, 0xC4, 0x23, 0x1F,
  0x26, 0xC9, 0xB3, 0x65, 0x59, 0xA3, 0x44, 0x26, 0xC9, 0xD2, 0xA5, 0xDB,
  0xB6, 0x44, 0x18, 0xF6, 0x51, 0xCF, 0x3D, 0x9C, 0x38, 0xF6, 0x59, 0x7D,
  0x0C, 0x30, 0x18, 0xF6, 0x51, 0xCF, 0x3D, 0x9C, 0x20, 0xE0, 0x39, 0xF6,
  0x5B, 0x79, 0x6D, 0xB2, 0x1D, 0xF6, 0x1C, 0x18, 0x28, 0xBE, 0xFF, 0xF2,
  0x08, 0x61, 0x84, 0x10, 0x26, 0xC9, 0x92, 0x64, 0xD9, 0x36, 0x38, 0xC7,
  0x3C, 0xB6, 0xD3, 0xCE, 0x18, 0x62, 0xCD, 0x12, 0xA7, 0x5F, 0xB6, 0x6C,
  0x66, 0x48, 0xE0, 0xC3, 0x8F, 0x12, 0x64, 0xCF, 0x25, 0x94, 0x61, 0x86,
  0x10, 0x3E, 0xF8, 0x20, 0xC3, 0x0C, 0x10, 0x7C, 0x3C, 0xE2, 0x18, 0x61,
  0x04, 0x30, 0xC2, 0x0E, 0x00, 0xDB, 0x6C, 0x92, 0x49, 0x80, 0x3C, 0xE0,
  0x82, 0x18, 0x41, 0x04, 0x30, 0xCE, 0x00, 0x18, 0x62, 0xDB, 0xC4, 0xFC,
  0x5C, 0x80, 0x3D, 0xB4, 0xF2, 0xD9, 0xE0, 0x10, 0x82, 0x1E, 0x6D, 0x34,
  0xF6, 0xF0, 0x3D, 0xD4, 0x30, 0x41, 0xE0, 0x02, 0x08, 0x11, 0xE6, 0xC9,
  0xB2, 0x6C, 0x78, 0x39, 0xB4, 0xFE, 0x41, 0xE0, 0x02, 0x0F, 0x08, 0x3E,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0xE0, 0x3D, 0xB4, 0xF2, 0x78, 0xE9,
  0xBC, 0x10, 0x82, 0x1E, 0x6D, 0x34, 0xB2, 0xD8, 0x23, 0x0E, 0x26, 0x64,
  0x70, 0x04, 0x0C, 0x01, 0xE0, 0x41, 0x83, 0x04, 0x08, 0xB3, 0xC0, 0x10,
  0x60, 0x81, 0x36, 0x8E, 0x14, 0x2C, 0xC8, 0xF2, 0x26, 0x64, 0x47, 0x7D,
  0x55, 0x7F, 0x8A, 0x20, 0x79, 0xB4, 0xD2, 0xCB, 0x60, 0x39, 0xB4, 0xF3,
  0xD9, 0xC0, 0x79, 0xB4, 0xD3, 0xDB, 0xC8, 0x20, 0x3D, 0xB4, 0xF2, 0xC9,
  0xE1, 0x84, 0x3D, 0xF6, 0x10, 0x43, 0x00, 0x3D, 0x97, 0x0E, 0x8B, 0xE0,
  0x27, 0xD8, 0x84, 0x61, 0xC0, 0x6D, 0xB4, 0x92, 0xD9, 0xE0, 0x8C, 0xF5,
  0xEE, 0x20, 0x46, 0xA9, 0xD7, 0xED, 0x9B, 0x00, 0x64, 0xA3, 0x8C, 0x7B,
  0x20, 0x32, 0x6C, 0xD1, 0xE3, 0x83, 0x0C, 0x70, 0x3D, 0x31, 0x8C, 0x63,
  0xE0, 0x1C, 0xE2, 0x08, 0x23, 0x04, 0x10, 0x43, 0x46, 0x00, 0x13, 0x32,
  0x26, 0x64, 0x4C, 0xC0, 0x31, 0xC6, 0x21, 0x0C, 0xC6, 0x21, 0x38, 0x7E,
  0x60,
};

const GFXglyph UbuntuSansMono_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 4, 3, 6, 2, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 10, 6, 0, -9 },
  { 21, 7, 8, 6, 0, -8 },
  { 28, 6, 8, 6, 0, -8 },
  { 34, 2, 3, 6, 3, -8 },
  { 35, 5, 11, 6, 1, -9 },
  { 42, 5, 11, 6, 0, -9 },
  { 49, 5, 5, 6, 1, -8 },
  { 53, 6, 6, 6, 0, -6 },
  { 58, 3, 4, 6, 1, -2 },
  { 60, 4, 2, 6, 1, -4 },
  { 61, 2, 2, 6, 2, -2 },
  { 62, 8, 11, 6, -1, -9 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 5, 8, 6, 0, -8 },
  { 84, 6, 8, 6, 0, -8 },
  { 90, 6, 8, 6, 0, -8 },
  { 96, 6, 8, 6, 0, -8 },
  { 102, 6, 8, 6, 0, -8 },
  { 108, 6, 8, 6, 0, -8 },
  { 114, 6, 8, 6, 1, -8 },
  { 120, 6, 8, 6, 0, -8 },
  { 126, 6, 8, 6, 0, -8 },
  { 132, 3, 6, 6, 2, -6 },
  { 135, 4, 8, 6, 1, -6 },
  { 139, 6, 5, 6, 0, -6 },
  { 143, 6, 4, 6, 0, -5 },
  { 146, 6, 5, 6, 0, -6 },
  { 150, 5, 8, 6, 1, -8 },
  { 155, 6, 10, 6, 0, -8 },
  { 163, 6, 8, 6, -1, -8 },
  { 169, 6, 8, 6, 0, -8 },
  { 175, 6, 8, 6, 1, -8 },
  { 181, 6, 8, 6, 0, -8 },
  { 187, 7, 8, 6, 0, -8 },
  { 194, 7, 8, 6, 0, -8 },
  { 201, 7, 8, 6, 0, -8 },
  { 208, 7, 8, 6, 0, -8 },
  { 215, 7, 8, 6, 0, -8 },
  { 222, 6, 8, 6, 0, -8 },
  { 228, 7, 8, 6, 0, -8 },
  { 235, 5, 8, 6, 0, -8 },
  { 240, 7, 8, 6, 0, -8 },
  { 247, 7, 8, 6, 0, -8 },
  { 254, 6, 8, 6, 0, -8 },
  { 260, 6, 8, 6, 0, -8 },
  { 266, 6, 10, 6, 0, -8 },
  { 274, 6, 8, 6, 0, -8 },
  { 280, 6, 8, 6, 0, -8 },
  { 286, 6, 8, 6, 1, -8 },
  { 292, 7, 8, 6, 0, -8 },
  { 299, 6, 8, 6, 1, -8 },
  { 305, 7, 8, 6, 0, -8 },
  { 312, 7, 8, 6, 0, -8 },
  { 319, 6, 8, 6, 1, -8 },
  { 325, 7, 8, 6, 0, -8 },
  { 332, 6, 11, 6, 1, -9 },
  { 341, 3, 11, 6, 2, -9 },
  { 346, 6, 11, 6, 0, -9 },
  { 355, 6, 5, 6, 0, -8 },
  { 359, 6, 1, 6, -1, 1 },
  { 360, 3, 3, 6, 2, -9 },
  { 362, 6, 6, 6, 0, -6 },
  { 367, 6, 9, 6, 0, -9 },
  { 374, 6, 6, 6, 0, -6 },
  { 379, 7, 9, 6, 0, -9 },
  { 387, 6, 6, 6, 0, -6 },
  { 392, 8, 11, 6, -1, -9 },
  { 403, 6, 8, 6, 0, -6 },
  { 409, 6, 9, 6, 0, -9 },
  { 416, 4, 9, 6, 1, -9 },
  { 421, 7, 11, 6, -1, -9 },
  { 431, 7, 9, 6, 0, -9 },
  { 439, 4, 8, 6, 1, -8 },
  { 443, 6, 6, 6, 0, -6 },
  { 448, 6, 6, 6, 0, -6 },
  { 453, 6, 6, 6, 0, -6 },
  { 458, 6, 8, 6, 0, -6 },
  { 464, 6, 8, 6, 0, -6 },
  { 470, 6, 6, 6, 0, -6 },
  { 475, 6, 6, 6, 0, -6 },
  { 480, 5, 7, 6, 1, -7 },
  { 485, 6, 6, 6, 0, -6 },
  { 490, 5, 6, 6, 1, -6 },
  { 494, 7, 6, 6, 0, -6 },
  { 500, 6, 6, 6, 0, -6 },
  { 505, 7, 8, 6, -1, -6 },
  { 512, 6, 6, 6, 0, -6 },
  { 517, 6, 11, 6, 1, -9 },
  { 526, 4, 11, 6, 1, -9 },
  { 532, 5, 11, 6, 0, -9 },
  { 539, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_BOLDITALIC11PT7B_H_
