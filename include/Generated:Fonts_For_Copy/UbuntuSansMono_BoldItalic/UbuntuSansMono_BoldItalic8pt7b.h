#ifndef _UBUNTUSANSMONO_BOLDITALIC8PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0x7A, 0x29, 0xBE, 0xAF, 0x50, 0x17, 0x43, 0x1E,
  0x40, 0x4D, 0x94, 0x67, 0x58, 0x35, 0x67, 0xBF, 0xE8, 0x2A, 0x49, 0x32,
  0x22, 0x13, 0x26, 0xC8, 0x5D, 0x50, 0x2F, 0x24, 0xB8, 0xE0, 0xB0, 0x18,
  0x88, 0x44, 0x22, 0x00, 0x35, 0x5B, 0x96, 0x17, 0x62, 0x2F, 0x35, 0x12,
  0x4F, 0x35, 0x17, 0x1E, 0x19, 0x95, 0x2F, 0x10, 0x3A, 0x10, 0x61, 0x70,
  0x1B, 0x19, 0xA9, 0x38, 0xF3, 0x24, 0x88, 0x32, 0xD4, 0xE9, 0x78, 0x25,
  0x57, 0x1E, 0x52, 0xC0, 0x52, 0xE0, 0x3C, 0x61, 0x78, 0xF0, 0x61, 0xE8,
  0x74, 0xE1, 0x80, 0x32, 0x6F, 0x6D, 0x59, 0x80, 0x33, 0x55, 0xF9, 0x35,
  0x57, 0x9F, 0x33, 0x51, 0x8C, 0x38, 0x65, 0x55, 0x9E, 0x7A, 0x10, 0xEC,
  0x78, 0x7A, 0x10, 0xE4, 0x40, 0x33, 0x51, 0xAD, 0x38, 0x4A, 0x55, 0xE9,
  0x58, 0x79, 0x08, 0x42, 0x78, 0x38, 0x84, 0x21, 0x70, 0x4A, 0x98, 0xCA,
  0x48, 0x64, 0x44, 0xCF, 0x4A, 0xD7, 0x69, 0x48, 0x4A, 0x5D, 0x6B, 0x48,
  0x32, 0x97, 0x29, 0x30, 0x72, 0xD6, 0xE8, 0x40, 0x32, 0x97, 0x29, 0x31,
  0x04, 0x65, 0x57, 0xA9, 0x32, 0x50, 0x61, 0x70, 0xF4, 0x44, 0x48, 0x4A,
  0xD5, 0xA9, 0x70, 0x99, 0xAA, 0xCC, 0x4A, 0x5B, 0x6F, 0x48, 0x4B, 0x8C,
  0x45, 0x48, 0x9B, 0xA4, 0x48, 0x78, 0x8C, 0xC4, 0x78, 0x39, 0x08, 0x84,
  0x23, 0x80, 0xFE, 0x71, 0x22, 0x22, 0xE0, 0x13, 0x5D, 0xF8, 0xC0, 0x7D,
  0x9F, 0x64, 0x75, 0x9E, 0x7C, 0x87, 0x08, 0x9D, 0xA9, 0x78, 0x7D, 0xA7,
  0x1C, 0x43, 0x8C, 0x20, 0x86, 0x30, 0x7D, 0x97, 0xA4, 0x64, 0x75, 0xDB,
  0x43, 0x2D, 0xC0, 0x10, 0x72, 0x22, 0xE4, 0x62, 0x54, 0xC6, 0x48, 0xC9,
  0x69, 0xC0, 0x7B, 0x99, 0x75, 0xDB, 0x79, 0x9E, 0x75, 0x9E, 0x80, 0x7D,
  0x97, 0x20, 0x74, 0x4C, 0x76, 0x3E, 0x5E, 0x4E, 0x55, 0x9F, 0xBA, 0xCC,
  0xCD, 0xBD, 0x40, 0x5B, 0x19, 0x20, 0x2C, 0xA3, 0x0C, 0xA1, 0x00, 0x72,
  0x4F, 0x74, 0x48, 0x88, 0xC0, 0x69, 0x2D, 0x20, 0x72, 0x23, 0x24, 0xC0,
  0xF0,
};

const GFXglyph UbuntuSansMono_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 6, 4, 1, -6 },
  { 4, 4, 2, 4, 1, -6 },
  { 5, 5, 6, 4, 0, -6 },
  { 9, 4, 7, 4, 0, -6 },
  { 13, 5, 6, 4, 0, -6 },
  { 17, 4, 6, 4, 0, -6 },
  { 20, 2, 3, 4, 2, -6 },
  { 21, 3, 8, 4, 1, -6 },
  { 24, 4, 8, 4, 0, -6 },
  { 28, 3, 4, 4, 1, -6 },
  { 30, 4, 4, 4, 0, -4 },
  { 32, 2, 3, 4, 1, -2 },
  { 33, 3, 1, 4, 1, -3 },
  { 34, 2, 2, 4, 1, -2 },
  { 35, 5, 7, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 5, 6, 4, 0, -6 },
  { 56, 5, 6, 4, 0, -6 },
  { 60, 5, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 1, -6 },
  { 67, 5, 6, 4, 0, -6 },
  { 71, 4, 6, 4, 0, -6 },
  { 74, 2, 5, 4, 1, -5 },
  { 76, 2, 6, 4, 1, -5 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 3, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 5, 7, 4, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 5, 6, 4, 0, -6 },
  { 102, 4, 6, 4, 0, -6 },
  { 105, 5, 6, 4, 0, -6 },
  { 109, 5, 6, 4, 0, -6 },
  { 113, 5, 6, 4, 0, -6 },
  { 117, 5, 6, 4, 0, -6 },
  { 121, 5, 6, 4, 0, -6 },
  { 125, 5, 6, 4, 0, -6 },
  { 129, 5, 6, 4, 0, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 5, 6, 4, 0, -6 },
  { 140, 5, 6, 4, 0, -6 },
  { 144, 5, 6, 4, 0, -6 },
  { 148, 5, 6, 4, 0, -6 },
  { 152, 5, 8, 4, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 5, 6, 4, 0, -6 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 5, 6, 4, 0, -6 },
  { 178, 5, 6, 4, 0, -6 },
  { 182, 4, 6, 4, 1, -6 },
  { 185, 5, 6, 4, 0, -6 },
  { 189, 5, 7, 4, 0, -6 },
  { 194, 1, 7, 4, 2, -6 },
  { 195, 4, 7, 4, 0, -6 },
  { 199, 4, 4, 4, 0, -6 },
  { 201, 5, 1, 4, -1, 0 },
  { 202, 2, 1, 4, 2, -6 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 6, 4, 0, -6 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 5, 6, 4, 0, -6 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 6, 8, 4, -1, -6 },
  { 222, 4, 6, 4, 0, -4 },
  { 225, 4, 6, 4, 0, -6 },
  { 228, 3, 6, 4, 1, -6 },
  { 231, 4, 8, 4, 0, -6 },
  { 235, 5, 6, 4, 0, -6 },
  { 239, 3, 6, 4, 1, -6 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 4, 4, 4, 0, -4 },
  { 248, 4, 5, 4, 0, -4 },
  { 251, 4, 5, 4, 0, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 4, 4, 4, 0, -4 },
  { 258, 3, 5, 4, 1, -5 },
  { 260, 4, 4, 4, 0, -4 },
  { 262, 4, 4, 4, 1, -4 },
  { 264, 5, 4, 4, 0, -4 },
  { 267, 5, 4, 4, 0, -4 },
  { 270, 6, 6, 4, -1, -4 },
  { 275, 4, 4, 4, 0, -4 },
  { 277, 4, 7, 4, 1, -6 },
  { 281, 3, 7, 4, 1, -6 },
  { 284, 4, 7, 4, 0, -6 },
  { 288, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_BOLDITALIC8PT7B_H_
