#ifndef _UBUNTUSANSMONO_BOLDITALIC7PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF4, 0x3F, 0x6F, 0xC0, 0x34, 0x62, 0xE4, 0x5E, 0x88,
  0xEB, 0x00, 0x66, 0x5A, 0xF0, 0xC0, 0x2A, 0x49, 0x30, 0x2C, 0x92, 0xB0,
  0x5F, 0x80, 0x2B, 0x44, 0x70, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x75, 0xB9,
  0xE0, 0x2C, 0x9E, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x13, 0x6F, 0x20,
  0x74, 0x62, 0xE0, 0x34, 0xE9, 0x60, 0xE5, 0x48, 0x75, 0x69, 0xE0, 0x65,
  0x72, 0xC0, 0x48, 0x21, 0x60, 0x1E, 0x62, 0xFF, 0x43, 0x68, 0xE7, 0x08,
  0x75, 0xFD, 0xA6, 0x2D, 0xFA, 0x75, 0x69, 0xE0, 0x34, 0x88, 0x60, 0x65,
  0x5B, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x78, 0x80, 0x34, 0x99, 0x60, 0x55,
  0x79, 0xA0, 0x72, 0x24, 0xE0, 0x71, 0x12, 0xE0, 0x56, 0x4A, 0xA0, 0x49,
  0x4E, 0x55, 0xB9, 0xA0, 0x55, 0xBA, 0xA0, 0x75, 0x99, 0xE0, 0x75, 0x78,
  0x80, 0x75, 0x99, 0xE6, 0x75, 0x6A, 0xA0, 0x74, 0x62, 0xE0, 0xE9, 0x48,
  0x55, 0x9A, 0xE0, 0xBA, 0xCC, 0x80, 0x55, 0xBF, 0xA0, 0x56, 0x26, 0xA0,
  0xBA, 0xC8, 0x80, 0x73, 0x24, 0xE0, 0x32, 0x44, 0x4E, 0xA5, 0x50, 0x72,
  0x22, 0x4C, 0x25, 0x90, 0xF0, 0x80, 0x7D, 0xAE, 0x46, 0x59, 0xE0, 0x34,
  0x86, 0x17, 0xDA, 0xE0, 0x69, 0xE6, 0x19, 0xC8, 0x42, 0x70, 0x7D, 0xA6,
  0xE0, 0x46, 0x5A, 0xA0, 0x5E, 0xB0, 0x12, 0x62, 0x22, 0xC0, 0x45, 0x6A,
  0xA0, 0xDA, 0xC0, 0x7B, 0xDA, 0x65, 0xAA, 0x69, 0x9E, 0x65, 0x9E, 0x80,
  0x75, 0xAE, 0x20, 0x74, 0x48, 0x74, 0x2E, 0x5E, 0x4C, 0x55, 0xAE, 0xB7,
  0x40, 0x9B, 0xFA, 0x56, 0x6A, 0x29, 0x4C, 0x4E, 0x00, 0x72, 0x4E, 0x32,
  0x4C, 0x46, 0x56, 0xA0, 0x62, 0x32, 0x4C, 0x5A,
};

const GFXglyph UbuntuSansMono_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 6, 4, 0, -5 },
  { 10, 5, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 3, 7, 4, 1, -6 },
  { 21, 3, 7, 4, 0, -6 },
  { 24, 3, 3, 4, 1, -5 },
  { 26, 4, 4, 4, 0, -4 },
  { 28, 2, 2, 4, 0, -1 },
  { 29, 2, 1, 4, 1, -3 },
  { 30, 1, 1, 4, 1, -1 },
  { 31, 4, 6, 4, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 3, 5, 4, 1, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 3, 4, 1, -3 },
  { 63, 3, 4, 4, 0, -3 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 2, 4, 0, -3 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 4, 6, 4, 0, -5 },
  { 75, 3, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 3, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 6, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 1, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 4, 5, 4, 1, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 4, 6, 4, 0, -5 },
  { 153, 2, 6, 4, 1, -5 },
  { 155, 4, 6, 4, 0, -5 },
  { 158, 4, 3, 4, 0, -5 },
  { 160, 4, 1, 4, -1, 0 },
  { 161, 1, 1, 4, 2, -5 },
  { 162, 4, 4, 4, 0, -4 },
  { 164, 4, 5, 4, 0, -5 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 4, 5, 4, 0, -5 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 5, 6, 4, -1, -5 },
  { 178, 4, 5, 4, 0, -4 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 2, 6, 4, 1, -6 },
  { 186, 4, 7, 4, 0, -6 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 2, 5, 4, 1, -5 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 5, 4, 0, -4 },
  { 204, 4, 5, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 3, 5, 4, 1, -5 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 3, 4, 4, 1, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 5, 5, 4, -1, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 6, 4, 0, -5 },
  { 230, 2, 6, 4, 1, -5 },
  { 232, 4, 6, 4, 0, -5 },
  { 235, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_BOLDITALIC7PT7B_H_
