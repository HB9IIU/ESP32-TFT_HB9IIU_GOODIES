#ifndef _UBUNTUSANSMONO_BOLDITALIC72PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8,
  0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xE3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x04, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x60, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0x80, 0x00, 0x1F, 0xFC,
  0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC3, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x01, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xF3, 0xFC,
  0x3F, 0xE0, 0xFF, 0xCF, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xF8, 0x03,
  0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xC3,
  0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x38, 0x0F, 0xE0, 0x18,
  0x3F, 0x07, 0xF0, 0x3E, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF9, 0xFC, 0xFF,
  0x8F, 0xFE, 0x7C, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x07, 0xC0,
  0xFF, 0x9F, 0xF0, 0x7F, 0x07, 0xFC, 0xFF, 0x87, 0xF8, 0x3F, 0xEF, 0xFC,
  0x3F, 0xC3, 0xFF, 0x7F, 0xC3, 0xFE, 0x1F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x9F, 0xF0, 0xFF, 0x87, 0xFD, 0xFF, 0x87, 0xF8, 0x3F, 0xEF, 0xFC, 0x3F,
  0xC3, 0xFF, 0x7F, 0xC0, 0xFC, 0x1F, 0xF3, 0xFE, 0x01, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x9F,
  0xF8, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0xE0, 0x3F,
  0xF0, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFB, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x1F, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3C, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x03,
  0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0x81, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xC0, 0xFF,
  0x81, 0xFF, 0x0F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x87, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFC,
  0x1F, 0xE0, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xFE,
  0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x30, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x10, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xC0, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0x81, 0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x0F, 0xFF, 0xC0, 0x03, 0xFD,
  0xF8, 0x3F, 0x7F, 0x00, 0x0F, 0xF7, 0xE1, 0xFD, 0xFC, 0x00, 0x3F, 0x9F,
  0x87, 0xE7, 0xF0, 0x01, 0xFE, 0x7E, 0x3F, 0xBF, 0xC0, 0x07, 0xF9, 0xF8,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xE7, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0x9F,
  0x8F, 0xE0, 0x03, 0xFC, 0x7E, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFB, 0xF1,
  0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x00, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF7, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0xFF,
  0x80, 0x07, 0xFD, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xF1, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x8F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x00, 0x7F,
  0xC1, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xE7, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFB,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xDF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xC0,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x87, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0xF8, 0x7F, 0x80, 0x0F, 0xE3, 0xF7, 0xE3, 0xFC, 0x00, 0x7F,
  0x8F, 0xDF, 0x8F, 0xF0, 0x01, 0xFE, 0x7E, 0x3E, 0x3F, 0xC0, 0x07, 0xF9,
  0xF8, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x0F, 0xDF, 0xE0, 0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x0F, 0xF7, 0xE0,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0x10, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x07,
  0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0E,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x01, 0xFF, 0xF8, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFF, 0x83, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xE7,
  0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0C, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x30, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x0E, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x3F, 0xF1, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF0,
  0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x7F, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0C, 0x00, 0x01,
  0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x40, 0x1F, 0xFE, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0x07,
  0xF0, 0x1F, 0xE1, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xDF, 0x9F, 0xE0, 0x1F, 0xC7,
  0xE7, 0xE7, 0xF0, 0x07, 0xF3, 0xF9, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x7E,
  0xFF, 0x00, 0x7F, 0x7F, 0x1F, 0xBF, 0x80, 0x1F, 0x9F, 0x87, 0xEF, 0xE0,
  0x0F, 0xEF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFE,
  0x00, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 23, 51, 40, 10, -50 },
  { 148, 29, 23, 40, 13, -55 },
  { 232, 43, 50, 40, 0, -50 },
  { 501, 39, 64, 40, 1, -56 },
  { 813, 49, 52, 40, -3, -51 },
  { 1132, 38, 52, 40, 1, -51 },
  { 1379, 13, 24, 40, 20, -55 },
  { 1418, 32, 71, 40, 8, -57 },
  { 1702, 33, 71, 40, 0, -57 },
  { 1995, 33, 32, 40, 7, -50 },
  { 2127, 36, 36, 40, 2, -39 },
  { 2289, 19, 25, 40, 5, -13 },
  { 2349, 25, 10, 40, 8, -26 },
  { 2381, 14, 14, 40, 10, -13 },
  { 2406, 48, 69, 40, -4, -56 },
  { 2820, 37, 52, 40, 3, -51 },
  { 3061, 32, 50, 40, 2, -50 },
  { 3261, 40, 51, 40, 0, -51 },
  { 3516, 40, 52, 40, -1, -51 },
  { 3776, 41, 50, 40, 0, -50 },
  { 4033, 42, 51, 40, 0, -50 },
  { 4301, 39, 51, 40, 3, -50 },
  { 4550, 39, 50, 40, 6, -50 },
  { 4794, 39, 52, 40, 2, -51 },
  { 5048, 39, 51, 40, 1, -51 },
  { 5297, 20, 38, 40, 10, -37 },
  { 5392, 25, 49, 40, 5, -37 },
  { 5546, 37, 34, 40, 3, -38 },
  { 5704, 39, 24, 40, 1, -33 },
  { 5821, 37, 34, 40, 1, -38 },
  { 5979, 31, 52, 40, 9, -51 },
  { 6181, 41, 62, 40, 1, -51 },
  { 6499, 39, 50, 40, -4, -50 },
  { 6743, 40, 51, 40, 0, -50 },
  { 6998, 39, 52, 40, 4, -51 },
  { 7252, 41, 51, 40, -1, -50 },
  { 7514, 42, 50, 40, 1, -50 },
  { 7777, 42, 50, 40, 2, -50 },
  { 8040, 40, 52, 40, 3, -51 },
  { 8300, 45, 50, 40, -1, -50 },
  { 8582, 43, 50, 40, 0, -50 },
  { 8851, 42, 51, 40, 0, -50 },
  { 9119, 47, 50, 40, -1, -50 },
  { 9413, 32, 50, 40, 1, -50 },
  { 9613, 46, 50, 40, -3, -50 },
  { 9901, 45, 50, 40, -1, -50 },
  { 10183, 39, 52, 40, 2, -51 },
  { 10437, 42, 50, 40, 0, -50 },
  { 10700, 38, 65, 40, 2, -51 },
  { 11009, 40, 50, 40, 0, -50 },
  { 11259, 42, 52, 40, -1, -51 },
  { 11532, 39, 50, 40, 7, -50 },
  { 11776, 42, 51, 40, 2, -50 },
  { 12044, 39, 50, 40, 8, -50 },
  { 12288, 46, 50, 40, 0, -50 },
  { 12576, 49, 50, 40, -3, -50 },
  { 12883, 39, 50, 40, 8, -50 },
  { 13127, 44, 50, 40, -1, -50 },
  { 13402, 39, 69, 40, 4, -56 },
  { 13739, 16, 69, 40, 14, -56 },
  { 13877, 39, 69, 40, -2, -56 },
  { 14214, 37, 29, 40, 3, -50 },
  { 14349, 38, 8, 40, -6, 5 },
  { 14387, 18, 15, 40, 16, -56 },
  { 14421, 37, 40, 40, 2, -39 },
  { 14606, 37, 57, 40, 0, -56 },
  { 14870, 37, 40, 40, 3, -39 },
  { 15055, 42, 57, 40, 2, -56 },
  { 15355, 36, 40, 40, 3, -39 },
  { 15535, 51, 70, 40, -6, -56 },
  { 15982, 43, 53, 40, -3, -39 },
  { 16267, 37, 56, 40, 0, -56 },
  { 16526, 28, 58, 40, 6, -57 },
  { 16729, 41, 71, 40, -4, -57 },
  { 17093, 42, 56, 40, 1, -56 },
  { 17387, 25, 57, 40, 9, -56 },
  { 17566, 41, 38, 40, -1, -38 },
  { 17761, 37, 39, 40, 0, -39 },
  { 17942, 36, 40, 40, 2, -39 },
  { 18122, 41, 52, 40, -3, -39 },
  { 18389, 37, 52, 40, 3, -39 },
  { 18630, 37, 39, 40, 3, -39 },
  { 18811, 37, 40, 40, 1, -39 },
  { 18996, 34, 50, 40, 6, -49 },
  { 19209, 36, 39, 40, 3, -38 },
  { 19385, 36, 38, 40, 6, -38 },
  { 19556, 42, 38, 40, 2, -38 },
  { 19756, 43, 38, 40, -2, -38 },
  { 19961, 47, 52, 40, -6, -38 },
  { 20267, 39, 38, 40, 1, -38 },
  { 20453, 39, 69, 40, 5, -56 },
  { 20790, 27, 69, 40, 7, -56 },
  { 21023, 39, 69, 40, -3, -56 },
  { 21360, 39, 15, 40, 1, -29 },
};

const GFXfont UbuntuSansMono_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic72pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _UBUNTUSANSMONO_BOLDITALIC72PT7B_H_
