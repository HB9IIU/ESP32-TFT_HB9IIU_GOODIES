#ifndef _UBUNTUSANSMONO_BOLDITALIC22PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x00, 0x03, 0x0F,
  0x1E, 0x3C, 0x00, 0x73, 0xFB, 0xB9, 0xDC, 0xEE, 0x76, 0x33, 0x18, 0x03,
  0x38, 0x39, 0x81, 0x9C, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0x73, 0x03, 0x38,
  0x39, 0x87, 0xFF, 0xBF, 0xF8, 0xE6, 0x06, 0x70, 0x73, 0x03, 0xB8, 0x00,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0x1F, 0xF1, 0xC0, 0x3C, 0x01, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xE4, 0x1E, 0x7F, 0xCF, 0xF8,
  0x3E, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x1E, 0x1C, 0x6C, 0x70, 0xD8,
  0xC3, 0x33, 0x06, 0x6C, 0x0F, 0xB0, 0x0E, 0xC0, 0x03, 0x80, 0x06, 0xE0,
  0x1B, 0xE0, 0x66, 0xC1, 0x99, 0x86, 0x33, 0x1C, 0x7C, 0x70, 0x70, 0x01,
  0x80, 0x7C, 0x0F, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x1F, 0x80, 0xF0, 0x1E,
  0x33, 0xF7, 0x67, 0x6E, 0x3E, 0xE1, 0xCE, 0x3C, 0x7F, 0xE7, 0xEE, 0x77,
  0xFE, 0xEE, 0xCC, 0x00, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x40, 0x00, 0x0E, 0x03, 0x06,
  0xCF, 0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x33, 0x00, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x0F, 0xFF, 0xFF, 0xBF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x1C, 0xF3, 0xCF, 0x0C, 0xEF, 0x10, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x0E, 0xE1, 0xD9, 0x3F, 0x77,
  0xEE, 0xFC, 0x9F, 0x83, 0x70, 0xEE, 0x3D, 0xCF, 0x1F, 0xC3, 0xF0, 0x03,
  0xC1, 0xE1, 0xF9, 0xFE, 0x37, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0xFF, 0xFF, 0xEF, 0xF8, 0x01, 0x80, 0xFE, 0x1F, 0xF1, 0x87,
  0x10, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0xFE, 0xFF, 0xCF, 0xFC, 0x03, 0x81, 0xFE, 0x0F, 0xF0, 0x87,
  0x00, 0x70, 0x07, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE4, 0x3C, 0xFF, 0xCF, 0xF0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x37,
  0x06, 0xE0, 0xCE, 0x18, 0xE3, 0x8E, 0x70, 0xC7, 0xFF, 0xFF, 0xF0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x07, 0xF8, 0x7F, 0x83, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x7E, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC4, 0x3C, 0x7F, 0xE3, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0x1F, 0x03, 0xC0,
  0x70, 0x07, 0x30, 0xFF, 0x8F, 0xFC, 0xE1, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C,
  0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xF7, 0xFE, 0x81, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x00, 0x03, 0x03, 0xF8, 0x7F, 0x9C, 0x73, 0x86, 0x71,
  0xCE, 0x70, 0xFC, 0x3F, 0x0E, 0x73, 0x87, 0x70, 0xEC, 0x1D, 0xC7, 0xBF,
  0xE3, 0xF8, 0x03, 0x00, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x87, 0x3F, 0xF1, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0xC1, 0xF8, 0x7F,
  0x0F, 0x80, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x1C, 0xF3, 0xCF, 0x00, 0x07,
  0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x3C, 0x3C, 0x0C, 0x38,
  0xF0, 0x40, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xE7, 0xE1, 0xE0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x70, 0x02, 0x00, 0x3F, 0xF3, 0xFF, 0x40, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x10, 0x03, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0E, 0x07, 0xE3, 0xFC, 0xFE, 0x0F, 0x00, 0x40, 0x00, 0x0C, 0x3F,
  0x9F, 0xE8, 0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x06,
  0x07, 0x83, 0xC1, 0xC0, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x38, 0x73, 0x83,
  0x98, 0xFD, 0xCF, 0xEC, 0xFE, 0x66, 0x73, 0x73, 0x9B, 0x9D, 0xDC, 0xCE,
  0xE6, 0x73, 0xF1, 0x9F, 0x8C, 0x00, 0x70, 0x01, 0xFC, 0x07, 0xE0, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x67, 0x0E, 0x70, 0xC7, 0x1C,
  0x71, 0xFF, 0x3F, 0xF3, 0x07, 0x70, 0x77, 0x07, 0xE0, 0x70, 0x1F, 0xE1,
  0xFF, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x8F, 0x3F, 0xC3, 0xFC, 0x30, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x73, 0xEF, 0xFC, 0xFF, 0x00, 0x01, 0xC0, 0x7F,
  0x1F, 0xF3, 0xC2, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x88, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE,
  0x1C, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x0E,
  0x70, 0xE7, 0x1C, 0xE7, 0xCF, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC7,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0x87, 0xF8, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC7, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0x87, 0xFC, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0xFF, 0x1F, 0xF3, 0xC2, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0xEE,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x38, 0x7F, 0x83, 0xF8, 0x1C, 0x3C,
  0x70, 0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x07, 0xFC, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x83, 0x86, 0x78, 0x7F,
  0xC1, 0xFC, 0x00, 0x1E, 0x3C, 0x71, 0xE1, 0xCF, 0x07, 0x38, 0x39, 0xC0,
  0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0x70,
  0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x00, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x7F, 0xDF, 0xFF,
  0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xF3, 0xC7, 0xCB, 0x1B, 0x7C, 0x6D, 0x61,
  0xBD, 0x8E, 0xE6, 0x3B, 0xB8, 0xCC, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x71,
  0x81, 0xCE, 0x07, 0x00, 0x1C, 0x18, 0xE1, 0xC7, 0x8E, 0x7C, 0x73, 0xE3,
  0x1F, 0xB8, 0xCD, 0xC6, 0x6E, 0x73, 0x63, 0x9F, 0x18, 0x78, 0xC3, 0xCE,
  0x1C, 0x70, 0xE3, 0x87, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x8E,
  0xE1, 0xDC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xEE, 0x3D, 0xEF,
  0x3F, 0xC3, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x9C,
  0x3C, 0xE1, 0xC7, 0xFE, 0x3F, 0xC3, 0xF8, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x8E, 0xE1,
  0xDC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x3D, 0xEF, 0x3F,
  0xC3, 0xF0, 0x38, 0x03, 0x80, 0x7C, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x1C,
  0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xE3, 0xFE, 0x7F, 0x87, 0x38, 0x73,
  0x87, 0x1C, 0xF1, 0xCE, 0x1C, 0xE0, 0xE0, 0x01, 0xC0, 0x7F, 0xC7, 0xFC,
  0x38, 0x41, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x31, 0xE3, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x00, 0x38, 0x73, 0x87, 0x38,
  0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x38, 0xE7, 0x8F, 0xF0, 0x7E, 0x00, 0xF0, 0x7F, 0x0F, 0xE0, 0xEE,
  0x0E, 0xE1, 0xC6, 0x1C, 0x63, 0x86, 0x38, 0x67, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E,
  0x0E, 0x30, 0x38, 0xCC, 0xE7, 0x73, 0x1D, 0xCC, 0x6D, 0x71, 0xB5, 0x87,
  0x9E, 0x1E, 0x78, 0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x00, 0x0E, 0x1E, 0x1E,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x03, 0x8E, 0x0F, 0x0E, 0x3C,
  0x1C, 0x00, 0xE0, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x70, 0xCE, 0x1F, 0x83,
  0xE0, 0x78, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xF0, 0xFE, 0x00, 0xE7, 0x39, 0xC6, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0x80, 0xF0, 0x3F, 0x0E, 0xE3,
  0xDC, 0xF1, 0xDC, 0x3F, 0x07, 0x20, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0,
  0x47, 0xBE, 0x70, 0x80, 0x07, 0xC3, 0xFC, 0xFF, 0xB8, 0xEE, 0x1D, 0xC3,
  0xB8, 0x77, 0x1C, 0xE3, 0x9C, 0xF3, 0xFE, 0x3E, 0xE0, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x0F, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xE3,
  0xB8, 0x77, 0x0E, 0xE3, 0xDC, 0xF7, 0xFC, 0xFF, 0x00, 0x07, 0xC3, 0xFC,
  0xFF, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0x31, 0xFE,
  0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x7E, 0x1F,
  0xE3, 0xFE, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7,
  0x8F, 0xF8, 0x7D, 0xC0, 0x07, 0x83, 0xF8, 0xFF, 0xB8, 0x7E, 0x0F, 0xC7,
  0xBF, 0xE7, 0xF0, 0xE0, 0x1E, 0x11, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x38, 0x73, 0xC7, 0x1C,
  0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x1C,
  0x33, 0xE3, 0xFE, 0x0F, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x3F, 0x87, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0x77, 0x0E, 0xE3,
  0x9C, 0x73, 0x8E, 0xE3, 0xC0, 0x0E, 0x0E, 0x0E, 0x04, 0x00, 0xFE, 0xFC,
  0xFC, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x6F, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x1C, 0x71, 0xC3, 0x9C, 0x39, 0xC1, 0xDC, 0x0F, 0xC0,
  0x7E, 0x07, 0xB8, 0x39, 0xC1, 0xC7, 0x0E, 0x38, 0xF1, 0xE0, 0xFD, 0xFB,
  0xF0, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x3C, 0xBF,
  0x7E, 0x0E, 0x63, 0xFF, 0x3F, 0xF3, 0x33, 0x77, 0x77, 0x77, 0x66, 0x66,
  0x66, 0xE0, 0xEE, 0x0E, 0xC0, 0xCC, 0x0C, 0x0F, 0xC3, 0xFC, 0xFF, 0x9C,
  0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xC7, 0x71, 0xE0,
  0x0F, 0x07, 0xF9, 0xFF, 0x38, 0xEE, 0x1F, 0xC3, 0xB8, 0x77, 0x0E, 0xE3,
  0xDE, 0xF3, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x38, 0xE1,
  0xC3, 0x8E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xDF, 0x1F, 0xF0, 0xFF,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBC,
  0x7F, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9E, 0xF3, 0xFE, 0x3F, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xE7, 0xFC, 0xFF, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x07, 0xF1,
  0xFE, 0x1F, 0xE1, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x01, 0xC6,
  0x3C, 0x7F, 0xCF, 0xF0, 0x1E, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xF3,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x79, 0x1F, 0xC3, 0xF0, 0x38,
  0xEE, 0x1D, 0xC7, 0xB8, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x1C, 0xE3, 0x9E,
  0xF3, 0xFE, 0x3E, 0xE0, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xCE,
  0x39, 0xC7, 0x70, 0x6E, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x60, 0x3E, 0x07,
  0xE0, 0x7E, 0x66, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC, 0xF7, 0xCF, 0x78,
  0xE3, 0x8C, 0x30, 0x1C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x83, 0x8E, 0x3C, 0x3C,
  0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03,
  0x9C, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x70,
  0x0B, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFC, 0x7F, 0xCF, 0xFC,
  0x03, 0xE0, 0xFC, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x1F, 0x03, 0x80, 0x78, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0x07, 0xC0, 0x7C, 0x08, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0xF8, 0x00, 0x1C, 0x23,
  0xE7, 0x7F, 0xEE, 0x7E, 0x21, 0x80,
};

const GFXglyph UbuntuSansMono_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 15, 12, 3, -15 },
  { 15, 9, 7, 12, 4, -17 },
  { 23, 13, 15, 12, 0, -15 },
  { 48, 12, 19, 12, 0, -17 },
  { 77, 15, 16, 12, -1, -16 },
  { 107, 12, 16, 12, 0, -16 },
  { 131, 4, 8, 12, 6, -17 },
  { 135, 10, 21, 12, 2, -17 },
  { 162, 10, 21, 12, 0, -17 },
  { 189, 10, 9, 12, 2, -15 },
  { 201, 11, 11, 12, 1, -12 },
  { 217, 6, 8, 12, 1, -4 },
  { 223, 7, 3, 12, 3, -8 },
  { 226, 4, 4, 12, 3, -4 },
  { 228, 14, 21, 12, -1, -17 },
  { 265, 11, 16, 12, 1, -16 },
  { 287, 10, 15, 12, 1, -15 },
  { 306, 12, 16, 12, 0, -16 },
  { 330, 12, 16, 12, 0, -16 },
  { 354, 12, 15, 12, 0, -15 },
  { 377, 13, 15, 12, 0, -15 },
  { 402, 12, 15, 12, 1, -15 },
  { 425, 12, 15, 12, 2, -15 },
  { 448, 11, 16, 12, 1, -16 },
  { 470, 12, 16, 12, 0, -16 },
  { 494, 6, 11, 12, 3, -11 },
  { 503, 8, 15, 12, 1, -11 },
  { 518, 11, 11, 12, 1, -12 },
  { 534, 12, 7, 12, 0, -10 },
  { 545, 12, 11, 12, 0, -12 },
  { 562, 9, 16, 12, 3, -16 },
  { 580, 13, 19, 12, 0, -16 },
  { 611, 12, 15, 12, -1, -15 },
  { 634, 12, 15, 12, 0, -15 },
  { 657, 12, 16, 12, 1, -16 },
  { 681, 12, 15, 12, 0, -15 },
  { 704, 13, 15, 12, 0, -15 },
  { 729, 13, 15, 12, 0, -15 },
  { 754, 12, 16, 12, 1, -16 },
  { 778, 14, 15, 12, 0, -15 },
  { 805, 13, 15, 12, 0, -15 },
  { 830, 13, 15, 12, 0, -15 },
  { 855, 14, 15, 12, 0, -15 },
  { 882, 10, 15, 12, 0, -15 },
  { 901, 14, 15, 12, -1, -15 },
  { 928, 13, 15, 12, 0, -15 },
  { 953, 11, 16, 12, 1, -16 },
  { 975, 13, 15, 12, 0, -15 },
  { 1000, 11, 20, 12, 1, -16 },
  { 1028, 12, 15, 12, 0, -15 },
  { 1051, 13, 16, 12, 0, -16 },
  { 1077, 12, 15, 12, 2, -15 },
  { 1100, 12, 15, 12, 1, -15 },
  { 1123, 12, 15, 12, 2, -15 },
  { 1146, 14, 15, 12, 0, -15 },
  { 1173, 15, 15, 12, -1, -15 },
  { 1202, 11, 15, 12, 3, -15 },
  { 1223, 13, 15, 12, 0, -15 },
  { 1248, 12, 21, 12, 1, -17 },
  { 1280, 5, 21, 12, 4, -17 },
  { 1294, 12, 21, 12, -1, -17 },
  { 1326, 11, 9, 12, 1, -15 },
  { 1339, 12, 3, 12, -2, 1 },
  { 1344, 5, 5, 12, 5, -17 },
  { 1348, 11, 12, 12, 1, -12 },
  { 1365, 11, 17, 12, 0, -17 },
  { 1389, 11, 12, 12, 1, -12 },
  { 1406, 12, 17, 12, 1, -17 },
  { 1432, 11, 12, 12, 1, -12 },
  { 1449, 16, 21, 12, -2, -17 },
  { 1491, 13, 16, 12, -1, -12 },
  { 1517, 11, 17, 12, 0, -17 },
  { 1541, 8, 17, 12, 2, -17 },
  { 1558, 12, 21, 12, -1, -17 },
  { 1590, 13, 17, 12, 0, -17 },
  { 1618, 7, 17, 12, 3, -17 },
  { 1633, 12, 12, 12, 0, -12 },
  { 1651, 11, 12, 12, 0, -12 },
  { 1668, 11, 12, 12, 1, -12 },
  { 1685, 13, 16, 12, -1, -12 },
  { 1711, 11, 16, 12, 1, -12 },
  { 1733, 11, 12, 12, 1, -12 },
  { 1750, 12, 12, 12, 0, -12 },
  { 1768, 10, 15, 12, 2, -15 },
  { 1787, 11, 12, 12, 1, -12 },
  { 1804, 11, 12, 12, 2, -12 },
  { 1821, 12, 12, 12, 1, -12 },
  { 1839, 14, 12, 12, -1, -12 },
  { 1860, 15, 16, 12, -2, -12 },
  { 1890, 12, 12, 12, 0, -12 },
  { 1908, 11, 21, 12, 2, -17 },
  { 1937, 8, 21, 12, 2, -17 },
  { 1958, 12, 21, 12, -1, -17 },
  { 1990, 12, 5, 12, 0, -9 },
};

const GFXfont UbuntuSansMono_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_BOLDITALIC22PT7B_H_
