#ifndef _UBUNTUSANSMONO_BOLDITALIC18PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0xE7, 0x39, 0x80, 0x07, 0x39, 0xC0, 0x66, 0xCF, 0xBF,
  0x7C, 0xD9, 0x80, 0x06, 0xE1, 0x98, 0x36, 0xBF, 0xE7, 0xFC, 0x36, 0x0C,
  0xC7, 0xFE, 0xFF, 0x8C, 0xC3, 0xB0, 0x66, 0x00, 0x03, 0x00, 0xC0, 0xFC,
  0x7F, 0x38, 0x4E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x39, 0x0E, 0xFF,
  0x0F, 0x01, 0x80, 0xE0, 0x0C, 0x08, 0xF1, 0x8D, 0x98, 0x6D, 0x83, 0x58,
  0x1E, 0x80, 0x4C, 0x00, 0xD8, 0x0D, 0xE0, 0xDB, 0x0C, 0xD8, 0x46, 0x8E,
  0x3C, 0x00, 0x07, 0x07, 0xE1, 0x98, 0x66, 0x3B, 0x07, 0x81, 0xCD, 0xF3,
  0x6F, 0xB1, 0xEC, 0x73, 0xFE, 0x7D, 0x80, 0x7F, 0xED, 0x80, 0x03, 0x07,
  0x1E, 0x1C, 0x38, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x30, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0xF0, 0x40, 0x18, 0x9A, 0xFF, 0xFF,
  0x3C, 0x7E, 0x66, 0x0C, 0x06, 0x03, 0x03, 0x1F, 0xF7, 0xF8, 0x60, 0x60,
  0x30, 0x00, 0x39, 0xCE, 0x3F, 0x70, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x1F, 0x8E, 0xEE, 0x36, 0x1F, 0x4F, 0x77, 0xB7, 0xC3, 0x61, 0xB1,
  0x9F, 0xC7, 0xC0, 0x0F, 0x3E, 0x7E, 0x6E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0xFF, 0xFE, 0x07, 0x07, 0xE3, 0x9C, 0x47, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x0C, 0x06, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0x07, 0xE1, 0x1C,
  0x07, 0x01, 0x83, 0xE1, 0xE0, 0x1C, 0x03, 0x80, 0xE8, 0x3B, 0xFC, 0xFE,
  0x00, 0x01, 0xC0, 0xF0, 0x78, 0x36, 0x19, 0x8C, 0xE6, 0x3B, 0xFF, 0xFF,
  0x81, 0xC0, 0x70, 0x18, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x3C, 0x0F, 0xC0,
  0x78, 0x0E, 0x03, 0xA0, 0xEF, 0xF3, 0xF8, 0x00, 0x87, 0xC7, 0xC6, 0x06,
  0x07, 0xF3, 0xFD, 0x86, 0xC3, 0x61, 0xB9, 0xDF, 0xC7, 0xC0, 0xFF, 0xFF,
  0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x00,
  0x07, 0x07, 0xF1, 0x9C, 0xE3, 0x38, 0xC7, 0xE1, 0xF0, 0xFC, 0x63, 0x98,
  0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x70, 0xDC,
  0x33, 0xFC, 0xFF, 0x01, 0x80, 0xE0, 0xF1, 0xF8, 0xF8, 0x00, 0x73, 0xDC,
  0x00, 0x03, 0x9C, 0xE0, 0x1C, 0x3C, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38,
  0x33, 0xC7, 0x00, 0x00, 0x81, 0xC7, 0xEF, 0xCF, 0x07, 0x81, 0xF0, 0x1E,
  0x02, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x20, 0x0E,
  0x07, 0xE0, 0x3F, 0x03, 0x83, 0xE7, 0xE3, 0xE0, 0xC0, 0x00, 0x1C, 0x7F,
  0x67, 0x07, 0x06, 0x1E, 0x38, 0x30, 0x40, 0x00, 0x60, 0xF0, 0x60, 0x07,
  0x81, 0xF8, 0x63, 0x18, 0x36, 0x3C, 0xCF, 0x9B, 0x32, 0x66, 0xDD, 0x9B,
  0xB3, 0x3E, 0x67, 0xC6, 0x00, 0xE0, 0x0F, 0xC0, 0x70, 0x03, 0x81, 0xE0,
  0x78, 0x3F, 0x0D, 0xC7, 0x71, 0x9C, 0xFF, 0x3F, 0xDC, 0x76, 0x1F, 0x87,
  0x0F, 0x07, 0xE1, 0x9C, 0xE3, 0x31, 0xCD, 0xE3, 0xF1, 0xFE, 0x61, 0x98,
  0x66, 0x3B, 0xFC, 0xFE, 0x00, 0x07, 0x07, 0xF3, 0xC9, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x11, 0xF8, 0x7F, 0x00, 0x0E, 0x07,
  0xE3, 0xF8, 0xE7, 0x31, 0xCC, 0x77, 0x1D, 0xC7, 0x61, 0x98, 0xEE, 0x73,
  0xF8, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x60, 0x1C, 0x03, 0xF8, 0x7F, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x60,
  0x1C, 0x03, 0x80, 0x7F, 0x0F, 0xE3, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x00, 0x07, 0x07, 0xF3, 0xC9, 0xC0, 0x60, 0x38, 0x0E, 0x3B, 0x0C, 0xC3,
  0x31, 0xCE, 0x73, 0xF8, 0x7E, 0x00, 0x18, 0xE7, 0x1C, 0xE3, 0x18, 0x63,
  0xFC, 0xFF, 0x9C, 0x63, 0x0C, 0x63, 0x9C, 0x73, 0x8C, 0x61, 0x80, 0x1F,
  0xE7, 0xF8, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x83, 0xFC, 0x7F, 0x80, 0x0F, 0xC7, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x11, 0xCF, 0xE1, 0xF0, 0x18, 0xE7, 0x38, 0xEE, 0x1B,
  0x83, 0xE0, 0xF8, 0x1F, 0x83, 0x30, 0x67, 0x1C, 0x63, 0x8E, 0x61, 0xC0,
  0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xFF, 0xFF,
  0x0C, 0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x37, 0xE3, 0x76, 0x37, 0x63, 0x6C,
  0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x1C, 0x18, 0x67, 0x1C, 0xF3, 0x1E, 0x63,
  0xCC, 0xEF, 0x99, 0xE3, 0x3C, 0x67, 0x9C, 0x73, 0x0C, 0x61, 0x80, 0x0E,
  0x1F, 0x8E, 0xEE, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0x63, 0xB1, 0xDF,
  0xC7, 0xC0, 0x0F, 0x07, 0xF1, 0xFC, 0xE3, 0x38, 0xCC, 0x33, 0x3D, 0xFE,
  0x7C, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x1F, 0x8E, 0xEE, 0x36,
  0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0x63, 0xB1, 0xDF, 0xC7, 0xC1, 0x80, 0xE8,
  0x38, 0x0E, 0x07, 0xE3, 0xBC, 0xE7, 0x31, 0xCC, 0x77, 0xF9, 0xFC, 0x66,
  0x19, 0xC6, 0x33, 0x8C, 0xC3, 0x80, 0x07, 0x87, 0xF3, 0x8C, 0xE0, 0x38,
  0x0F, 0x01, 0xF0, 0x1C, 0x03, 0x80, 0xE4, 0x3B, 0xFC, 0xFE, 0x00, 0xFF,
  0xFF, 0xC6, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C,
  0x00, 0x71, 0xDC, 0x66, 0x19, 0x8E, 0xE3, 0xB8, 0xCC, 0x33, 0x1C, 0xC7,
  0x31, 0x8F, 0xE1, 0xF0, 0xE1, 0xF8, 0xEC, 0x33, 0x1C, 0xC6, 0x31, 0x8C,
  0xC3, 0xB0, 0xF8, 0x3E, 0x0F, 0x01, 0xC0, 0x38, 0x73, 0x06, 0x30, 0x63,
  0x0C, 0x66, 0xC6, 0xEC, 0x6E, 0xC7, 0xF8, 0x57, 0x8F, 0x38, 0xE3, 0x0E,
  0x30, 0x1C, 0x78, 0x73, 0x03, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xF0, 0x1D, 0x81, 0xCC, 0x1C, 0x71, 0xC3, 0x80, 0xE3, 0xF8, 0xC6,
  0x71, 0x98, 0x6C, 0x1F, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x1F, 0xE7, 0xF8, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x13, 0xFC, 0x7F, 0x80, 0x0F, 0xC3, 0xE0, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0xF0, 0xFC, 0x00, 0xE6, 0x66, 0x66, 0x66, 0x77, 0x77, 0x33, 0x33, 0x30,
  0x0F, 0x8F, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x71, 0xF8, 0xF8, 0x00, 0x0E, 0x0F, 0x8F, 0xC6,
  0x66, 0x3F, 0x1D, 0x04, 0xFF, 0xFF, 0xC0, 0x4E, 0x71, 0x0E, 0x1F, 0xDC,
  0xDC, 0x6C, 0x36, 0x3B, 0x1D, 0x8C, 0xFE, 0x3F, 0x80, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0xE1, 0xFC, 0xEE, 0x63, 0x71, 0xB8, 0xD8, 0xEC, 0x7F, 0xF7,
  0xF0, 0x0F, 0x1F, 0xDE, 0x5C, 0x0E, 0x06, 0x03, 0x01, 0xC0, 0xFE, 0x3F,
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x0F, 0x8F, 0xE7, 0x33, 0x8C, 0xC3,
  0x31, 0xCC, 0x73, 0x18, 0xFE, 0x1F, 0xC0, 0x0E, 0x1F, 0x9C, 0xFC, 0x7C,
  0x77, 0xF3, 0xC1, 0x80, 0xFE, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0x03, 0x00,
  0x70, 0x07, 0x01, 0xFE, 0x1F, 0xE0, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC1, 0xFC,
  0x73, 0x9C, 0x63, 0x0C, 0x63, 0x8C, 0x71, 0xFC, 0x1F, 0x80, 0x70, 0x0E,
  0x3F, 0x8F, 0xE0, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0xF1, 0xFC, 0xEE, 0x63,
  0x71, 0xB9, 0xD8, 0xEC, 0x6E, 0x37, 0x38, 0x0E, 0x0E, 0x0C, 0x00, 0x00,
  0x7C, 0xFC, 0x18, 0x18, 0x38, 0x38, 0x38, 0x3E, 0x1F, 0x00, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x61, 0xF8, 0xFC, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x82, 0x73, 0x8E, 0xE1, 0xB8, 0x3E, 0x0F, 0xC1, 0xD8, 0x33, 0x86,
  0x31, 0xC7, 0x00, 0x7F, 0xE1, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18,
  0x7D, 0xF0, 0x19, 0x8F, 0xF6, 0x6D, 0x93, 0x6C, 0xDB, 0x66, 0x1B, 0x06,
  0xC1, 0xB0, 0xC0, 0x0F, 0x1F, 0xCE, 0xE6, 0x37, 0x1B, 0x9D, 0x8E, 0xC6,
  0xE3, 0x73, 0x80, 0x0C, 0x3F, 0x77, 0xE3, 0xC3, 0xC3, 0xC7, 0xC7, 0xFE,
  0x7C, 0x07, 0x07, 0xF1, 0x9C, 0x63, 0x38, 0xCE, 0x33, 0x1C, 0xCE, 0x7F,
  0x9F, 0x86, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x1F, 0xDE, 0xFC, 0x6C, 0x36,
  0x3B, 0x1D, 0x8C, 0xFE, 0x3F, 0x03, 0x81, 0x80, 0xC0, 0x0F, 0x1F, 0xDF,
  0xCE, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x0F, 0x0F, 0xCE,
  0x27, 0x03, 0xC0, 0xF8, 0x1C, 0x86, 0x7F, 0x7F, 0x00, 0x1C, 0x0E, 0x06,
  0x0F, 0xFF, 0xF1, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1F, 0x87, 0xC0, 0x73,
  0xB1, 0xB8, 0xDC, 0xEC, 0x76, 0x33, 0x19, 0xFC, 0xFF, 0x00, 0xE3, 0xB1,
  0xD8, 0xCC, 0xE6, 0x63, 0x61, 0xF0, 0xF0, 0x30, 0x00, 0xC1, 0xF3, 0x6D,
  0xDB, 0x76, 0xFF, 0x2F, 0xCE, 0xE3, 0x38, 0xCE, 0x00, 0x38, 0xE3, 0xB8,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xE1, 0x8C, 0xF1, 0xC0, 0x0C, 0x70,
  0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x7C, 0x0F, 0x80, 0x3F, 0xCF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xC1, 0xF0, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0xE0, 0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xF0,
  0x3C, 0x00, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC7, 0x1C, 0x61,
  0x8E, 0x38, 0xC0, 0x0F, 0x03, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0xC1, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC1, 0xF0, 0xF8,
  0x00, 0x38, 0xDF, 0xEC, 0xF8, 0x08,
};

const GFXglyph UbuntuSansMono_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 7, 6, 10, 3, -14 },
  { 15, 11, 12, 10, 0, -12 },
  { 32, 10, 16, 10, 0, -14 },
  { 52, 13, 13, 10, -1, -13 },
  { 74, 10, 13, 10, 0, -13 },
  { 91, 3, 6, 10, 5, -14 },
  { 94, 8, 17, 10, 2, -14 },
  { 111, 8, 17, 10, 0, -14 },
  { 128, 8, 7, 10, 2, -12 },
  { 135, 9, 9, 10, 1, -10 },
  { 146, 5, 6, 10, 1, -3 },
  { 150, 6, 2, 10, 2, -6 },
  { 152, 3, 3, 10, 3, -3 },
  { 154, 12, 17, 10, -1, -14 },
  { 180, 9, 13, 10, 1, -13 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 10, 13, 10, 0, -13 },
  { 224, 10, 13, 10, 0, -13 },
  { 241, 10, 12, 10, 0, -12 },
  { 256, 10, 12, 10, 0, -12 },
  { 271, 9, 13, 10, 1, -13 },
  { 286, 9, 12, 10, 2, -12 },
  { 300, 10, 13, 10, 0, -13 },
  { 317, 10, 13, 10, 0, -13 },
  { 334, 5, 9, 10, 3, -9 },
  { 340, 7, 12, 10, 1, -9 },
  { 351, 9, 9, 10, 1, -10 },
  { 362, 10, 6, 10, 0, -8 },
  { 370, 10, 9, 10, 0, -10 },
  { 382, 8, 13, 10, 2, -13 },
  { 395, 11, 16, 10, 0, -13 },
  { 417, 10, 12, 10, -1, -12 },
  { 432, 10, 13, 10, 0, -13 },
  { 449, 10, 13, 10, 1, -13 },
  { 466, 10, 13, 10, 0, -13 },
  { 483, 11, 12, 10, 0, -12 },
  { 500, 11, 12, 10, 0, -12 },
  { 517, 10, 13, 10, 1, -13 },
  { 534, 11, 12, 10, 0, -12 },
  { 551, 11, 12, 10, 0, -12 },
  { 568, 10, 12, 10, 0, -12 },
  { 583, 11, 12, 10, 0, -12 },
  { 600, 8, 12, 10, 0, -12 },
  { 612, 12, 12, 10, -1, -12 },
  { 630, 11, 12, 10, 0, -12 },
  { 647, 9, 13, 10, 1, -13 },
  { 662, 10, 13, 10, 0, -13 },
  { 679, 9, 16, 10, 1, -13 },
  { 697, 10, 13, 10, 0, -13 },
  { 714, 10, 13, 10, 0, -13 },
  { 731, 9, 12, 10, 2, -12 },
  { 745, 10, 12, 10, 1, -12 },
  { 760, 10, 12, 10, 2, -12 },
  { 775, 12, 12, 10, 0, -12 },
  { 793, 13, 12, 10, -1, -12 },
  { 813, 10, 12, 10, 2, -12 },
  { 828, 11, 12, 10, 0, -12 },
  { 845, 10, 17, 10, 1, -14 },
  { 867, 4, 17, 10, 3, -14 },
  { 876, 9, 17, 10, 0, -14 },
  { 896, 9, 7, 10, 1, -12 },
  { 904, 9, 2, 10, -1, 1 },
  { 907, 4, 4, 10, 4, -14 },
  { 909, 9, 10, 10, 1, -10 },
  { 921, 9, 14, 10, 0, -14 },
  { 937, 9, 10, 10, 1, -10 },
  { 949, 10, 14, 10, 1, -14 },
  { 967, 9, 10, 10, 1, -10 },
  { 979, 12, 17, 10, -1, -14 },
  { 1005, 11, 13, 10, -1, -10 },
  { 1023, 9, 14, 10, 0, -14 },
  { 1039, 8, 14, 10, 1, -14 },
  { 1053, 10, 17, 10, -1, -14 },
  { 1075, 11, 14, 10, 0, -14 },
  { 1095, 6, 14, 10, 2, -14 },
  { 1106, 10, 10, 10, 0, -10 },
  { 1119, 9, 10, 10, 0, -10 },
  { 1131, 8, 10, 10, 1, -10 },
  { 1141, 10, 13, 10, -1, -10 },
  { 1158, 9, 13, 10, 1, -10 },
  { 1173, 9, 10, 10, 1, -10 },
  { 1185, 9, 10, 10, 0, -10 },
  { 1197, 9, 12, 10, 1, -12 },
  { 1211, 9, 9, 10, 1, -9 },
  { 1222, 9, 9, 10, 1, -9 },
  { 1233, 10, 9, 10, 1, -9 },
  { 1245, 11, 9, 10, -1, -9 },
  { 1258, 12, 12, 10, -2, -9 },
  { 1276, 10, 9, 10, 0, -9 },
  { 1288, 10, 17, 10, 1, -14 },
  { 1310, 6, 17, 10, 2, -14 },
  { 1323, 10, 17, 10, -1, -14 },
  { 1345, 10, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_BOLDITALIC18PT7B_H_
