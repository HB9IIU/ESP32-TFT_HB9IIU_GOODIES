#ifndef _UBUNTUSANSMONO_BOLDITALIC14PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x00, 0xEC, 0x6D, 0xB4, 0xD2, 0xC8, 0x09, 0x1B,
  0x12, 0x7F, 0x36, 0x24, 0xFE, 0xFE, 0x58, 0xD8, 0x04, 0x0C, 0x3F, 0x32,
  0x30, 0x38, 0x1C, 0x06, 0x06, 0xFC, 0x78, 0x30, 0x20, 0x18, 0xCF, 0x22,
  0x90, 0xA8, 0x34, 0x03, 0xC1, 0xF8, 0x56, 0x25, 0x31, 0xC0, 0x1C, 0x3E,
  0x36, 0x34, 0x38, 0x7B, 0xDA, 0xCE, 0xCE, 0x7E, 0xFB, 0x68, 0x08, 0x73,
  0x18, 0xE3, 0x0C, 0x20, 0x82, 0x0C, 0x30, 0x61, 0x00, 0x18, 0x60, 0xC3,
  0x04, 0x10, 0xC3, 0x0C, 0x63, 0x1C, 0xE2, 0x00, 0x10, 0x21, 0xFF, 0xE2,
  0x8D, 0x80, 0x0C, 0x10, 0x63, 0xFF, 0xE2, 0x0C, 0x00, 0x27, 0x72, 0xC0,
  0xFF, 0x5F, 0x00, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x3C, 0xF9, 0x9E,
  0x3D, 0x76, 0xE3, 0x46, 0xD9, 0xE0, 0x06, 0x38, 0xF1, 0x60, 0xC1, 0x06,
  0x0C, 0x7F, 0xF8, 0x1E, 0x3F, 0x23, 0x03, 0x06, 0x1C, 0x30, 0x60, 0xFE,
  0xFC, 0x1E, 0x3E, 0x03, 0x06, 0x1C, 0x3C, 0x06, 0x06, 0xCE, 0xFC, 0x03,
  0x07, 0x0E, 0x1E, 0x36, 0x66, 0xFF, 0xFE, 0x0C, 0x0C, 0x1F, 0x1F, 0x30,
  0x30, 0x3C, 0x5E, 0x06, 0x06, 0xCC, 0xFC, 0x0E, 0x7D, 0x86, 0x0F, 0xD9,
  0xA3, 0x66, 0xDC, 0xF0, 0x7F, 0x7E, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0x1E, 0x3F, 0x33, 0x33, 0x3E, 0x3C, 0x66, 0xC6, 0xEE, 0x7C,
  0x1C, 0x3E, 0x63, 0x63, 0x63, 0x3F, 0x06, 0x0E, 0x7C, 0xF0, 0x27, 0x70,
  0x04, 0xEC, 0x11, 0xCE, 0x00, 0x11, 0xCE, 0x26, 0x00, 0x0E, 0x7B, 0x87,
  0x07, 0x83, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x70, 0x78, 0x38, 0xF7, 0x98,
  0x00, 0x7B, 0xF0, 0xC6, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x0E, 0x3B, 0x21,
  0x6F, 0x5F, 0xDB, 0xD2, 0xD6, 0xDE, 0xC0, 0x60, 0x3C, 0x06, 0x06, 0x0F,
  0x1B, 0x1B, 0x33, 0x3F, 0x7F, 0x63, 0xC3, 0x3E, 0x3F, 0x33, 0x23, 0x7E,
  0x7E, 0x66, 0x46, 0xFE, 0xFC, 0x1E, 0x7D, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xE8, 0xF8, 0x3C, 0x3E, 0x33, 0x63, 0x63, 0x63, 0x66, 0xC6, 0xFC, 0xF8,
  0x1F, 0x3F, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x7E, 0xFC, 0x1F, 0x9F,
  0x8C, 0x06, 0x03, 0xE3, 0xF1, 0x80, 0xC0, 0x60, 0x60, 0x00, 0x1E, 0x7D,
  0x86, 0x0C, 0x19, 0xB3, 0x66, 0xFC, 0xF0, 0x31, 0x99, 0x8C, 0xCC, 0x67,
  0xF3, 0xF1, 0x99, 0x8C, 0xC6, 0x66, 0x00, 0x3F, 0x3F, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0xFE, 0xFC, 0x1F, 0x1F, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0xDC, 0xF8, 0x31, 0x99, 0x8D, 0x8D, 0x87, 0x83, 0xC1, 0xB0, 0x98,
  0xCE, 0x63, 0x00, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xFF, 0xF8,
  0x31, 0x33, 0x33, 0x75, 0x7F, 0x5B, 0xDA, 0xC6, 0xC6, 0x86, 0x31, 0x98,
  0x8C, 0xCF, 0x66, 0xB3, 0x51, 0x39, 0x9C, 0xCE, 0x62, 0x00, 0x1E, 0x3F,
  0x33, 0x63, 0x63, 0x63, 0xC6, 0xC6, 0x6C, 0x78, 0x3E, 0x3F, 0x33, 0x23,
  0x63, 0x7E, 0x78, 0x60, 0xC0, 0xC0, 0x1E, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0xC6, 0xC6, 0x6C, 0x78, 0x30, 0x1C, 0x08, 0x3C, 0x3E, 0x33, 0x63, 0x66,
  0x7C, 0x6C, 0x4C, 0xC4, 0xC6, 0x1E, 0x3F, 0x30, 0x30, 0x38, 0x1C, 0x06,
  0x06, 0xCE, 0xFC, 0x7F, 0xFF, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x33, 0x33, 0x23, 0x63, 0x62, 0x66, 0x66, 0xC6, 0x6C, 0x7C, 0xC7,
  0x8E, 0x34, 0x69, 0x93, 0x3C, 0x78, 0xE1, 0x80, 0x31, 0x90, 0xD8, 0x4C,
  0x67, 0xB2, 0xD9, 0xE9, 0xD4, 0xEE, 0x66, 0x00, 0x18, 0xC6, 0x60, 0xF0,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0xD8, 0x33, 0x38, 0xC0, 0xC7, 0x9B, 0x36,
  0xCF, 0x0E, 0x18, 0x30, 0xC1, 0x80, 0x3F, 0x3F, 0x06, 0x0E, 0x0C, 0x18,
  0x30, 0x60, 0xFE, 0xFC, 0x1E, 0x3C, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x06, 0x0F, 0x9E, 0x00, 0xDB, 0x6D, 0xB6, 0xC9, 0x36, 0xC0, 0x1E,
  0x3C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xCF, 0x1E, 0x00,
  0x18, 0x38, 0xF3, 0x6C, 0x70, 0x80, 0xFF, 0xFC, 0x4E, 0x30, 0x0C, 0x3F,
  0x76, 0x66, 0xC6, 0xC6, 0x6E, 0x7E, 0x18, 0x60, 0xC1, 0xA3, 0xEC, 0xD9,
  0xB3, 0x67, 0xBB, 0xE0, 0x08, 0xFF, 0x86, 0x0C, 0x18, 0x3E, 0x3E, 0x01,
  0x81, 0x80, 0xC0, 0x63, 0xF3, 0xB1, 0x99, 0x8C, 0xC6, 0x37, 0x1F, 0x80,
  0x18, 0xFB, 0x1E, 0x6F, 0xD0, 0x32, 0x3C, 0x03, 0xC1, 0xE0, 0xC0, 0x30,
  0x3F, 0x83, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0xF0, 0x30,
  0x00, 0x02, 0x0F, 0xCE, 0xC6, 0x62, 0x31, 0x98, 0xF8, 0x2C, 0x46, 0x7E,
  0x0C, 0x00, 0x18, 0x60, 0xC1, 0xC3, 0xEC, 0xD9, 0xB3, 0x67, 0x9B, 0x30,
  0x18, 0x60, 0x02, 0xF0, 0xC3, 0x0C, 0x61, 0xF3, 0xC0, 0x03, 0x03, 0x00,
  0x00, 0x1F, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x4C, 0xF8, 0x30, 0x18,
  0x10, 0x30, 0x30, 0x37, 0x3E, 0x78, 0x78, 0x6C, 0x6C, 0xC6, 0xF7, 0x88,
  0xC6, 0x31, 0x98, 0xC7, 0x9E, 0x7F, 0x6B, 0x5A, 0x5A, 0xC6, 0xC6, 0x86,
  0x08, 0x7D, 0x9B, 0x36, 0x6C, 0xF3, 0x66, 0x08, 0x7D, 0x9B, 0x34, 0x78,
  0xDB, 0x3C, 0x04, 0x1F, 0x33, 0x33, 0x33, 0x33, 0x7E, 0x7C, 0x60, 0x60,
  0xC0, 0x08, 0xFF, 0xB6, 0x6C, 0xD1, 0xB6, 0x7C, 0x18, 0x30, 0x40, 0x04,
  0x3F, 0x31, 0x20, 0x60, 0x60, 0x60, 0xE0, 0x0C, 0x7C, 0xC1, 0x83, 0xC1,
  0xD3, 0x7E, 0x08, 0x60, 0xC7, 0xF2, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0xE7,
  0x9B, 0x36, 0x6C, 0x9F, 0x3F, 0x00, 0xC7, 0x9B, 0x36, 0xC5, 0x8E, 0x18,
  0x00, 0x61, 0x4B, 0x5B, 0x5A, 0xEE, 0xEC, 0xCC, 0x77, 0x36, 0x1C, 0x18,
  0x3C, 0x6C, 0xC6, 0x31, 0x99, 0x8C, 0xC2, 0xC1, 0xE0, 0xE0, 0x70, 0x30,
  0xF0, 0x60, 0x00, 0x3F, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0xFC, 0x0E, 0x3C,
  0x60, 0x83, 0x06, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x86, 0x00, 0x0C,
  0x61, 0x86, 0x10, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x00, 0x1E, 0x1E,
  0x06, 0x06, 0x06, 0x04, 0x07, 0x0F, 0x0C, 0x08, 0x18, 0x18, 0x78, 0xE0,
  0x22, 0x7F, 0xDE,
};

const GFXglyph UbuntuSansMono_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 6, 5, 8, 2, -11 },
  { 10, 8, 10, 8, 0, -10 },
  { 20, 8, 13, 8, 0, -11 },
  { 33, 10, 10, 8, -1, -10 },
  { 46, 8, 10, 8, 0, -10 },
  { 56, 3, 5, 8, 4, -11 },
  { 58, 6, 14, 8, 2, -11 },
  { 69, 6, 14, 8, 0, -11 },
  { 80, 7, 6, 8, 1, -10 },
  { 86, 7, 7, 8, 0, -8 },
  { 93, 4, 5, 8, 1, -3 },
  { 96, 4, 2, 8, 2, -5 },
  { 97, 3, 3, 8, 2, -3 },
  { 99, 10, 14, 8, -1, -11 },
  { 117, 7, 10, 8, 1, -10 },
  { 126, 7, 10, 8, 0, -10 },
  { 135, 8, 10, 8, 0, -10 },
  { 145, 8, 10, 8, 0, -10 },
  { 155, 8, 10, 8, 0, -10 },
  { 165, 8, 10, 8, 0, -10 },
  { 175, 7, 10, 8, 1, -10 },
  { 184, 8, 10, 8, 1, -10 },
  { 194, 8, 10, 8, 0, -10 },
  { 204, 8, 10, 8, 0, -10 },
  { 214, 4, 8, 8, 2, -8 },
  { 218, 5, 10, 8, 1, -8 },
  { 225, 7, 6, 8, 1, -7 },
  { 231, 8, 4, 8, 0, -6 },
  { 235, 7, 6, 8, 0, -7 },
  { 241, 6, 10, 8, 2, -10 },
  { 249, 8, 12, 8, 0, -10 },
  { 261, 8, 10, 8, -1, -10 },
  { 271, 8, 10, 8, 0, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 8, 10, 8, 0, -10 },
  { 300, 8, 10, 8, 0, -10 },
  { 310, 9, 10, 8, 0, -10 },
  { 322, 7, 10, 8, 1, -10 },
  { 331, 9, 10, 8, 0, -10 },
  { 343, 8, 10, 8, 0, -10 },
  { 353, 8, 10, 8, 0, -10 },
  { 363, 9, 10, 8, 0, -10 },
  { 375, 7, 10, 8, 0, -10 },
  { 384, 8, 10, 8, 0, -10 },
  { 394, 9, 10, 8, 0, -10 },
  { 406, 8, 10, 8, 0, -10 },
  { 416, 8, 10, 8, 0, -10 },
  { 426, 8, 13, 8, 0, -10 },
  { 439, 8, 10, 8, 0, -10 },
  { 449, 8, 10, 8, 0, -10 },
  { 459, 8, 10, 8, 1, -10 },
  { 469, 8, 10, 8, 0, -10 },
  { 479, 7, 10, 8, 2, -10 },
  { 488, 9, 10, 8, 0, -10 },
  { 500, 10, 10, 8, -1, -10 },
  { 513, 7, 10, 8, 2, -10 },
  { 522, 8, 10, 8, 0, -10 },
  { 532, 7, 14, 8, 1, -11 },
  { 545, 3, 14, 8, 3, -11 },
  { 551, 7, 14, 8, 0, -11 },
  { 564, 7, 6, 8, 1, -10 },
  { 570, 7, 2, 8, -1, 1 },
  { 572, 4, 3, 8, 3, -11 },
  { 574, 8, 8, 8, 0, -8 },
  { 582, 7, 11, 8, 0, -11 },
  { 592, 7, 8, 8, 1, -8 },
  { 599, 9, 11, 8, 0, -11 },
  { 612, 7, 8, 8, 1, -8 },
  { 619, 10, 14, 8, -1, -11 },
  { 637, 9, 11, 8, -1, -8 },
  { 650, 7, 11, 8, 0, -11 },
  { 660, 6, 11, 8, 1, -11 },
  { 669, 8, 14, 8, -1, -11 },
  { 683, 8, 11, 8, 0, -11 },
  { 694, 5, 11, 8, 2, -11 },
  { 701, 8, 7, 8, 0, -7 },
  { 708, 7, 8, 8, 0, -8 },
  { 715, 7, 8, 8, 0, -8 },
  { 722, 8, 11, 8, -1, -8 },
  { 733, 7, 11, 8, 1, -8 },
  { 743, 8, 8, 8, 0, -8 },
  { 751, 7, 8, 8, 0, -8 },
  { 758, 7, 10, 8, 1, -10 },
  { 767, 7, 7, 8, 1, -7 },
  { 774, 7, 7, 8, 1, -7 },
  { 781, 8, 7, 8, 0, -7 },
  { 788, 8, 7, 8, 0, -7 },
  { 795, 9, 10, 8, -1, -7 },
  { 807, 8, 7, 8, 0, -7 },
  { 814, 7, 14, 8, 1, -11 },
  { 827, 6, 14, 8, 1, -11 },
  { 838, 8, 14, 8, -1, -11 },
  { 852, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_BOLDITALIC14PT7B_H_
