#ifndef _UBUNTUSANSMONO_BOLDITALIC52PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x3F, 0xC3, 0xF9, 0xFC,
  0x3F, 0xCF, 0xE1, 0xFE, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9,
  0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x83,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x1C, 0x07, 0xF8, 0x00, 0x40, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x02, 0x00, 0x07, 0xF0, 0x38, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0,
  0x1F, 0xFE, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0xF8, 0xF8, 0x0F,
  0x80, 0x1E, 0x1F, 0x03, 0xE0, 0x03, 0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x0F, 0x80, 0x03, 0xE3, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x1F, 0x00, 0x01, 0xFF, 0xE7, 0xC0, 0x00,
  0x1F, 0xF9, 0xF0, 0x00, 0x03, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x03, 0xE3, 0xFF, 0x00, 0x00,
  0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC7, 0x80,
  0x01, 0xF1, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x1E, 0x00, 0x1F, 0x07, 0x83,
  0xC0, 0x07, 0xE0, 0xF0, 0xF8, 0x01, 0xF8, 0x1E, 0x1F, 0x00, 0x3E, 0x03,
  0xC3, 0xC0, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xF0,
  0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0xC3, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0xCF,
  0xE7, 0xE3, 0xF8, 0x7F, 0x7E, 0x3F, 0x07, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC,
  0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xDF, 0x81, 0xFF, 0xF1, 0xFC, 0x0F,
  0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F,
  0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x7E, 0x0C, 0x7E,
  0x7C, 0x3C, 0x7F, 0x3C, 0xFE, 0x7F, 0xBD, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F,
  0xC7, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0x81, 0xC0, 0x01,
  0x00, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x17, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFC,
  0x01, 0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0F, 0x07, 0xF1, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0x87, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x83, 0xF9, 0xF8, 0x7C,
  0x7F, 0x7F, 0x1F, 0x8F, 0xEF, 0xE3, 0xF1, 0xFD, 0xF8, 0xFE, 0x3F, 0x3F,
  0x1F, 0xCF, 0xEF, 0xE3, 0xF1, 0xFD, 0xFC, 0x3C, 0x3F, 0xBF, 0x80, 0x07,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x9F, 0xC0,
  0x3E, 0x3F, 0x80, 0x60, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x7F, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0xE0, 0x07, 0xF8, 0x04, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x78, 0x1F, 0xF0, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x30, 0x00, 0xFF, 0x87, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x3F,
  0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0xFC, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x02,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xF0, 0xFF, 0xC6, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x7F, 0xF1, 0xF8, 0x1F, 0xFF, 0x8F, 0x81, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF,
  0xE7, 0xC1, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF, 0xF3, 0xF0, 0xFE, 0x1F, 0x9F,
  0x0F, 0xE0, 0xFC, 0xF8, 0x7E, 0x0F, 0xC7, 0xC3, 0xF0, 0x7E, 0x3E, 0x3F,
  0x03, 0xF3, 0xF1, 0xF8, 0x1F, 0x9F, 0x8F, 0xC1, 0xFC, 0xFC, 0x7E, 0x0F,
  0xC7, 0xC3, 0xF0, 0x7E, 0x3E, 0x1F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0x8F,
  0x87, 0xF1, 0xF8, 0x7C, 0x3F, 0xFF, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0x87,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x03, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xCF,
  0xC0, 0x7F, 0xC0, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x83,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x9F,
  0x80, 0x7F, 0xC0, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x18, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xEF, 0x80,
  0x7F, 0xF1, 0xF7, 0xC0, 0x3E, 0xF8, 0xF7, 0xE0, 0x1F, 0x3C, 0xFB, 0xE0,
  0x1F, 0x9E, 0x79, 0xF0, 0x0F, 0xCF, 0x7C, 0xF8, 0x07, 0xC7, 0xBC, 0xFC,
  0x03, 0xE3, 0xFE, 0x7E, 0x03, 0xF1, 0xFE, 0x3E, 0x01, 0xF8, 0xFF, 0x3F,
  0x00, 0xFC, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC7, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8,
  0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F,
  0x80, 0x3F, 0x7E, 0x0F, 0xC0, 0x1F, 0x9F, 0x0F, 0xE0, 0x1F, 0xCF, 0x87,
  0xE0, 0x0F, 0xE7, 0xC3, 0xF0, 0x07, 0xE3, 0xF1, 0xF8, 0x03, 0xF0, 0xF9,
  0xFC, 0x01, 0xF8, 0x7C, 0xFC, 0x01, 0xFC, 0x3E, 0x7E, 0x00, 0xFC, 0x1F,
  0xBF, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0x3F, 0x03, 0xFF, 0x80, 0x3F, 0x81,
  0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x01, 0xF8,
  0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xDF, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xCF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xDF, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0x00, 0x18,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x01, 0xFE, 0x03, 0x80,
  0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0xE0, 0x3F, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC3, 0xF0, 0x1F, 0x8F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF8, 0xF8, 0x07, 0xE7,
  0xFC, 0xFC, 0x03, 0xE3, 0xFE, 0x7E, 0x01, 0xF3, 0xFF, 0x3F, 0x01, 0xF9,
  0xE7, 0x9F, 0x00, 0xFD, 0xF3, 0xCF, 0x80, 0x7C, 0xF1, 0xEF, 0xC0, 0x3E,
  0xF8, 0xF7, 0xC0, 0x1F, 0x78, 0x7B, 0xE0, 0x0F, 0xFC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0,
  0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0x07, 0x00,
  0x07, 0x80, 0x40, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x10, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x0C, 0x00, 0x40, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFE,
  0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xFD, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xEF, 0xE0, 0x3F, 0xE1, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x8F, 0xF0, 0x3F, 0xE1, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xE0, 0x03, 0xFE, 0x1F, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x7F, 0x80,
  0x1F, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x02, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x04, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x13, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x07, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7E, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x1F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0xC7,
  0xE1, 0xF0, 0x3E, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xE1, 0xF0,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0x7C, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFB, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xF0, 0xFF, 0x81,
  0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFD, 0xFC, 0x00, 0x18, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x08, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0x70, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x0C, 0x00, 0x7F, 0x87, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x40, 0x00, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0x80, 0xFF,
  0x8F, 0xE0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x07, 0xC1, 0xF9, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x87, 0xE7, 0xE1, 0xFC, 0x3E, 0x3F, 0x0F, 0xE3,
  0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xC7, 0xF8, 0xF8, 0x7C, 0x7F, 0xCF, 0xC3,
  0xE3, 0xDE, 0x7C, 0x1F, 0x3E, 0xF3, 0xE0, 0xFB, 0xE7, 0x9F, 0x07, 0xDF,
  0x3D, 0xF0, 0x3F, 0xF1, 0xEF, 0x81, 0xFF, 0x8F, 0x7C, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x02, 0x00, 0x7F, 0xC0, 0x3C, 0x0F,
  0xFE, 0x03, 0xF1, 0xFF, 0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0x0F,
  0x80, 0x7F, 0xE0, 0x18, 0x01, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 17, 37, 29, 7, -36 },
  { 80, 21, 17, 29, 9, -40 },
  { 125, 31, 36, 29, 0, -36 },
  { 265, 28, 46, 29, 1, -40 },
  { 426, 35, 38, 29, -2, -37 },
  { 593, 28, 38, 29, 0, -37 },
  { 726, 10, 18, 29, 14, -40 },
  { 749, 23, 51, 29, 6, -41 },
  { 896, 24, 51, 29, 0, -41 },
  { 1049, 24, 23, 29, 5, -36 },
  { 1118, 26, 26, 29, 2, -28 },
  { 1203, 15, 19, 29, 3, -10 },
  { 1239, 18, 7, 29, 6, -18 },
  { 1255, 11, 11, 29, 7, -10 },
  { 1271, 35, 51, 29, -3, -41 },
  { 1495, 27, 38, 29, 2, -37 },
  { 1624, 23, 36, 29, 2, -36 },
  { 1728, 29, 37, 29, 0, -37 },
  { 1863, 28, 38, 29, 0, -37 },
  { 1996, 29, 36, 29, 0, -36 },
  { 2127, 30, 37, 29, 0, -36 },
  { 2266, 28, 37, 29, 2, -36 },
  { 2396, 27, 36, 29, 5, -36 },
  { 2518, 28, 38, 29, 1, -37 },
  { 2651, 28, 37, 29, 1, -37 },
  { 2781, 15, 29, 29, 7, -28 },
  { 2836, 19, 37, 29, 3, -28 },
  { 2924, 27, 25, 29, 2, -28 },
  { 3009, 29, 17, 29, 0, -24 },
  { 3071, 26, 25, 29, 1, -28 },
  { 3153, 22, 38, 29, 7, -37 },
  { 3258, 29, 45, 29, 1, -37 },
  { 3422, 29, 36, 29, -3, -36 },
  { 3553, 29, 36, 29, 0, -36 },
  { 3684, 28, 38, 29, 3, -37 },
  { 3817, 29, 36, 29, 0, -36 },
  { 3948, 30, 36, 29, 1, -36 },
  { 4083, 31, 36, 29, 1, -36 },
  { 4223, 29, 38, 29, 2, -37 },
  { 4361, 33, 36, 29, -1, -36 },
  { 4510, 31, 36, 29, 0, -36 },
  { 4650, 30, 37, 29, 0, -36 },
  { 4789, 33, 36, 29, 0, -36 },
  { 4938, 24, 36, 29, 0, -36 },
  { 5046, 33, 36, 29, -2, -36 },
  { 5195, 33, 36, 29, -1, -36 },
  { 5344, 27, 38, 29, 2, -37 },
  { 5473, 30, 36, 29, 0, -36 },
  { 5608, 27, 47, 29, 2, -37 },
  { 5767, 29, 36, 29, 0, -36 },
  { 5898, 30, 38, 29, 0, -37 },
  { 6041, 28, 36, 29, 5, -36 },
  { 6167, 29, 37, 29, 2, -36 },
  { 6302, 28, 36, 29, 6, -36 },
  { 6428, 33, 36, 29, 0, -36 },
  { 6577, 35, 36, 29, -2, -36 },
  { 6735, 28, 36, 29, 6, -36 },
  { 6861, 32, 36, 29, -1, -36 },
  { 7005, 28, 51, 29, 3, -41 },
  { 7184, 11, 51, 29, 10, -41 },
  { 7255, 28, 51, 29, -1, -41 },
  { 7434, 27, 21, 29, 2, -36 },
  { 7505, 27, 7, 29, -4, 3 },
  { 7529, 12, 11, 29, 12, -40 },
  { 7546, 26, 29, 29, 2, -28 },
  { 7641, 27, 41, 29, 0, -40 },
  { 7780, 27, 29, 29, 2, -28 },
  { 7878, 30, 41, 29, 2, -40 },
  { 8032, 26, 29, 29, 2, -28 },
  { 8127, 36, 50, 29, -4, -40 },
  { 8352, 31, 38, 29, -2, -28 },
  { 8500, 27, 40, 29, 0, -40 },
  { 8635, 21, 42, 29, 4, -41 },
  { 8746, 30, 51, 29, -3, -41 },
  { 8938, 30, 40, 29, 1, -40 },
  { 9088, 18, 41, 29, 6, -40 },
  { 9181, 30, 28, 29, -1, -28 },
  { 9286, 27, 28, 29, 0, -28 },
  { 9381, 25, 29, 29, 2, -28 },
  { 9472, 29, 38, 29, -2, -28 },
  { 9610, 27, 38, 29, 2, -28 },
  { 9739, 27, 28, 29, 2, -28 },
  { 9834, 26, 29, 29, 1, -28 },
  { 9929, 25, 36, 29, 4, -35 },
  { 10042, 26, 28, 29, 2, -27 },
  { 10133, 26, 27, 29, 4, -27 },
  { 10221, 29, 27, 29, 2, -27 },
  { 10319, 32, 27, 29, -2, -27 },
  { 10427, 35, 37, 29, -5, -27 },
  { 10589, 28, 27, 29, 1, -27 },
  { 10684, 28, 51, 29, 4, -41 },
  { 10863, 19, 51, 29, 5, -41 },
  { 10985, 28, 51, 29, -2, -41 },
  { 11164, 28, 11, 29, 1, -21 },
};

const GFXfont UbuntuSansMono_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_BOLDITALIC52PT7B_H_
