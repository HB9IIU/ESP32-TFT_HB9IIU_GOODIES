#ifndef _UBUNTUSANSMONO_BOLDITALIC35PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x7E, 0x7D,
  0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C,
  0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x00, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80,
  0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x01, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFE, 0x1C, 0x0F, 0x80, 0x40, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x82, 0x00, 0xF8, 0x3C, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x3C, 0x1F, 0xC0, 0x70,
  0x7B, 0x81, 0xC0, 0xE7, 0x07, 0x01, 0xCE, 0x1E, 0x07, 0x1C, 0x78, 0x0E,
  0x39, 0xE0, 0x1C, 0xF7, 0x80, 0x3F, 0xCE, 0x00, 0x3F, 0x38, 0x00, 0x7C,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0xF8, 0x00, 0x73,
  0xF8, 0x01, 0xCF, 0xF0, 0x07, 0x1C, 0xE0, 0x1E, 0x71, 0xC0, 0x78, 0xE3,
  0x81, 0xE1, 0xC7, 0x03, 0x83, 0x9C, 0x0E, 0x07, 0xF8, 0x38, 0x0F, 0xE0,
  0xF0, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x1E, 0x1F, 0xE3, 0xC7, 0xFC, 0x79, 0xE7, 0xDE, 0x78, 0x7F, 0xCF, 0x0F,
  0xF3, 0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF9, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xBC, 0x1F, 0xC7, 0xC0, 0x7D, 0xF7, 0xFF, 0xFB, 0xEF, 0xBC,
  0xF3, 0x8E, 0x38, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x06, 0x38, 0x47, 0x9C, 0xF3, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDE, 0x03, 0xEF,
  0x83, 0xE3, 0xE0, 0x71, 0xC0, 0x10, 0x40, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x05, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x02, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x1E, 0x07, 0x8F,
  0xCF, 0xE3, 0xF0, 0x60, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x10,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x3F, 0x07, 0x87, 0xC0, 0xF1, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0x80, 0x79, 0xF3, 0x8F, 0x3E, 0x79, 0xE7, 0x9F, 0x3C,
  0xF3, 0xCF, 0x9E, 0x39, 0xF7, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3C, 0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x0E, 0x7C, 0x08,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x7E, 0x0E, 0x07, 0xC1, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x38, 0x7E, 0x04, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC4, 0x01, 0xF8, 0xF9, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87,
  0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x86, 0x01, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xBF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF1, 0xF8, 0xF0, 0x1F, 0x1E, 0x01, 0xE7,
  0xC0, 0x3C, 0xF8, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87,
  0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00,
  0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7E, 0x1E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x3F, 0x7E, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x83, 0xE0, 0xF8, 0x78,
  0x0F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xFC,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xF8, 0xFC, 0x7C,
  0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0,
  0x0F, 0x1F, 0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1E,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x02,
  0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xC0, 0x00,
  0x40, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x1F, 0x83, 0xF8,
  0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x10,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x78, 0xFD, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0x80,
  0x39, 0xE0, 0x0F, 0x3C, 0x3F, 0xEF, 0x0F, 0xFD, 0xE3, 0xFF, 0xB8, 0xFD,
  0xFF, 0x1E, 0x3D, 0xE7, 0x87, 0xBC, 0xF0, 0xF7, 0x9E, 0x3E, 0xE3, 0xC7,
  0x9C, 0x78, 0xF3, 0x8F, 0x1E, 0x71, 0xF3, 0xCE, 0x3F, 0xF1, 0xE3, 0xFE,
  0x3C, 0x3F, 0xC7, 0x81, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x10,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1E,
  0xF8, 0x07, 0xDF, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF8,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x1F, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xC3,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x1F, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x7C, 0x3F, 0x01, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x40, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E,
  0x3E, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC7, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x7C, 0x3F, 0x01,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF8,
  0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x40, 0x00,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x20, 0x1F, 0x03, 0x03, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0xFC,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1D, 0x87, 0xE0, 0x77, 0x3B, 0x83, 0xDC,
  0xFE, 0x0F, 0x77, 0x78, 0x3D, 0xDD, 0xE1, 0xE7, 0xE7, 0x07, 0x9F, 0xBC,
  0x1E, 0x7C, 0xF0, 0x79, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03,
  0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x78,
  0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0xC1, 0xF0, 0xFE, 0x0F, 0x07, 0xF0,
  0x78, 0x3F, 0x83, 0xC3, 0xFE, 0x3E, 0x1F, 0xF1, 0xE0, 0xF3, 0x8F, 0x07,
  0x9C, 0x78, 0x3C, 0xF7, 0xC3, 0xE7, 0xBC, 0x1E, 0x1D, 0xE0, 0xF0, 0xEF,
  0x07, 0x87, 0xF8, 0x7C, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x07, 0xE0, 0xF0,
  0x3F, 0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFC,
  0x3F, 0x0F, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0xC3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x3F, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x3F, 0x0F, 0x87, 0xC0, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7D, 0xFE, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F,
  0x87, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E,
  0x7C, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0xF0,
  0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xE1, 0xE0, 0xF8, 0x04,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x60,
  0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E,
  0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7,
  0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x3E,
  0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x78, 0xF0, 0x79, 0xE3, 0xC3,
  0xCF, 0x9E, 0x0F, 0x3E, 0x78, 0x3D, 0xF9, 0xE0, 0xF7, 0xE7, 0x83, 0xBB,
  0x9C, 0x1E, 0xE6, 0xF0, 0x7F, 0x1B, 0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80,
  0x07, 0xCF, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3C, 0x03,
  0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3E, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF8,
  0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF1, 0xE3, 0xC7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x81, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x7C, 0x7C,
  0x3E, 0x1F, 0x1F, 0x83, 0xEF, 0xC0, 0xFB, 0xE0, 0x3F, 0x70, 0x07, 0x04,
  0x01, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0x20, 0x70, 0x7C, 0xFE, 0x3F, 0x0F, 0x06, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF0,
  0x3E, 0x78, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFC, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x9C, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFC, 0x33, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x11, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3B, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87,
  0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x1F,
  0x78, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE1,
  0xF0, 0xF8, 0x1E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0,
  0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1C, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x40, 0x3E, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xE0, 0x00, 0x40, 0x07, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x02, 0x07, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x10, 0xF8, 0x7E,
  0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x17, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0,
  0x00, 0xC0, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x3C,
  0xF0, 0xF3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0xF1, 0xE7,
  0x9E, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x80,
  0x00, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC0,
  0xFB, 0xF0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xF0,
  0x7E, 0x1F, 0x0F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xC7, 0xCF, 0xC1, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9E, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xC7, 0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x20, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0x83,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC2, 0x01, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x04, 0x00, 0x00, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E,
  0x04, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0x07, 0xC7,
  0xC1, 0xF1, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0, 0xF8,
  0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xF7, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x7C, 0x1E,
  0x7C, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x3C, 0x71, 0xF3, 0xC7, 0x3F,
  0x3C, 0xF3, 0xF3, 0x8F, 0x7F, 0x78, 0xF7, 0x77, 0x8F, 0xF7, 0x70, 0xFE,
  0x7F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x03, 0x80, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xF0,
  0x07, 0xCF, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x87, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF0,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x02, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x08, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x83, 0xFC, 0x3C, 0xFF, 0xEF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xF0, 0xFF, 0x2C, 0x0F, 0xC0,
};

const GFXglyph UbuntuSansMono_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 24, 20, 5, -24 },
  { 34, 14, 11, 20, 6, -27 },
  { 54, 21, 24, 20, 0, -24 },
  { 117, 20, 31, 20, 0, -27 },
  { 195, 23, 26, 20, -1, -25 },
  { 270, 19, 25, 20, 0, -25 },
  { 330, 6, 12, 20, 10, -27 },
  { 339, 16, 35, 20, 4, -28 },
  { 409, 16, 35, 20, 0, -28 },
  { 479, 17, 15, 20, 3, -24 },
  { 511, 18, 18, 20, 1, -19 },
  { 552, 10, 13, 20, 2, -7 },
  { 569, 12, 4, 20, 4, -12 },
  { 575, 7, 7, 20, 5, -7 },
  { 582, 23, 33, 20, -2, -27 },
  { 677, 19, 26, 20, 1, -25 },
  { 739, 16, 24, 20, 1, -24 },
  { 787, 19, 25, 20, 0, -25 },
  { 847, 19, 26, 20, 0, -25 },
  { 909, 20, 24, 20, 0, -24 },
  { 969, 20, 25, 20, 0, -24 },
  { 1032, 19, 25, 20, 1, -24 },
  { 1092, 19, 24, 20, 3, -24 },
  { 1149, 19, 26, 20, 1, -25 },
  { 1211, 19, 25, 20, 1, -25 },
  { 1271, 10, 19, 20, 5, -19 },
  { 1295, 13, 25, 20, 2, -19 },
  { 1336, 17, 17, 20, 2, -19 },
  { 1373, 20, 12, 20, 0, -16 },
  { 1403, 17, 17, 20, 1, -19 },
  { 1440, 14, 25, 20, 5, -25 },
  { 1484, 19, 30, 20, 1, -25 },
  { 1556, 19, 24, 20, -2, -24 },
  { 1613, 20, 25, 20, 0, -25 },
  { 1676, 19, 26, 20, 2, -25 },
  { 1738, 19, 25, 20, 0, -25 },
  { 1798, 20, 24, 20, 1, -24 },
  { 1858, 20, 24, 20, 1, -24 },
  { 1918, 19, 26, 20, 2, -25 },
  { 1980, 21, 24, 20, 0, -24 },
  { 2043, 21, 24, 20, 0, -24 },
  { 2106, 20, 25, 20, 0, -24 },
  { 2169, 22, 24, 20, 0, -24 },
  { 2235, 16, 24, 20, 0, -24 },
  { 2283, 22, 24, 20, -1, -24 },
  { 2349, 21, 24, 20, 0, -24 },
  { 2412, 19, 26, 20, 1, -25 },
  { 2474, 20, 25, 20, 0, -25 },
  { 2537, 19, 32, 20, 1, -25 },
  { 2613, 19, 25, 20, 0, -25 },
  { 2673, 20, 26, 20, 0, -25 },
  { 2738, 18, 24, 20, 4, -24 },
  { 2792, 20, 25, 20, 1, -24 },
  { 2855, 19, 24, 20, 4, -24 },
  { 2912, 22, 24, 20, 0, -24 },
  { 2978, 23, 24, 20, -1, -24 },
  { 3047, 19, 24, 20, 4, -24 },
  { 3104, 21, 24, 20, 0, -24 },
  { 3167, 19, 33, 20, 2, -27 },
  { 3246, 7, 33, 20, 7, -27 },
  { 3275, 19, 33, 20, -1, -27 },
  { 3354, 18, 14, 20, 2, -24 },
  { 3386, 19, 4, 20, -3, 2 },
  { 3396, 8, 7, 20, 8, -27 },
  { 3403, 18, 19, 20, 1, -19 },
  { 3446, 18, 28, 20, 0, -27 },
  { 3509, 17, 19, 20, 2, -19 },
  { 3550, 20, 27, 20, 1, -27 },
  { 3618, 18, 19, 20, 1, -19 },
  { 3661, 25, 34, 20, -3, -27 },
  { 3768, 20, 26, 20, -1, -19 },
  { 3833, 18, 27, 20, 0, -27 },
  { 3894, 14, 28, 20, 3, -28 },
  { 3943, 20, 35, 20, -2, -28 },
  { 4031, 20, 27, 20, 1, -27 },
  { 4099, 12, 27, 20, 4, -27 },
  { 4140, 20, 19, 20, -1, -19 },
  { 4188, 18, 19, 20, 0, -19 },
  { 4231, 17, 20, 20, 1, -19 },
  { 4274, 20, 25, 20, -2, -19 },
  { 4337, 18, 25, 20, 1, -19 },
  { 4394, 19, 19, 20, 1, -19 },
  { 4440, 18, 20, 20, 0, -19 },
  { 4485, 16, 24, 20, 3, -24 },
  { 4533, 18, 18, 20, 1, -18 },
  { 4574, 17, 18, 20, 3, -18 },
  { 4613, 20, 18, 20, 1, -18 },
  { 4658, 21, 18, 20, -1, -18 },
  { 4706, 23, 25, 20, -3, -18 },
  { 4778, 19, 18, 20, 0, -18 },
  { 4821, 19, 33, 20, 2, -27 },
  { 4900, 13, 33, 20, 3, -27 },
  { 4954, 18, 33, 20, -1, -27 },
  { 5029, 19, 7, 20, 0, -14 },
};

const GFXfont UbuntuSansMono_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_BOLDITALIC35PT7B_H_
