#ifndef _UBUNTUSANSMONO_BOLDITALIC41PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x01, 0x00,
  0x00, 0x3F, 0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3,
  0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x07, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x03, 0xE1, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07,
  0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3E, 0x1E, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x30, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x40, 0x07, 0xE0, 0xF0, 0x1F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x01, 0xFE, 0x01, 0xE0,
  0x3F, 0xE0, 0x3C, 0x07, 0x8E, 0x07, 0x80, 0x78, 0xE0, 0xF0, 0x07, 0x0E,
  0x1E, 0x00, 0x71, 0xE3, 0xE0, 0x07, 0x1E, 0x3C, 0x00, 0xF1, 0xC7, 0x80,
  0x07, 0xBC, 0xF0, 0x00, 0x7F, 0x9E, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x1E, 0x7E,
  0x00, 0x03, 0xCF, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x0F, 0x9E, 0x70, 0x00,
  0xF3, 0xC7, 0x00, 0x1E, 0x3C, 0x70, 0x03, 0xC3, 0x87, 0x00, 0x78, 0x38,
  0xF0, 0x0F, 0x03, 0x8F, 0x01, 0xF0, 0x39, 0xE0, 0x1E, 0x03, 0xFE, 0x03,
  0xC0, 0x3F, 0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xF1, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F,
  0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x83, 0xC3, 0xFF, 0x0F, 0x1F, 0xFC, 0x7C, 0xFD, 0xF9, 0xE3,
  0xE3, 0xFF, 0x9F, 0x07, 0xFC, 0x7C, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F, 0x80,
  0x7C, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFE, 0x7C, 0x1F, 0xE1, 0xF8, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x10, 0xF8, 0x27, 0x9E, 0x3C, 0xF9, 0xCF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xDE, 0x01,
  0xFB, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0xF0, 0x06, 0x0C, 0x00,
  0x41, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x03, 0xC0, 0xF0, 0x7E, 0x7F, 0x8F,
  0xE1, 0xF0, 0x38, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xC0, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE7, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x61, 0xF7, 0xC7,
  0x9F, 0xFE, 0x7C, 0xFB, 0xE3, 0xE7, 0xDF, 0x1F, 0x3E, 0xF8, 0xF1, 0xF7,
  0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0x1F, 0x80, 0x83, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0xE0,
  0x1F, 0x81, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x06, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x10, 0x01, 0xFC, 0x78,
  0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x20, 0x07, 0xE0, 0x78, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x7D, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8,
  0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7E, 0x1F,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0x03,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0,
  0xFC, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x9F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0x7E,
  0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F,
  0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xF7, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0x7E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x04, 0x00, 0x00,
  0x70, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x7E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC6, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0x07, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1E, 0x00, 0x3E, 0x7C, 0x1F, 0xFC, 0xF0, 0x7F, 0xFB, 0xE1, 0xFF, 0xE7,
  0x87, 0xFF, 0xCF, 0x1F, 0x8F, 0x9E, 0x3E, 0x1F, 0x7C, 0x78, 0x3C, 0xF1,
  0xF0, 0xF9, 0xE3, 0xE1, 0xF3, 0xC7, 0xC3, 0xE7, 0x8F, 0x07, 0x8F, 0x1E,
  0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xFF, 0xF0, 0xF0, 0xFF,
  0xE1, 0xE1, 0xFF, 0xC3, 0xE0, 0xFF, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF7, 0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F,
  0x3E, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7C, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3E, 0x03, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7F, 0xBF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xC0, 0x60, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x20, 0x7F, 0xC7, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x60,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83,
  0xF0, 0x7F, 0x8F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x20, 0x0F, 0xC0, 0x30,
  0x0F, 0xC0, 0x7E, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3E, 0x07, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF0,
  0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1E, 0xE3, 0xFE,
  0x07, 0xB8, 0xEF, 0x01, 0xEE, 0x7B, 0xC0, 0xFB, 0xDC, 0xF0, 0x3E, 0xFF,
  0x7C, 0x0F, 0x3F, 0x9F, 0x03, 0xCF, 0xE7, 0x81, 0xF3, 0xF1, 0xE0, 0x7C,
  0xFC, 0xF8, 0x1E, 0x1E, 0x3E, 0x0F, 0x87, 0x8F, 0x83, 0xE0, 0x03, 0xC0,
  0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xFC, 0x0F, 0x80, 0xFF, 0x03,
  0xE0, 0x3F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xDE, 0x1F, 0x01, 0xF7,
  0x87, 0xC0, 0x7D, 0xE1, 0xF0, 0x3E, 0x78, 0xF8, 0x0F, 0x8F, 0x3E, 0x03,
  0xE3, 0xCF, 0x80, 0xF8, 0xF3, 0xE0, 0x7C, 0x3D, 0xF0, 0x1F, 0x0F, 0xFC,
  0x07, 0xC1, 0xFF, 0x01, 0xF0, 0x7F, 0xC0, 0xFC, 0x1F, 0xE0, 0x3E, 0x07,
  0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0x81, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC3, 0xF0,
  0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x03, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x10, 0x03, 0xF8, 0x7C, 0x0F, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF1, 0xE1, 0xE0, 0x7C, 0xF8, 0xF8, 0x1E, 0x3E, 0x3E, 0x0F, 0x9F,
  0x8F, 0x03, 0xE7, 0xE3, 0xC0, 0xFB, 0xFD, 0xF0, 0x3C, 0xEF, 0x7C, 0x0F,
  0x7B, 0xDE, 0x03, 0xDC, 0xF7, 0x81, 0xFF, 0x3F, 0xE0, 0x7B, 0x8F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x7E, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8,
  0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7E,
  0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E,
  0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0xFC,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xFC, 0xFE, 0x07, 0xE7,
  0xE0, 0x1F, 0x7E, 0x00, 0xFC, 0xE0, 0x07, 0xC2, 0x00, 0x10, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x0E, 0x03, 0xC1, 0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0E, 0x00, 0x80,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xE0, 0xF8, 0xFE, 0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC3, 0xF9, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xF1, 0xF0, 0x00, 0x18,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x83, 0xF8, 0xFC, 0x3F, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xE0, 0x10, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x7C,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xF0, 0x3F,
  0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xE3, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xE7, 0xF3,
  0xF0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x38, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x02, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x67, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x02, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x40, 0x0F, 0xC0, 0x38, 0x1F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF7, 0x0F,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x40, 0x7E, 0x00, 0xE1, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xC7, 0xF0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xF9,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xEF, 0x7F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0xF8, 0x78, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x9F, 0xBF, 0x0F, 0x8F, 0x1F,
  0x0F, 0x9F, 0x1E, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0x1E, 0x3E,
  0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x3C, 0x1E, 0x3E, 0x7C, 0x3E, 0x3C, 0x7C,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF8,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFE, 0x0F, 0xC7, 0xF3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0x83, 0xF8, 0x1F,
  0xBF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC,
  0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x87, 0xF3,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xC1, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x02, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x40, 0x0F, 0xC7, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x83, 0xFE, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x1F,
  0x8F, 0xEF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC,
  0xFC, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xFC, 0x78, 0x78, 0xFC, 0xF8, 0x79, 0xFC, 0xF0, 0x79, 0xFC, 0xF0, 0x7B,
  0xDC, 0xF0, 0x7B, 0xDD, 0xE0, 0xF7, 0x9D, 0xE0, 0xF7, 0x9D, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x21, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x70, 0x7F, 0xC1,
  0xF3, 0xFF, 0xCF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xE3, 0xFF, 0x8F,
  0x03, 0xFC, 0x0C, 0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 13, 29, 23, 6, -28 },
  { 49, 17, 13, 23, 7, -31 },
  { 77, 24, 28, 23, 0, -28 },
  { 161, 23, 36, 23, 0, -32 },
  { 265, 28, 30, 23, -2, -29 },
  { 370, 22, 29, 23, 0, -29 },
  { 450, 8, 14, 23, 11, -31 },
  { 464, 18, 41, 23, 5, -33 },
  { 557, 19, 41, 23, 0, -33 },
  { 655, 19, 18, 23, 4, -28 },
  { 698, 21, 20, 23, 1, -22 },
  { 751, 11, 15, 23, 3, -8 },
  { 772, 14, 6, 23, 5, -15 },
  { 783, 8, 9, 23, 6, -8 },
  { 792, 27, 40, 23, -2, -32 },
  { 927, 21, 30, 23, 2, -29 },
  { 1006, 19, 28, 23, 1, -28 },
  { 1073, 23, 29, 23, 0, -29 },
  { 1157, 22, 30, 23, 0, -29 },
  { 1240, 23, 28, 23, 0, -28 },
  { 1321, 24, 29, 23, 0, -28 },
  { 1408, 22, 30, 23, 2, -29 },
  { 1491, 22, 28, 23, 4, -28 },
  { 1568, 22, 30, 23, 1, -29 },
  { 1651, 22, 29, 23, 1, -29 },
  { 1731, 11, 23, 23, 6, -22 },
  { 1763, 14, 29, 23, 3, -22 },
  { 1814, 21, 20, 23, 2, -22 },
  { 1867, 23, 14, 23, 0, -19 },
  { 1908, 21, 20, 23, 1, -22 },
  { 1961, 18, 30, 23, 5, -29 },
  { 2029, 23, 35, 23, 1, -29 },
  { 2130, 22, 28, 23, -2, -28 },
  { 2207, 23, 29, 23, 0, -29 },
  { 2291, 22, 30, 23, 2, -29 },
  { 2374, 23, 29, 23, 0, -29 },
  { 2458, 23, 28, 23, 1, -28 },
  { 2539, 24, 28, 23, 1, -28 },
  { 2623, 22, 30, 23, 2, -29 },
  { 2706, 26, 28, 23, -1, -28 },
  { 2797, 25, 28, 23, 0, -28 },
  { 2885, 24, 29, 23, 0, -28 },
  { 2972, 26, 28, 23, 0, -28 },
  { 3063, 19, 28, 23, 0, -28 },
  { 3130, 26, 28, 23, -1, -28 },
  { 3221, 26, 28, 23, -1, -28 },
  { 3312, 22, 30, 23, 1, -29 },
  { 3395, 24, 29, 23, 0, -29 },
  { 3482, 22, 37, 23, 1, -29 },
  { 3584, 23, 29, 23, 0, -29 },
  { 3668, 23, 30, 23, 0, -29 },
  { 3755, 22, 28, 23, 4, -28 },
  { 3832, 24, 29, 23, 1, -28 },
  { 3919, 23, 28, 23, 4, -28 },
  { 4000, 26, 28, 23, 0, -28 },
  { 4091, 28, 28, 23, -2, -28 },
  { 4189, 22, 28, 23, 5, -28 },
  { 4266, 25, 28, 23, 0, -28 },
  { 4354, 23, 40, 23, 2, -32 },
  { 4469, 9, 40, 23, 8, -32 },
  { 4514, 22, 40, 23, -1, -32 },
  { 4624, 21, 16, 23, 2, -28 },
  { 4666, 21, 5, 23, -3, 3 },
  { 4680, 10, 9, 23, 9, -32 },
  { 4692, 21, 22, 23, 1, -22 },
  { 4750, 21, 33, 23, 0, -32 },
  { 4837, 21, 22, 23, 2, -22 },
  { 4895, 24, 32, 23, 1, -32 },
  { 4991, 20, 23, 23, 2, -22 },
  { 5049, 28, 40, 23, -3, -32 },
  { 5189, 25, 30, 23, -2, -22 },
  { 5283, 21, 32, 23, 0, -32 },
  { 5367, 16, 32, 23, 3, -32 },
  { 5431, 23, 40, 23, -2, -32 },
  { 5546, 23, 32, 23, 1, -32 },
  { 5638, 14, 32, 23, 5, -32 },
  { 5694, 24, 22, 23, -1, -22 },
  { 5760, 21, 22, 23, 0, -22 },
  { 5818, 20, 23, 23, 1, -22 },
  { 5876, 24, 30, 23, -2, -22 },
  { 5966, 21, 30, 23, 2, -22 },
  { 6045, 22, 22, 23, 1, -22 },
  { 6106, 20, 23, 23, 1, -22 },
  { 6164, 20, 28, 23, 3, -28 },
  { 6234, 20, 22, 23, 2, -22 },
  { 6289, 21, 22, 23, 3, -22 },
  { 6347, 24, 22, 23, 1, -22 },
  { 6413, 25, 22, 23, -1, -22 },
  { 6482, 28, 30, 23, -4, -22 },
  { 6587, 22, 22, 23, 1, -22 },
  { 6648, 22, 40, 23, 3, -32 },
  { 6758, 15, 40, 23, 4, -32 },
  { 6833, 22, 40, 23, -2, -32 },
  { 6943, 22, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_BOLDITALIC41PT7B_H_
