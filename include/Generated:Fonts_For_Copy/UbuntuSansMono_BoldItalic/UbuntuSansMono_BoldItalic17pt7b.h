#ifndef _UBUNTUSANSMONO_BOLDITALIC17PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x01, 0x8F, 0x18, 0x6F, 0xDF,
  0x36, 0x6C, 0x80, 0x06, 0xC3, 0x30, 0xD9, 0xFF, 0x7F, 0xC4, 0xC3, 0x33,
  0xFE, 0xFF, 0x9B, 0x0C, 0xC3, 0x60, 0x03, 0x03, 0x07, 0xE7, 0x33, 0x01,
  0xC0, 0xF0, 0x3E, 0x07, 0x01, 0x90, 0xDF, 0xE3, 0xC0, 0xC0, 0xC0, 0x1C,
  0x31, 0x66, 0x34, 0xC3, 0x58, 0x3D, 0x01, 0xB0, 0x06, 0x80, 0xDC, 0x1B,
  0x43, 0x24, 0x22, 0xCC, 0x38, 0x0F, 0x0F, 0x8C, 0x46, 0x63, 0x60, 0xE0,
  0xF6, 0xDB, 0xC7, 0x63, 0xBF, 0xCF, 0x70, 0xFF, 0x6D, 0x00, 0x02, 0x0C,
  0x38, 0xE3, 0x8E, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x38,
  0x20, 0x08, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x07, 0x07, 0x06, 0x06,
  0x0E, 0x1C, 0x18, 0x38, 0xE0, 0x40, 0x38, 0x33, 0x5F, 0xF3, 0x8D, 0xBB,
  0x94, 0x0C, 0x18, 0x18, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x3B, 0xCE, 0x6F,
  0x60, 0xFF, 0xE0, 0x7F, 0x60, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xDB, 0xDB, 0xC3, 0xC7,
  0xC6, 0xFC, 0x78, 0x06, 0x3D, 0xFB, 0xE4, 0xC1, 0x87, 0x0C, 0x18, 0x33,
  0xFF, 0xF0, 0x0F, 0x1F, 0xC4, 0x60, 0x30, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x3F, 0xDF, 0xE0, 0x3F, 0x0F, 0xC4, 0x60, 0x30, 0x38, 0xF0, 0x7C,
  0x06, 0x03, 0x01, 0xBF, 0xDF, 0xC0, 0x01, 0xC0, 0xE0, 0x78, 0x36, 0x1B,
  0x8C, 0xC6, 0x33, 0xFE, 0xFF, 0x81, 0x80, 0x60, 0x18, 0x0F, 0xC7, 0xF1,
  0x80, 0x60, 0x30, 0x0F, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0xCF, 0xF3, 0xF8,
  0x07, 0x8F, 0xCE, 0x0E, 0x06, 0x07, 0xF3, 0x9D, 0x86, 0xC3, 0x63, 0xBF,
  0x8F, 0x80, 0xFF, 0xFF, 0x81, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x30, 0x18, 0x00, 0x0F, 0x07, 0xE3, 0x9C, 0xC6, 0x39, 0x87, 0xC3,
  0xF1, 0x8C, 0x63, 0xB8, 0xC7, 0xF1, 0xF8, 0x1F, 0x1F, 0xCC, 0x6E, 0x37,
  0x1B, 0x8C, 0xFE, 0x17, 0x03, 0x07, 0x1F, 0x1E, 0x00, 0x39, 0xCE, 0x00,
  0x01, 0xDE, 0x60, 0x1C, 0x71, 0xC0, 0x00, 0x03, 0x9E, 0x38, 0xCF, 0x30,
  0x01, 0x0F, 0x3E, 0xF0, 0xE0, 0x7C, 0x1E, 0x06, 0x7F, 0xBF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x20, 0x3C, 0x07, 0xC0, 0xF0, 0x79, 0xF3, 0xE1, 0x80,
  0x3C, 0xFD, 0x18, 0x30, 0xE7, 0x0C, 0x30, 0x00, 0xC3, 0x87, 0x00, 0x0F,
  0x87, 0xF3, 0x0C, 0x83, 0x67, 0xDB, 0x64, 0xDB, 0x66, 0xD9, 0xB7, 0xEC,
  0xF1, 0x80, 0x70, 0x0F, 0x80, 0xC0, 0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8,
  0xCC, 0x66, 0x7F, 0x3F, 0xB8, 0xD8, 0x7C, 0x30, 0x1F, 0x1F, 0xCE, 0x66,
  0x33, 0x19, 0xF9, 0xFC, 0xC7, 0x61, 0xB1, 0xFF, 0xDF, 0xC0, 0x0F, 0x9F,
  0xCC, 0x2E, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3F, 0x8F, 0xC0,
  0x1E, 0x1F, 0xCC, 0xE6, 0x33, 0x1B, 0x8D, 0xC6, 0xC7, 0x63, 0xF3, 0xBF,
  0x9F, 0x80, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x30, 0x0F, 0xC3, 0xF1, 0xC0,
  0x60, 0x18, 0x07, 0xF3, 0xFC, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0F,
  0xE3, 0xF1, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x0F, 0x9F, 0xDC, 0x2C,
  0x0E, 0x06, 0x03, 0x0D, 0x8E, 0xC6, 0x63, 0x3F, 0x8F, 0xC0, 0x18, 0xCE,
  0x33, 0x0C, 0xC7, 0x31, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x38, 0xCC, 0x33,
  0x1C, 0x1F, 0xCF, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x0F, 0xF3, 0xFC, 0x0F, 0xC7, 0xF0, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x11, 0xCF, 0xE1, 0xF0, 0x18, 0xE7, 0x38, 0xEE, 0x1B,
  0x83, 0x60, 0xF8, 0x1F, 0x03, 0x70, 0x66, 0x1C, 0xE3, 0x8C, 0x61, 0x80,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xFF, 0xFF,
  0x0C, 0x63, 0x9C, 0x73, 0x8E, 0xF3, 0x56, 0x6E, 0x8D, 0xB1, 0xB6, 0x60,
  0xCC, 0x19, 0x86, 0x70, 0xC0, 0x18, 0xCE, 0x33, 0x8C, 0xF3, 0x3D, 0x9B,
  0x66, 0x59, 0x96, 0x67, 0x31, 0xCC, 0x73, 0x0C, 0x1E, 0x1F, 0x9C, 0xCC,
  0x7E, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x0F, 0x00, 0x1F, 0x07,
  0xE3, 0x9C, 0xC7, 0x31, 0xCC, 0x67, 0xF9, 0xF8, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0x1E, 0x1F, 0x9C, 0xCC, 0x7E, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x63,
  0x3F, 0x0F, 0x03, 0x01, 0xC0, 0x70, 0x1F, 0x1F, 0xCE, 0x66, 0x33, 0x1B,
  0x9D, 0xFC, 0xFC, 0x66, 0x33, 0xB8, 0xD8, 0x60, 0x0F, 0xC7, 0xE3, 0x08,
  0xC0, 0x38, 0x0F, 0x80, 0xF0, 0x1C, 0x03, 0x20, 0xCF, 0xF3, 0xF8, 0xFF,
  0xFF, 0x86, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C,
  0x00, 0x71, 0xB8, 0xD8, 0xEC, 0x66, 0x37, 0x1B, 0x1D, 0x8E, 0xC6, 0x63,
  0x3F, 0x1F, 0x80, 0xC3, 0xE1, 0xB0, 0xD8, 0xEC, 0x66, 0x73, 0x31, 0xB8,
  0xD8, 0x78, 0x3C, 0x1C, 0x00, 0x30, 0x66, 0x1C, 0xC3, 0x18, 0x66, 0x4C,
  0xD9, 0x1B, 0x63, 0xEC, 0x57, 0x9C, 0xE3, 0x9C, 0x63, 0x80, 0x1C, 0x70,
  0xC6, 0x0C, 0xC0, 0xF8, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x1B, 0x83,
  0x98, 0x71, 0x8E, 0x18, 0xC3, 0xE1, 0xB9, 0xCC, 0xC6, 0xC3, 0xE1, 0xE0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0xCF, 0xF0, 0x18, 0x0C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0F, 0xF3, 0xFC, 0x0F, 0x87, 0xC7,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0xF1, 0xF0, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x67, 0x77, 0x33, 0x1F,
  0x8F, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xC3, 0xE1, 0xF0, 0x0E, 0x0F, 0x07, 0x86, 0xE7, 0x37, 0x19,
  0x0E, 0xFF, 0xFF, 0x80, 0x4E, 0x70, 0x3F, 0x7F, 0xE7, 0xC7, 0xC6, 0xC6,
  0xC6, 0xFE, 0xFE, 0x18, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xCE, 0xE3,
  0x63, 0xB1, 0xD9, 0xDF, 0xCF, 0xC0, 0x1F, 0x7F, 0x70, 0xE0, 0xC0, 0xC0,
  0xC0, 0xFE, 0x7E, 0x01, 0x80, 0xC0, 0xE0, 0x71, 0xF3, 0xFB, 0x9D, 0x8E,
  0xC6, 0x63, 0x31, 0x9F, 0xCF, 0xE0, 0x3E, 0x7F, 0x63, 0xC7, 0xFE, 0xF8,
  0xC0, 0xFE, 0x7E, 0x01, 0xF0, 0x3E, 0x07, 0x00, 0x60, 0x1F, 0xC1, 0xFC,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0xF8, 0x0F, 0x00, 0x07, 0xC7, 0xF3, 0x8C, 0xC7, 0x31, 0x8C, 0x63, 0xF8,
  0xFE, 0x03, 0x00, 0xC7, 0xF3, 0xF0, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0xF1,
  0xFC, 0xCE, 0xE7, 0x73, 0x31, 0x98, 0xDC, 0xEE, 0x60, 0x1C, 0x38, 0x20,
  0x07, 0xDF, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0xF1, 0xE0, 0x01, 0xC0, 0x70,
  0x08, 0x00, 0x1F, 0x87, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x11, 0x87, 0xE3, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x39, 0xCC,
  0xE3, 0x70, 0xF8, 0x7C, 0x1F, 0x86, 0x61, 0x9C, 0xE3, 0x00, 0xFB, 0xE3,
  0x8C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x1F, 0x7C, 0x3F, 0xBF, 0xDB, 0x6D,
  0xB6, 0xDA, 0x4F, 0x0D, 0x86, 0xC3, 0x00, 0x3F, 0x1F, 0xCC, 0xEE, 0x77,
  0x33, 0x19, 0x8D, 0xCE, 0xE6, 0x00, 0x3E, 0x7F, 0xE7, 0xC3, 0xC7, 0xC7,
  0xC6, 0xFC, 0xF8, 0x1F, 0x87, 0xF1, 0x9C, 0xE3, 0x31, 0xCC, 0x73, 0x39,
  0xFC, 0x7E, 0x18, 0x06, 0x03, 0x80, 0x1F, 0x7F, 0x63, 0xC7, 0xC6, 0xC6,
  0xC6, 0xFE, 0x7E, 0x0C, 0x0C, 0x1C, 0x3F, 0x7F, 0x60, 0x60, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0x1F, 0x9F, 0x8C, 0x07, 0x01, 0xE0, 0x38, 0x0C, 0xFE,
  0xFE, 0x00, 0x04, 0x18, 0x18, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x7E, 0x3E, 0x63, 0x63, 0xE7, 0xE6, 0xC6, 0xC6, 0xCE, 0xFE, 0xFE, 0xE3,
  0xF1, 0xB9, 0xCC, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x70, 0x00, 0xC1, 0xE0,
  0xF6, 0x5B, 0x6B, 0xB5, 0x53, 0xB9, 0x9C, 0xCC, 0x00, 0x38, 0xE3, 0x38,
  0x3E, 0x07, 0x80, 0xE0, 0x1E, 0x06, 0xC1, 0x9C, 0xE1, 0x80, 0x1C, 0x70,
  0xC6, 0x0C, 0xE0, 0xCC, 0x0C, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x06, 0x00,
  0xE0, 0x7C, 0x0F, 0x80, 0x3F, 0x9F, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0,
  0xFE, 0xFE, 0x00, 0x07, 0x87, 0xC3, 0x01, 0x81, 0x80, 0xC0, 0x61, 0xE0,
  0xF0, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0xF0, 0x78, 0x1C, 0x71, 0x86,
  0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0x0F, 0x07, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x07, 0x83, 0x03, 0x81, 0x80, 0xC0,
  0x61, 0xE1, 0xF0, 0x38, 0xBE, 0xFB, 0xC8, 0xC0,
};

const GFXglyph UbuntuSansMono_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 12, 10, 2, -12 },
  { 10, 7, 5, 10, 3, -13 },
  { 15, 10, 12, 10, 0, -12 },
  { 30, 9, 15, 10, 0, -13 },
  { 47, 12, 12, 10, -1, -12 },
  { 65, 9, 12, 10, 0, -12 },
  { 79, 3, 6, 10, 5, -13 },
  { 82, 7, 17, 10, 2, -14 },
  { 97, 8, 17, 10, 0, -14 },
  { 114, 7, 8, 10, 2, -12 },
  { 121, 8, 8, 10, 1, -9 },
  { 129, 5, 6, 10, 1, -3 },
  { 133, 6, 2, 10, 2, -6 },
  { 135, 4, 3, 10, 2, -3 },
  { 137, 11, 16, 10, -1, -13 },
  { 159, 8, 12, 10, 1, -12 },
  { 171, 7, 12, 10, 1, -12 },
  { 182, 9, 12, 10, 0, -12 },
  { 196, 9, 12, 10, 0, -12 },
  { 210, 10, 12, 10, 0, -12 },
  { 225, 10, 12, 10, 0, -12 },
  { 240, 9, 12, 10, 1, -12 },
  { 254, 9, 12, 10, 2, -12 },
  { 268, 10, 12, 10, 0, -12 },
  { 283, 9, 12, 10, 0, -12 },
  { 297, 5, 9, 10, 2, -9 },
  { 303, 6, 12, 10, 1, -9 },
  { 312, 8, 8, 10, 1, -9 },
  { 320, 9, 6, 10, 0, -8 },
  { 327, 9, 8, 10, 0, -9 },
  { 336, 7, 12, 10, 2, -12 },
  { 347, 10, 15, 10, 0, -12 },
  { 366, 9, 12, 10, -1, -12 },
  { 380, 9, 12, 10, 0, -12 },
  { 394, 9, 12, 10, 1, -12 },
  { 408, 9, 12, 10, 0, -12 },
  { 422, 10, 12, 10, 0, -12 },
  { 437, 10, 12, 10, 0, -12 },
  { 452, 9, 12, 10, 1, -12 },
  { 466, 10, 12, 10, 0, -12 },
  { 481, 10, 12, 10, 0, -12 },
  { 496, 10, 12, 10, 0, -12 },
  { 511, 11, 12, 10, 0, -12 },
  { 528, 8, 12, 10, 0, -12 },
  { 540, 11, 12, 10, -1, -12 },
  { 557, 10, 12, 10, 0, -12 },
  { 572, 9, 12, 10, 1, -12 },
  { 586, 10, 12, 10, 0, -12 },
  { 601, 9, 15, 10, 1, -12 },
  { 618, 9, 12, 10, 0, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 9, 12, 10, 2, -12 },
  { 661, 9, 12, 10, 1, -12 },
  { 675, 9, 12, 10, 2, -12 },
  { 689, 11, 12, 10, 0, -12 },
  { 706, 12, 12, 10, -1, -12 },
  { 724, 9, 12, 10, 2, -12 },
  { 738, 10, 12, 10, 0, -12 },
  { 753, 9, 16, 10, 1, -13 },
  { 771, 4, 16, 10, 3, -13 },
  { 779, 9, 16, 10, 0, -13 },
  { 797, 9, 7, 10, 1, -12 },
  { 805, 9, 2, 10, -1, 1 },
  { 808, 4, 3, 10, 4, -13 },
  { 810, 8, 9, 10, 1, -9 },
  { 819, 9, 13, 10, 0, -13 },
  { 834, 8, 9, 10, 1, -9 },
  { 843, 9, 13, 10, 1, -13 },
  { 858, 8, 9, 10, 1, -9 },
  { 867, 12, 16, 10, -1, -13 },
  { 891, 10, 12, 10, -1, -9 },
  { 906, 9, 13, 10, 0, -13 },
  { 921, 7, 13, 10, 1, -13 },
  { 933, 10, 16, 10, -1, -13 },
  { 953, 10, 13, 10, 0, -13 },
  { 970, 6, 13, 10, 2, -13 },
  { 980, 9, 9, 10, 0, -9 },
  { 991, 9, 9, 10, 0, -9 },
  { 1002, 8, 9, 10, 1, -9 },
  { 1011, 10, 12, 10, -1, -9 },
  { 1026, 8, 12, 10, 1, -9 },
  { 1038, 8, 9, 10, 1, -9 },
  { 1047, 9, 9, 10, 0, -9 },
  { 1058, 8, 12, 10, 1, -12 },
  { 1070, 8, 9, 10, 1, -9 },
  { 1079, 9, 9, 10, 1, -9 },
  { 1090, 9, 9, 10, 1, -9 },
  { 1101, 11, 9, 10, -1, -9 },
  { 1114, 12, 12, 10, -2, -9 },
  { 1132, 9, 9, 10, 0, -9 },
  { 1143, 9, 16, 10, 1, -13 },
  { 1161, 6, 16, 10, 2, -13 },
  { 1173, 9, 16, 10, -1, -13 },
  { 1191, 9, 4, 10, 0, -7 },
};

const GFXfont UbuntuSansMono_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_BOLDITALIC17PT7B_H_
