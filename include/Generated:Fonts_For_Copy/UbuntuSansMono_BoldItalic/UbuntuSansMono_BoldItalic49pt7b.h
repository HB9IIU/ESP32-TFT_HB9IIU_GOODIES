#ifndef _UBUNTUSANSMONO_BOLDITALIC49PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x7F, 0x8F, 0xEF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x8F, 0xFF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE1, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xF8, 0x1F,
  0xE0, 0x0C, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0x00, 0x1F, 0xE1, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xC0,
  0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0x1E, 0x03, 0xE0, 0x0F, 0x0F, 0x03, 0xE0,
  0x07, 0x87, 0x83, 0xE0, 0x07, 0xC7, 0xC3, 0xE0, 0x03, 0xC3, 0xC1, 0xE0,
  0x01, 0xE1, 0xE1, 0xF0, 0x00, 0xF1, 0xF1, 0xF0, 0x00, 0x78, 0xF1, 0xF0,
  0x00, 0x3F, 0xF9, 0xF0, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x07, 0xF9, 0xF0,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF9, 0xFF, 0x00, 0x00, 0xF9,
  0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xC0, 0x00, 0x7C, 0xF9, 0xF0, 0x00, 0x7C,
  0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0x7C,
  0x1E, 0x1E, 0x00, 0x3E, 0x0F, 0x0F, 0x00, 0x3E, 0x07, 0x8F, 0x80, 0x3E,
  0x03, 0xC7, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0xFC, 0x0F, 0xFC, 0x1F, 0x03, 0xFF, 0xC3, 0xE1, 0xFD, 0xF8, 0xFC, 0x3F,
  0x3F, 0x9F, 0x0F, 0xC3, 0xFF, 0xE3, 0xF0, 0x3F, 0xF8, 0x7E, 0x07, 0xFF,
  0x0F, 0xC0, 0x7F, 0xC3, 0xF0, 0x07, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xBF, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xF0, 0xFE, 0x00, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x40, 0xFC, 0x01, 0xE3, 0xF0, 0xE7,
  0xC7, 0x8F, 0x9F, 0xDE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC1, 0xF8, 0x7E, 0x03,
  0xE1, 0xF0, 0x03, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xE3, 0xFF, 0x0F,
  0xF8, 0x3F, 0x80, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFC, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x78, 0x7E, 0xFC, 0x7E, 0x3F, 0x7E, 0x3F,
  0x1F, 0xBF, 0x1F, 0x9F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC7, 0xC7, 0xEF, 0xC3,
  0xC3, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x00, 0xE1, 0xFC, 0x02, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0x0F,
  0x00, 0x7F, 0x00, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x0F, 0xF0, 0x02, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x82, 0x00, 0x0F, 0xE0,
  0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x0F,
  0xE0, 0x3C, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xCF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFC, 0x07, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x78, 0x1F, 0xE2, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x1F,
  0xFE, 0x1F, 0x07, 0xFF, 0xE3, 0xE0, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF, 0xE3,
  0xE1, 0xFF, 0xFE, 0x7C, 0x3F, 0x87, 0xC7, 0xC3, 0xF0, 0xFC, 0x7C, 0x7E,
  0x0F, 0xC7, 0xC7, 0xE0, 0xFC, 0xF8, 0x7C, 0x0F, 0x8F, 0x87, 0xC1, 0xF8,
  0xF8, 0xFC, 0x1F, 0x8F, 0x8F, 0xC1, 0xF8, 0xF8, 0xFC, 0x1F, 0x0F, 0x8F,
  0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7F, 0xFE,
  0x0F, 0x87, 0xFF, 0xE0, 0xF8, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xE0, 0x7C,
  0x07, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE7, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0xC7,
  0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xF0, 0x1F, 0xE0, 0x04, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x1F, 0xF8, 0x7C, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8,
  0x3F, 0x83, 0xFF, 0x07, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xC1, 0xE0, 0x3F, 0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x04,
  0x00, 0x7F, 0x00, 0x70, 0x07, 0xF8, 0x03, 0xE0, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFD,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xF7, 0x87, 0xFC, 0x01, 0xF7,
  0x8F, 0xFC, 0x01, 0xF7, 0x8F, 0x7C, 0x01, 0xF7, 0x9F, 0x7C, 0x03, 0xE7,
  0x9E, 0xFC, 0x03, 0xE7, 0xBE, 0xF8, 0x03, 0xE7, 0xBC, 0xF8, 0x07, 0xE7,
  0xFC, 0xF8, 0x07, 0xE7, 0xF9, 0xF8, 0x07, 0xC7, 0xF9, 0xF8, 0x07, 0xC7,
  0xF1, 0xF0, 0x0F, 0xC7, 0xF1, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0x87,
  0xC3, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0,
  0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x81,
  0xF8, 0x07, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x07, 0xE0, 0x1F, 0xBE, 0x1F,
  0x80, 0x3F, 0x7C, 0x3F, 0x00, 0xFC, 0xF8, 0x7E, 0x01, 0xF9, 0xF0, 0xFC,
  0x03, 0xF1, 0xF3, 0xF0, 0x07, 0xE3, 0xE7, 0xE0, 0x1F, 0x87, 0xCF, 0xC0,
  0x3F, 0x0F, 0x9F, 0x80, 0x7E, 0x0F, 0x7E, 0x00, 0xFC, 0x1F, 0xFC, 0x03,
  0xF0, 0x3F, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xF8,
  0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xE7,
  0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xE3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x08, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x00, 0xFE, 0x07, 0xE0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x7C,
  0x3F, 0x01, 0xF0, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0xF8, 0x0F, 0xC7, 0xE1,
  0xF0, 0x1F, 0x1F, 0xC7, 0xE0, 0x3E, 0x3F, 0x8F, 0xC0, 0x7C, 0xF7, 0x9F,
  0x01, 0xF9, 0xEF, 0x3E, 0x03, 0xE7, 0x9E, 0xFC, 0x07, 0xCF, 0x3D, 0xF0,
  0x0F, 0xBC, 0x7B, 0xE0, 0x1F, 0x78, 0xF7, 0xC0, 0x3D, 0xE1, 0xEF, 0x80,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0x81, 0xFE,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0x00, 0x0F, 0xC7, 0x00, 0x07, 0x00,
  0x80, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x10,
  0x03, 0x80, 0x3E, 0x07, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFE, 0x03,
  0xE0, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xE1, 0xFF, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFE, 0x03,
  0xFF, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0x7F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0x07,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xF9, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0x07, 0xFE,
  0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xE3, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xE0, 0x07,
  0xFE, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x3F,
  0x80, 0x3F, 0x9F, 0x80, 0x3F, 0xCF, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x10, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x20, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC3, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x03, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x00, 0x04,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x1C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x20, 0x0F, 0xE0, 0x06, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xE3, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xBF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC7, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xF0, 0x03, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x3F, 0xFB, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7C, 0x7E, 0x3F,
  0x07, 0xC3, 0xE3, 0xF0, 0x7C, 0x3E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC,
  0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x7E, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0xFC, 0x3F,
  0x10, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF3, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80,
  0xFC, 0x0F, 0xF8, 0x1F, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0x90, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE3, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFB, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x18, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xF0, 0x1F, 0xC0, 0x08, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x04, 0x00, 0x3F, 0x87, 0xC0,
  0x7F, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x81, 0xFF, 0x0F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0xFF, 0x0F, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x0F, 0xF8, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E,
  0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1F, 0x87, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xE0, 0xF8, 0xFF,
  0x1F, 0x07, 0xC7, 0xF9, 0xF8, 0x3E, 0x7F, 0xCF, 0x81, 0xF3, 0xDE, 0x7C,
  0x0F, 0xBE, 0xF3, 0xC0, 0x7D, 0xE7, 0xBE, 0x03, 0xDF, 0x3D, 0xF0, 0x1E,
  0xF1, 0xEF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xC0, 0xFF, 0xC0, 0xFC,
  0x7F, 0xFC, 0x3E, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xF0, 0xFF, 0xF8, 0xF8, 0x0F, 0xFC, 0x1E, 0x01, 0xFE, 0x00, 0x00,
  0x08, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 15, 35, 27, 7, -34 },
  { 67, 19, 15, 27, 9, -37 },
  { 103, 29, 34, 27, 0, -34 },
  { 227, 26, 43, 27, 1, -38 },
  { 367, 33, 36, 27, -2, -35 },
  { 516, 27, 35, 27, 0, -35 },
  { 635, 10, 16, 27, 13, -37 },
  { 655, 22, 48, 27, 5, -39 },
  { 787, 22, 48, 27, 0, -39 },
  { 919, 22, 22, 27, 5, -34 },
  { 980, 24, 25, 27, 2, -27 },
  { 1055, 14, 17, 27, 3, -9 },
  { 1085, 16, 6, 27, 6, -17 },
  { 1097, 10, 10, 27, 7, -9 },
  { 1110, 33, 47, 27, -3, -38 },
  { 1304, 25, 36, 27, 2, -35 },
  { 1417, 22, 34, 27, 1, -34 },
  { 1511, 27, 35, 27, 0, -35 },
  { 1630, 27, 36, 27, 0, -35 },
  { 1752, 28, 34, 27, 0, -34 },
  { 1871, 28, 35, 27, 0, -34 },
  { 1994, 26, 35, 27, 2, -34 },
  { 2108, 27, 34, 27, 4, -34 },
  { 2223, 27, 36, 27, 1, -35 },
  { 2345, 26, 35, 27, 1, -35 },
  { 2459, 14, 27, 27, 7, -26 },
  { 2507, 18, 34, 27, 3, -26 },
  { 2584, 25, 24, 27, 2, -26 },
  { 2659, 27, 17, 27, 0, -23 },
  { 2717, 25, 24, 27, 1, -26 },
  { 2792, 21, 36, 27, 6, -35 },
  { 2887, 28, 42, 27, 1, -35 },
  { 3034, 26, 34, 27, -2, -34 },
  { 3145, 27, 34, 27, 0, -34 },
  { 3260, 26, 36, 27, 3, -35 },
  { 3377, 27, 34, 27, 0, -34 },
  { 3492, 28, 34, 27, 1, -34 },
  { 3611, 29, 34, 27, 1, -34 },
  { 3735, 27, 36, 27, 2, -35 },
  { 3857, 31, 34, 27, -1, -34 },
  { 3989, 30, 34, 27, 0, -34 },
  { 4117, 29, 35, 27, 0, -34 },
  { 4244, 31, 34, 27, 0, -34 },
  { 4376, 23, 34, 27, 0, -34 },
  { 4474, 32, 34, 27, -2, -34 },
  { 4610, 31, 34, 27, -1, -34 },
  { 4742, 26, 36, 27, 2, -35 },
  { 4859, 28, 34, 27, 0, -34 },
  { 4978, 26, 44, 27, 2, -35 },
  { 5121, 27, 34, 27, 0, -34 },
  { 5236, 28, 36, 27, 0, -35 },
  { 5362, 26, 34, 27, 5, -34 },
  { 5473, 28, 35, 27, 2, -34 },
  { 5596, 27, 34, 27, 5, -34 },
  { 5711, 31, 34, 27, 0, -34 },
  { 5843, 33, 34, 27, -2, -34 },
  { 5984, 26, 34, 27, 6, -34 },
  { 6095, 30, 34, 27, -1, -34 },
  { 6223, 27, 47, 27, 3, -38 },
  { 6382, 11, 47, 27, 9, -38 },
  { 6447, 26, 47, 27, -1, -38 },
  { 6600, 25, 20, 27, 2, -34 },
  { 6663, 26, 6, 27, -4, 3 },
  { 6683, 12, 10, 27, 11, -38 },
  { 6698, 26, 27, 27, 1, -26 },
  { 6786, 25, 39, 27, 0, -38 },
  { 6908, 25, 27, 27, 2, -26 },
  { 6993, 29, 39, 27, 1, -38 },
  { 7135, 25, 27, 27, 2, -26 },
  { 7220, 34, 47, 27, -4, -38 },
  { 7420, 29, 35, 27, -2, -26 },
  { 7547, 25, 38, 27, 0, -38 },
  { 7666, 19, 40, 27, 4, -39 },
  { 7761, 27, 48, 27, -2, -39 },
  { 7923, 28, 38, 27, 1, -38 },
  { 8056, 17, 39, 27, 6, -38 },
  { 8139, 28, 26, 27, -1, -26 },
  { 8230, 25, 26, 27, 0, -26 },
  { 8312, 24, 27, 27, 2, -26 },
  { 8393, 28, 35, 27, -2, -26 },
  { 8516, 25, 35, 27, 2, -26 },
  { 8626, 25, 26, 27, 2, -26 },
  { 8708, 25, 27, 27, 1, -26 },
  { 8793, 23, 34, 27, 4, -33 },
  { 8891, 25, 27, 27, 2, -26 },
  { 8976, 24, 26, 27, 4, -26 },
  { 9054, 29, 26, 27, 1, -26 },
  { 9149, 30, 26, 27, -2, -26 },
  { 9247, 32, 35, 27, -4, -26 },
  { 9387, 26, 26, 27, 1, -26 },
  { 9472, 27, 47, 27, 3, -38 },
  { 9631, 18, 47, 27, 5, -38 },
  { 9737, 26, 47, 27, -2, -38 },
  { 9890, 26, 11, 27, 1, -20 },
};

const GFXfont UbuntuSansMono_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic49pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUSANSMONO_BOLDITALIC49PT7B_H_
