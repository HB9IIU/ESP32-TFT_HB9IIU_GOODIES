#ifndef _UBUNTUSANSMONO_BOLDITALIC67PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC,
  0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F,
  0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC7,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC7, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xF0, 0x7C, 0x0F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x70, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xFB, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0xF3, 0xFC, 0x3F, 0xC1, 0xFF, 0x3F, 0x87, 0xF8, 0x0F,
  0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0xFF,
  0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFD, 0xFF,
  0x03, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x03,
  0xF8, 0x0E, 0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0xC7, 0xE3, 0xFC, 0x7F, 0xCF,
  0xCF, 0xF9, 0xFF, 0xDF, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8,
  0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x3F, 0x81, 0xFF, 0x0F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC,
  0x3F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x83, 0xC0, 0xFF, 0x7F, 0xC1, 0xF8, 0x3F, 0xDF, 0xF0, 0xFE,
  0x1F, 0xF7, 0xFC, 0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xE1, 0xFF, 0x7F, 0x87,
  0xF8, 0x7F, 0xBF, 0xE1, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0x0F, 0xFB, 0xFE,
  0x1F, 0xC3, 0xFE, 0xFF, 0x03, 0xC0, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xF9,
  0xFF, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x01, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x01, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x00, 0x7F,
  0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xC7, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0,
  0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xF1,
  0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF,
  0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xFC, 0x0F, 0xF1, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0xFF, 0x01,
  0xFC, 0x1F, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x20, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x07, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x40,
  0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xF7,
  0xC0, 0xFF, 0xF8, 0x01, 0xFD, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x7C, 0x1F,
  0xBF, 0x00, 0x1F, 0xDF, 0x07, 0xEF, 0xC0, 0x0F, 0xE7, 0xC3, 0xF7, 0xF0,
  0x03, 0xF9, 0xF0, 0xF9, 0xFC, 0x00, 0xFE, 0x7C, 0x7E, 0x7F, 0x00, 0x3F,
  0x9F, 0x1F, 0x1F, 0xC0, 0x1F, 0xC7, 0xEF, 0xCF, 0xE0, 0x07, 0xF1, 0xFB,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xFC, 0x7F,
  0x80, 0x3F, 0xC7, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x83,
  0xF8, 0x03, 0xFC, 0x0F, 0xC1, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF7, 0xE0,
  0x3F, 0xE0, 0x07, 0xFD, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x9F, 0xC0, 0xFF, 0x00, 0x1F, 0xE3, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x80, 0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x7F, 0x80, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0x80,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC1, 0xFC,
  0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xE3, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x7F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xFC, 0x3F, 0x80, 0x0F, 0xE3,
  0xFF, 0x87, 0xF0, 0x03, 0xFC, 0xFD, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xBE,
  0x3F, 0x80, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE3, 0xF7, 0xF0, 0x01,
  0xFD, 0xF8, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x0F, 0xDF, 0xC0, 0x07, 0xFF,
  0xC1, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFC, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x06, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x7F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x02, 0x07, 0xFF, 0x00,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xDF,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xE1, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00,
  0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x10, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x02, 0x03, 0xFF,
  0x83, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x13, 0xFF, 0xC3, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00,
  0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0,
  0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x20, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x80, 0x0E,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x01, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0x0F, 0xFF, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0x87, 0xF0, 0x3F,
  0x87, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0xF9, 0xFC, 0x03, 0xF1, 0xFB, 0xF3, 0xF8, 0x07,
  0xE7, 0xF7, 0xE7, 0xE0, 0x1F, 0xCF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x9F,
  0xBF, 0x80, 0x7F, 0x7E, 0x3F, 0x7E, 0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xC3, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x7F, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xE0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0x00, 0xFE,
  0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 21, 47, 38, 10, -46 },
  { 125, 27, 21, 38, 12, -51 },
  { 196, 40, 46, 38, 0, -46 },
  { 426, 36, 59, 38, 1, -52 },
  { 692, 46, 49, 38, -3, -48 },
  { 974, 36, 49, 38, 1, -48 },
  { 1195, 13, 22, 38, 18, -51 },
  { 1231, 30, 66, 38, 7, -53 },
  { 1479, 30, 66, 38, 0, -53 },
  { 1727, 31, 29, 38, 6, -46 },
  { 1840, 34, 34, 38, 2, -37 },
  { 1985, 19, 24, 38, 4, -13 },
  { 2042, 22, 9, 38, 8, -24 },
  { 2067, 14, 14, 38, 9, -13 },
  { 2092, 45, 64, 38, -4, -52 },
  { 2452, 34, 49, 38, 3, -48 },
  { 2661, 30, 46, 38, 2, -46 },
  { 2834, 37, 48, 38, 0, -48 },
  { 3056, 37, 49, 38, -1, -48 },
  { 3283, 38, 46, 38, 0, -46 },
  { 3502, 39, 47, 38, 0, -46 },
  { 3732, 36, 48, 38, 3, -47 },
  { 3948, 36, 46, 38, 6, -46 },
  { 4155, 36, 49, 38, 2, -48 },
  { 4376, 36, 48, 38, 1, -48 },
  { 4592, 19, 37, 38, 9, -36 },
  { 4680, 24, 47, 38, 4, -36 },
  { 4821, 34, 33, 38, 3, -36 },
  { 4962, 36, 22, 38, 1, -31 },
  { 5061, 34, 33, 38, 1, -36 },
  { 5202, 28, 49, 38, 9, -48 },
  { 5374, 38, 58, 38, 1, -48 },
  { 5650, 36, 46, 38, -3, -46 },
  { 5857, 37, 48, 38, 0, -47 },
  { 6079, 36, 49, 38, 4, -48 },
  { 6300, 37, 48, 38, 0, -47 },
  { 6522, 39, 46, 38, 1, -46 },
  { 6747, 40, 46, 38, 1, -46 },
  { 6977, 37, 49, 38, 3, -48 },
  { 7204, 42, 46, 38, -1, -46 },
  { 7446, 40, 46, 38, 0, -46 },
  { 7676, 39, 47, 38, 0, -46 },
  { 7906, 42, 46, 38, 0, -46 },
  { 8148, 30, 46, 38, 1, -46 },
  { 8321, 42, 46, 38, -2, -46 },
  { 8563, 42, 46, 38, -1, -46 },
  { 8805, 36, 49, 38, 2, -48 },
  { 9026, 39, 47, 38, 0, -47 },
  { 9256, 36, 61, 38, 2, -48 },
  { 9531, 37, 47, 38, 0, -47 },
  { 9749, 38, 49, 38, 0, -48 },
  { 9982, 35, 46, 38, 7, -46 },
  { 10184, 39, 47, 38, 2, -46 },
  { 10414, 36, 46, 38, 7, -46 },
  { 10621, 43, 46, 38, 0, -46 },
  { 10869, 46, 46, 38, -3, -46 },
  { 11134, 36, 46, 38, 8, -46 },
  { 11341, 41, 46, 38, -1, -46 },
  { 11577, 36, 64, 38, 4, -52 },
  { 11865, 14, 64, 38, 13, -52 },
  { 11977, 37, 64, 38, -2, -52 },
  { 12273, 34, 27, 38, 3, -46 },
  { 12388, 35, 8, 38, -5, 4 },
  { 12423, 16, 14, 38, 15, -52 },
  { 12451, 35, 37, 38, 2, -36 },
  { 12613, 35, 53, 38, 0, -52 },
  { 12845, 34, 37, 38, 3, -36 },
  { 13003, 39, 53, 38, 2, -52 },
  { 13262, 33, 37, 38, 3, -36 },
  { 13415, 47, 65, 38, -5, -52 },
  { 13797, 40, 49, 38, -3, -36 },
  { 14042, 35, 52, 38, 0, -52 },
  { 14270, 27, 54, 38, 5, -53 },
  { 14453, 38, 66, 38, -3, -53 },
  { 14767, 39, 52, 38, 1, -52 },
  { 15021, 23, 53, 38, 8, -52 },
  { 15174, 38, 36, 38, -1, -36 },
  { 15345, 35, 36, 38, 0, -36 },
  { 15503, 33, 37, 38, 2, -36 },
  { 15656, 38, 48, 38, -3, -36 },
  { 15884, 34, 48, 38, 3, -36 },
  { 16088, 35, 36, 38, 2, -36 },
  { 16246, 34, 37, 38, 1, -36 },
  { 16404, 32, 47, 38, 5, -46 },
  { 16592, 34, 36, 38, 3, -35 },
  { 16745, 34, 35, 38, 5, -35 },
  { 16894, 39, 35, 38, 2, -35 },
  { 17065, 40, 35, 38, -2, -35 },
  { 17240, 44, 48, 38, -6, -35 },
  { 17504, 36, 35, 38, 1, -35 },
  { 17662, 36, 64, 38, 5, -52 },
  { 17950, 24, 64, 38, 7, -52 },
  { 18142, 36, 64, 38, -3, -52 },
  { 18430, 36, 14, 38, 1, -27 },
};

const GFXfont UbuntuSansMono_BoldItalic67pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic67pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic67pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _UBUNTUSANSMONO_BOLDITALIC67PT7B_H_
