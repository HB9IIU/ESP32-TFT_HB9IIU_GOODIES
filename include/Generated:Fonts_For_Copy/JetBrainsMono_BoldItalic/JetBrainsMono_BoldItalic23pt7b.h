#ifndef _JETBRAINSMONO_BOLDITALIC23PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x07,
  0x3C, 0xF0, 0x63, 0xF3, 0xB9, 0xDC, 0xEE, 0x76, 0x3B, 0x18, 0x03, 0x0C,
  0x0C, 0x60, 0x31, 0x81, 0x86, 0x3F, 0xFC, 0xFF, 0xF0, 0xC3, 0x03, 0x18,
  0x0C, 0x60, 0x63, 0x81, 0x8C, 0x3F, 0xFC, 0xFF, 0xF0, 0xC6, 0x03, 0x18,
  0x18, 0x60, 0x63, 0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x7C, 0x1F, 0xF3,
  0xFF, 0x3B, 0x73, 0xB7, 0x3A, 0x03, 0xA0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7E, 0x04, 0xEE, 0x4E, 0xE4, 0xEF, 0x5C, 0x7F, 0xC3, 0xF0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x0F, 0x03, 0x8F, 0xC3, 0x06, 0x63, 0x86, 0x31, 0x83,
  0x19, 0x81, 0x8D, 0x80, 0xFD, 0x80, 0x1D, 0x80, 0x01, 0x80, 0x01, 0xD8,
  0x00, 0xDF, 0x00, 0xD9, 0x80, 0xCC, 0xC0, 0xCC, 0x60, 0xC6, 0x30, 0xC3,
  0xF0, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0x9C, 0x38, 0x61, 0xC4,
  0x0E, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xB9, 0xDC, 0xFC, 0xE7, 0xC6,
  0x1E, 0x30, 0xE1, 0xCF, 0x8F, 0xFC, 0x3E, 0x70, 0x77, 0x76, 0xEE, 0xE0,
  0x00, 0xC0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0xF8, 0x0E, 0x00, 0x80, 0x0C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x03, 0x00, 0x30, 0x03,
  0x06, 0x33, 0x72, 0xFF, 0xFF, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x9C, 0x71,
  0xC2, 0x18, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0xFF,
  0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3E, 0x70, 0xE3, 0x87, 0x1C,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xC1,
  0xFE, 0x3E, 0xF3, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77, 0x67, 0x77, 0x76,
  0x66, 0x60, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F, 0x00,
  0x03, 0xC1, 0xF8, 0x7E, 0x1D, 0xC3, 0x38, 0x47, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x70, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xEF, 0xFE,
  0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x3F, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1,
  0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xCE, 0x38, 0xE7, 0x0E, 0x60, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0x80,
  0x38, 0x03, 0x80, 0x37, 0xC3, 0xFE, 0x79, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xEE, 0x0E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0,
  0xEE, 0x06, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xFE, 0x0E, 0xE0, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x00,
  0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE1, 0xFC,
  0x0F, 0x83, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xFC,
  0x3F, 0x00, 0x0F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x6E, 0x06, 0xE0,
  0xEE, 0x1E, 0xFF, 0xC7, 0xFC, 0x13, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x18, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x8F,
  0x3C, 0xF0, 0x0E, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87,
  0xC7, 0xE1, 0xF0, 0x30, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xC0,
  0x04, 0x3F, 0xF3, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0xFF, 0xC0, 0x20, 0x07, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xC0,
  0x18, 0x1F, 0x0F, 0xCF, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x7E, 0x1F, 0xC7,
  0xF8, 0x0E, 0x01, 0xC0, 0x60, 0x38, 0xFE, 0x3F, 0x0F, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC3,
  0xCE, 0x07, 0x30, 0x0C, 0xC0, 0x37, 0x1E, 0xDC, 0xEF, 0x63, 0x19, 0x9C,
  0x66, 0x71, 0x99, 0x86, 0xE6, 0x3B, 0x9C, 0xEE, 0x7F, 0xB0, 0xEC, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xCE, 0x1C, 0x61, 0xC6, 0x38,
  0x63, 0xFE, 0x3F, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x70, 0x3F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x70, 0xE3, 0x87, 0x18, 0x39, 0xC3, 0x8F, 0xF8, 0x7F,
  0xC3, 0x8F, 0x1C, 0x38, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x8F, 0x1F, 0xF8,
  0xFF, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x77, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0xEE, 0x0E, 0xF1,
  0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73,
  0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0xE6, 0x0E, 0xE0, 0xEE,
  0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFC, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x77, 0x00, 0x70,
  0x07, 0x00, 0x73, 0xF7, 0x3E, 0x73, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1,
  0xC7, 0xF8, 0x3F, 0x00, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x87,
  0x18, 0x39, 0xC1, 0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x1C, 0x38, 0xE1, 0xCE,
  0x0E, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xE1, 0xC0, 0x1F, 0xF1, 0xFF, 0x3F,
  0xF0, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xEE, 0x06, 0x70, 0x71, 0xC7, 0x8F, 0xF8,
  0x3F, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xC7,
  0x07, 0x3C, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0x38, 0x18, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0x1C, 0x1C, 0x70, 0xF1,
  0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xDB, 0x63, 0x6D, 0x8D, 0xEE, 0x33, 0xB9,
  0xCC, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0xC1, 0xC6, 0x07, 0x18, 0x1C,
  0xE0, 0x70, 0x3C, 0x39, 0xE1, 0xCF, 0x0C, 0x78, 0x63, 0xE7, 0x3B, 0x39,
  0xD9, 0xCE, 0xCE, 0x76, 0x63, 0x3B, 0x19, 0xD8, 0xC6, 0xCE, 0x3E, 0x71,
  0xF3, 0x8F, 0x9C, 0x78, 0xC1, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87,
  0x38, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFC, 0x70, 0xF3, 0x83, 0x98, 0x1D, 0xC1, 0xCE, 0x0E, 0x7F, 0xE3, 0xFE,
  0x1F, 0x80, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x06, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3, 0xC7, 0xF8,
  0x3F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x70, 0xE3, 0x83, 0x98, 0x39, 0xC1, 0xCE, 0x1E, 0x7F, 0xE3, 0xFE,
  0x1C, 0xE0, 0xC7, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xE0,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x00, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x01, 0xCE, 0x0E, 0x70, 0x73, 0xC7,
  0x0F, 0xF8, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0C, 0x70,
  0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0xCF, 0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x3B,
  0x03, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x73,
  0x83, 0x9C, 0x1C, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x00, 0x63, 0x8D, 0x8E, 0x76, 0x39, 0x99, 0xE6, 0x67, 0x99, 0x96,
  0xE6, 0x53, 0x1B, 0x4C, 0x6D, 0x31, 0xA5, 0xCF, 0x96, 0x3E, 0x58, 0xF9,
  0x63, 0x47, 0x8F, 0x1C, 0x3C, 0xF0, 0xE3, 0xC0, 0x1C, 0x1E, 0x38, 0x78,
  0x70, 0xE0, 0x73, 0x80, 0xEF, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0x1C, 0x1E, 0x38,
  0x38, 0x38, 0xE0, 0x70, 0xE0, 0x3B, 0x83, 0x9C, 0x38, 0xE1, 0xC7, 0x1C,
  0x1C, 0xE0, 0xEE, 0x07, 0x60, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF3, 0xFF, 0x3F,
  0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x1F, 0xC7,
  0xE1, 0xF8, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0xF8, 0xFC,
  0x3F, 0x00, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07,
  0x1F, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3,
  0xF0, 0xFC, 0x3F, 0x00, 0x07, 0x03, 0xC0, 0xF8, 0x7E, 0x19, 0x8E, 0x67,
  0x1D, 0x87, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE3, 0x9E, 0x0F, 0x71, 0xFF,
  0x3F, 0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x1E,
  0xF3, 0xC7, 0xFC, 0x7D, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3B,
  0xC3, 0x7E, 0x7F, 0xE7, 0x8F, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E, 0xE0,
  0xEE, 0x0E, 0xF1, 0xCF, 0xFC, 0xEF, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7,
  0x07, 0x70, 0x77, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xF1, 0xC7,
  0xF8, 0x3F, 0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0xF7, 0x0F,
  0xF8, 0xFF, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xC1, 0xCE, 0x0E,
  0x70, 0xF3, 0xCF, 0x0F, 0xF8, 0x7D, 0xC0, 0x07, 0x81, 0xFE, 0x3C, 0xE7,
  0x06, 0x70, 0x67, 0x06, 0x7F, 0xEE, 0x00, 0xE0, 0x0E, 0x02, 0xF1, 0xC7,
  0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF7,
  0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xE7, 0x1E, 0x7E, 0xC3,
  0xDC, 0x01, 0xC0, 0x1C, 0x03, 0xC7, 0xF8, 0x7F, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3B, 0xC3, 0x7E, 0x7F, 0xE7, 0x8E, 0x70, 0x67, 0x0E,
  0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xC0, 0x01,
  0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x87, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0x9C, 0x39, 0xC3, 0x8E,
  0x38, 0x73, 0xC3, 0xFC, 0x1F, 0xC0, 0xFF, 0x06, 0x38, 0x71, 0xC3, 0x87,
  0x1C, 0x38, 0xE0, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFC, 0x7F,
  0x0F, 0xC0, 0x3B, 0x31, 0xBB, 0xCE, 0xEE, 0x66, 0x33, 0x33, 0xB9, 0x9D,
  0xCC, 0xEE, 0x66, 0x63, 0x33, 0x31, 0x99, 0x9D, 0xCC, 0xEE, 0x67, 0x00,
  0x3B, 0xC3, 0x7E, 0x7F, 0xE7, 0x8E, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xC0, 0x07, 0x81, 0xFE, 0x3F,
  0xE7, 0x0E, 0x70, 0x67, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF3,
  0xC7, 0xF8, 0x3F, 0x00, 0x1D, 0xE0, 0xDF, 0x8F, 0xFC, 0x78, 0xF3, 0x83,
  0x1C, 0x38, 0xE1, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x9E, 0x38, 0xFF, 0xC7,
  0x78, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x71, 0xFF, 0x3F,
  0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3,
  0xC7, 0xFC, 0x7D, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x3B, 0xC3,
  0xFF, 0x3F, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xFE, 0x3C, 0xF7, 0x07,
  0x70, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x0E, 0xE1, 0xEF, 0xFC,
  0x7F, 0x80, 0x0E, 0x01, 0xC0, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x0F, 0xE0, 0xFC,
  0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E,
  0xE0, 0xEE, 0x0E, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x1C, 0x61, 0xC7, 0x18, 0x73, 0x87, 0x30, 0x77, 0x07, 0x60, 0x3E,
  0x03, 0xC0, 0x3C, 0x00, 0xE3, 0x1F, 0x38, 0xF9, 0xCF, 0xCA, 0x6E, 0xF3,
  0x77, 0xBB, 0xAD, 0x9F, 0x6C, 0xFB, 0x67, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E,
  0x3C, 0x00, 0x38, 0x3C, 0x71, 0xE1, 0xC7, 0x03, 0xB8, 0x0F, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1C, 0x38, 0xF0,
  0xF0, 0x38, 0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xEE,
  0x0E, 0xE1, 0xE7, 0xBE, 0x7E, 0xC3, 0xDC, 0x01, 0xC0, 0x1C, 0x03, 0x87,
  0xF8, 0x7E, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x00,
  0xF0, 0x1F, 0x03, 0xF0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x38, 0x1C, 0x71, 0xC7, 0x1C,
  0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3,
  0x80, 0x0F, 0x00, 0xF8, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x7F, 0x01, 0xF0, 0x7F, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x1C, 0x07,
  0xE3, 0x7E, 0x3E, 0x7F, 0xE3, 0xE0, 0x18,
};

const GFXglyph JetBrainsMono_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 9, 7, 14, 4, -17 },
  { 22, 14, 17, 14, 0, -17 },
  { 52, 12, 23, 14, 1, -20 },
  { 87, 17, 17, 14, -1, -17 },
  { 124, 13, 17, 14, 0, -17 },
  { 152, 4, 7, 14, 6, -17 },
  { 156, 10, 22, 14, 3, -19 },
  { 184, 10, 22, 14, 1, -19 },
  { 212, 12, 12, 14, 1, -14 },
  { 230, 12, 11, 14, 1, -13 },
  { 247, 7, 7, 14, 2, -3 },
  { 254, 8, 3, 14, 3, -9 },
  { 257, 4, 4, 14, 4, -4 },
  { 259, 14, 22, 14, 0, -19 },
  { 298, 12, 17, 14, 1, -17 },
  { 324, 11, 17, 14, 1, -17 },
  { 348, 12, 17, 14, 1, -17 },
  { 374, 12, 17, 14, 1, -17 },
  { 400, 12, 17, 14, 1, -17 },
  { 426, 12, 17, 14, 1, -17 },
  { 452, 12, 17, 14, 1, -17 },
  { 478, 12, 17, 14, 2, -17 },
  { 504, 12, 17, 14, 1, -17 },
  { 530, 12, 17, 14, 2, -17 },
  { 556, 6, 13, 14, 4, -13 },
  { 566, 8, 17, 14, 2, -13 },
  { 583, 11, 13, 14, 2, -14 },
  { 601, 12, 9, 14, 1, -12 },
  { 615, 11, 13, 14, 1, -14 },
  { 633, 10, 17, 14, 3, -17 },
  { 655, 14, 21, 14, 0, -17 },
  { 692, 12, 17, 14, 0, -17 },
  { 718, 13, 17, 14, 1, -17 },
  { 746, 12, 17, 14, 1, -17 },
  { 772, 12, 17, 14, 1, -17 },
  { 798, 13, 17, 14, 1, -17 },
  { 826, 13, 17, 14, 1, -17 },
  { 854, 12, 17, 14, 1, -17 },
  { 880, 13, 17, 14, 1, -17 },
  { 908, 12, 17, 14, 1, -17 },
  { 934, 13, 17, 14, 0, -17 },
  { 962, 14, 17, 14, 1, -17 },
  { 992, 11, 17, 14, 1, -17 },
  { 1016, 14, 17, 14, 0, -17 },
  { 1046, 13, 17, 14, 1, -17 },
  { 1074, 12, 17, 14, 1, -17 },
  { 1100, 13, 17, 14, 1, -17 },
  { 1128, 12, 21, 14, 1, -17 },
  { 1160, 13, 17, 14, 1, -17 },
  { 1188, 13, 17, 14, 1, -17 },
  { 1216, 12, 17, 14, 2, -17 },
  { 1242, 13, 17, 14, 1, -17 },
  { 1270, 13, 17, 14, 2, -17 },
  { 1298, 14, 17, 14, 1, -17 },
  { 1328, 15, 17, 14, 0, -17 },
  { 1360, 13, 17, 14, 2, -17 },
  { 1388, 12, 17, 14, 1, -17 },
  { 1414, 10, 22, 14, 3, -19 },
  { 1442, 8, 22, 14, 3, -19 },
  { 1464, 10, 22, 14, 2, -19 },
  { 1492, 10, 9, 14, 2, -17 },
  { 1504, 11, 2, 14, 0, 1 },
  { 1507, 5, 3, 14, 6, -18 },
  { 1509, 12, 13, 14, 1, -13 },
  { 1529, 12, 17, 14, 1, -17 },
  { 1555, 12, 13, 14, 1, -13 },
  { 1575, 13, 17, 14, 1, -17 },
  { 1603, 12, 13, 14, 1, -13 },
  { 1623, 15, 21, 14, -1, -17 },
  { 1663, 12, 17, 14, 1, -13 },
  { 1689, 12, 17, 14, 1, -17 },
  { 1715, 11, 18, 14, 1, -18 },
  { 1740, 13, 22, 14, 0, -18 },
  { 1776, 13, 17, 14, 1, -17 },
  { 1804, 10, 17, 14, 2, -17 },
  { 1826, 13, 13, 14, 0, -13 },
  { 1848, 12, 13, 14, 1, -13 },
  { 1868, 12, 13, 14, 1, -13 },
  { 1888, 13, 17, 14, 0, -13 },
  { 1916, 12, 17, 14, 1, -13 },
  { 1942, 12, 13, 14, 1, -13 },
  { 1962, 12, 13, 14, 1, -13 },
  { 1982, 11, 16, 14, 2, -16 },
  { 2004, 12, 13, 14, 1, -13 },
  { 2024, 12, 13, 14, 2, -13 },
  { 2044, 13, 13, 14, 1, -13 },
  { 2066, 14, 13, 14, 0, -13 },
  { 2089, 12, 17, 14, 1, -13 },
  { 2115, 12, 13, 14, 1, -13 },
  { 2135, 12, 22, 14, 2, -19 },
  { 2168, 6, 22, 14, 4, -19 },
  { 2185, 12, 22, 14, 0, -19 },
  { 2218, 12, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_BOLDITALIC23PT7B_H_
