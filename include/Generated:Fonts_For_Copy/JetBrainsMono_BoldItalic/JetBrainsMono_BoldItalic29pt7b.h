#ifndef _JETBRAINSMONO_BOLDITALIC29PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xF8, 0x70, 0x71, 0xFE,
  0x3F, 0xC7, 0x78, 0xEF, 0x3D, 0xC7, 0xB8, 0xF7, 0x1C, 0xE3, 0x80, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06, 0x1C, 0x03, 0x87, 0x07, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0x60, 0x0C, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x38,
  0x70, 0x0E, 0x18, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1E, 0xCF, 0x3C, 0xCF, 0x3C, 0xC0, 0x3C, 0xC0, 0x3E, 0x80, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xBC, 0x01,
  0x1C, 0xF3, 0x1C, 0xF3, 0x3C, 0xFB, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x78,
  0x7F, 0x07, 0x07, 0x18, 0x30, 0x30, 0xC3, 0x01, 0x86, 0x38, 0x0C, 0x73,
  0x80, 0xE3, 0xB8, 0x03, 0xFB, 0x80, 0x1F, 0xB8, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC4, 0x00, 0x1D, 0xF8, 0x01, 0xDF, 0xE0, 0x1D, 0xC7,
  0x01, 0xCE, 0x38, 0x0C, 0x71, 0xC0, 0xC3, 0x0C, 0x0E, 0x1C, 0xE0, 0xE0,
  0xFE, 0x0E, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x27, 0x78, 0xE7, 0x9E, 0xF3, 0xC7, 0xF1, 0xC3,
  0xF0, 0xE0, 0xF8, 0x70, 0x78, 0x38, 0x7C, 0x1F, 0xFF, 0x0F, 0xFB, 0xC3,
  0xF9, 0xE0, 0x7B, 0xBD, 0xEF, 0x7B, 0x9C, 0xE0, 0x00, 0x08, 0x01, 0xC0,
  0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x08, 0x00, 0x08, 0x00, 0x38, 0x01,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x21, 0xC2, 0x79, 0xCF, 0x7D, 0xBF, 0xFF, 0xFE,
  0x01, 0x80, 0x03, 0xC0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x78,
  0x38, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38,
  0x0E, 0x39, 0x8E, 0x3B, 0xCE, 0x7B, 0xDE, 0x7B, 0xDE, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x1C, 0xF0,
  0x63, 0xC2, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x0E, 0x3C, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0xF0,
  0x73, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0xF0, 0x7F, 0xF8, 0xFF, 0xF3, 0xE1,
  0xF7, 0x81, 0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0xF0, 0x3C, 0xF0, 0xF1,
  0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E,
  0x1E, 0x1C, 0x1F, 0x7C, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0xF7,
  0x81, 0xEE, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0x70, 0x3C, 0xF0, 0xF9, 0xFF,
  0xE1, 0xFF, 0xC1, 0xEF, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x7C, 0xF9, 0xF1,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0x9F, 0x3E, 0x7C, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x00, 0x18, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x7C, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x87, 0xFE,
  0x7F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE3, 0xFC,
  0x3F, 0x83, 0xF0, 0x38, 0x03, 0x80, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0x78,
  0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE1, 0xF6, 0x38,
  0xFD, 0x9E, 0x79, 0xE7, 0x1C, 0x39, 0xC7, 0x0E, 0x71, 0xC3, 0x9C, 0x71,
  0xE7, 0x38, 0x71, 0xCE, 0x1C, 0xE3, 0x87, 0x38, 0xFF, 0xCE, 0x1F, 0x73,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x77, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x3C,
  0x70, 0x70, 0xE1, 0xE1, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x38, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1C, 0x1F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E,
  0x38, 0x7C, 0x3F, 0xF0, 0x3F, 0xF8, 0x78, 0xFC, 0x78, 0x3C, 0x78, 0x1E,
  0x78, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x3C, 0x70, 0x3C,
  0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0xFE, 0x79, 0xFE, 0x79, 0xFE, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0x78,
  0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0,
  0x38, 0xF0, 0x78, 0xF0, 0x78, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x3C,
  0x3E, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x07, 0x8F, 0x07,
  0x87, 0x83, 0xC3, 0x83, 0xC1, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x0E,
  0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x36, 0x1F, 0x9F, 0x87, 0xE6, 0xE1, 0xDB, 0xB8, 0xF6, 0xEE, 0x39, 0xB7,
  0x0E, 0x7D, 0xC3, 0x9E, 0x70, 0xE7, 0x9C, 0x38, 0x0F, 0x0E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xC0,
  0x78, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07,
  0x3B, 0x0F, 0x3B, 0x8F, 0x3B, 0x8E, 0x3B, 0x8E, 0x3B, 0x8E, 0x39, 0x8E,
  0x79, 0xDE, 0x79, 0xDE, 0x71, 0xDC, 0x71, 0xDC, 0x71, 0xDC, 0x70, 0xFC,
  0x70, 0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0xE0, 0xF8, 0xE0, 0x78, 0x03, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x83,
  0xE1, 0xC0, 0xF1, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C,
  0x3F, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x78,
  0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x1F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0x70,
  0xF0, 0x70, 0x70, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0x03,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C,
  0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78,
  0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xE7, 0x03,
  0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xE1, 0xE3, 0x83,
  0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0xE1, 0xDC, 0x38, 0xF7,
  0x1E, 0x39, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x36, 0x71, 0xCD,
  0x9C, 0x73, 0x67, 0x1C, 0xD9, 0x87, 0x66, 0xE1, 0xD9, 0xB8, 0x76, 0x6E,
  0x1F, 0x1B, 0x07, 0xC7, 0xC1, 0xB1, 0xF0, 0x6C, 0x7C, 0x1E, 0x1E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x00, 0x1E, 0x03, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07,
  0x81, 0xC1, 0xE0, 0x78, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x70,
  0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x38, 0xF0, 0x3D, 0xE0, 0x3D,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xDC, 0x0F, 0x70, 0x39, 0xC1, 0xC7, 0x0F, 0x0E, 0x38, 0x39, 0xE0, 0xEF,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE3, 0x8F, 0x07,
  0xCE, 0x3F, 0xDC, 0x7F, 0xF9, 0xE1, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07,
  0x3C, 0x0E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F,
  0xFF, 0x1F, 0xEE, 0x1F, 0xBC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x9F, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3E, 0x78, 0x3C,
  0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x38, 0x1E, 0x78,
  0x3D, 0xF0, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0x7E, 0x00, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x07, 0xCE, 0x1F, 0xEE, 0x1F, 0xFE, 0x3C, 0x3E, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x70,
  0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x7F, 0xB8, 0x3F, 0x78, 0x07, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF1, 0xE0, 0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBF, 0xFE,
  0x7F, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x27, 0x83, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xCE, 0x3F, 0xDC,
  0x7F, 0xF9, 0xE1, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x0E, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xFF, 0x87, 0xF7, 0x07, 0xCE,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x9F, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3E, 0x3E, 0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0xE7, 0x81,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0x70, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7,
  0x81, 0xCF, 0x07, 0x80, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x7C, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3C,
  0x1E, 0x3C, 0x0E, 0x3C, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0x80, 0x1D, 0xCF, 0x0D, 0xFF, 0x8F, 0x7D, 0xE7, 0x1C, 0xF3, 0x8E, 0x71,
  0xC6, 0x38, 0xE3, 0x1C, 0x73, 0x8E, 0x79, 0xC7, 0x38, 0xE7, 0x9C, 0x73,
  0xCE, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x73, 0xCE, 0x39, 0xE7, 0x3C, 0x3C,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07,
  0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0x3C, 0x0E, 0x78, 0x3C, 0x07, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE1,
  0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x1C, 0xE0, 0x79,
  0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x1E,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x7C,
  0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xCE, 0x3F, 0xDC, 0x7F, 0xF9, 0xE1,
  0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xE0, 0x79,
  0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x1F, 0xEE, 0x1F, 0xBC, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0xFC, 0x1D,
  0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xE0,
  0xF3, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xEF, 0x03, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03,
  0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0xC1, 0xE7,
  0x87, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0,
  0x73, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xE0,
  0x73, 0xC0, 0xF7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x8E, 0xE7,
  0x9C, 0xED, 0x9C, 0xED, 0x9C, 0xED, 0x98, 0xE9, 0xB8, 0xF9, 0xB8, 0xF9,
  0xB0, 0xD9, 0xF0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0x1E, 0x07, 0x8F,
  0x07, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x03, 0xEF, 0x01, 0xE7,
  0x81, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0x3C, 0x0E, 0x78, 0x3C, 0xF0,
  0x79, 0xC0, 0xF3, 0x81, 0xEF, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xE7, 0xE7, 0xFB, 0x87, 0xF7, 0x07, 0x9E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x3F, 0x07, 0x7F, 0x8E, 0x73,
  0xCE, 0x71, 0xFE, 0xF1, 0xFC, 0xE0, 0xF8,
};

const GFXglyph JetBrainsMono_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 5, -21 },
  { 22, 11, 9, 17, 5, -21 },
  { 35, 18, 21, 17, 0, -21 },
  { 83, 16, 29, 17, 1, -25 },
  { 141, 21, 21, 17, -1, -21 },
  { 197, 17, 21, 17, 0, -21 },
  { 242, 5, 9, 17, 8, -21 },
  { 248, 13, 29, 17, 4, -25 },
  { 296, 13, 29, 17, 1, -25 },
  { 344, 16, 15, 17, 1, -18 },
  { 374, 14, 13, 17, 2, -16 },
  { 397, 9, 9, 17, 2, -4 },
  { 408, 10, 3, 17, 4, -11 },
  { 412, 6, 5, 17, 5, -5 },
  { 416, 18, 27, 17, 0, -24 },
  { 477, 16, 21, 17, 1, -21 },
  { 519, 14, 21, 17, 1, -21 },
  { 556, 16, 21, 17, 1, -21 },
  { 598, 16, 21, 17, 1, -21 },
  { 640, 15, 21, 17, 1, -21 },
  { 680, 16, 21, 17, 1, -21 },
  { 722, 15, 21, 17, 1, -21 },
  { 762, 15, 21, 17, 3, -21 },
  { 802, 16, 21, 17, 1, -21 },
  { 844, 15, 21, 17, 2, -21 },
  { 884, 7, 16, 17, 5, -16 },
  { 898, 11, 21, 17, 2, -16 },
  { 927, 15, 15, 17, 2, -17 },
  { 956, 14, 11, 17, 2, -15 },
  { 976, 15, 15, 17, 1, -17 },
  { 1005, 12, 21, 17, 4, -21 },
  { 1037, 18, 26, 17, 0, -21 },
  { 1096, 15, 21, 17, 0, -21 },
  { 1136, 16, 21, 17, 1, -21 },
  { 1178, 16, 21, 17, 1, -21 },
  { 1220, 16, 21, 17, 1, -21 },
  { 1262, 16, 21, 17, 1, -21 },
  { 1304, 17, 21, 17, 1, -21 },
  { 1349, 16, 21, 17, 1, -21 },
  { 1391, 16, 21, 17, 1, -21 },
  { 1433, 16, 21, 17, 1, -21 },
  { 1475, 17, 21, 17, 0, -21 },
  { 1520, 17, 21, 17, 1, -21 },
  { 1565, 13, 21, 17, 2, -21 },
  { 1600, 18, 21, 17, 0, -21 },
  { 1648, 16, 21, 17, 1, -21 },
  { 1690, 16, 21, 17, 1, -21 },
  { 1732, 17, 21, 17, 1, -21 },
  { 1777, 16, 26, 17, 1, -21 },
  { 1829, 16, 21, 17, 1, -21 },
  { 1871, 16, 21, 17, 1, -21 },
  { 1913, 15, 21, 17, 3, -21 },
  { 1953, 16, 21, 17, 1, -21 },
  { 1995, 15, 21, 17, 3, -21 },
  { 2035, 18, 21, 17, 1, -21 },
  { 2083, 18, 21, 17, 0, -21 },
  { 2131, 16, 21, 17, 3, -21 },
  { 2173, 16, 21, 17, 1, -21 },
  { 2215, 12, 27, 17, 4, -24 },
  { 2256, 10, 27, 17, 4, -24 },
  { 2290, 13, 27, 17, 2, -24 },
  { 2334, 14, 11, 17, 2, -21 },
  { 2354, 14, 3, 17, 0, 1 },
  { 2360, 6, 4, 17, 7, -23 },
  { 2363, 15, 16, 17, 1, -16 },
  { 2393, 15, 21, 17, 1, -21 },
  { 2433, 15, 16, 17, 1, -16 },
  { 2463, 16, 21, 17, 1, -21 },
  { 2505, 15, 16, 17, 1, -16 },
  { 2535, 20, 26, 17, -2, -21 },
  { 2600, 15, 21, 17, 1, -16 },
  { 2640, 15, 21, 17, 1, -21 },
  { 2680, 14, 23, 17, 1, -23 },
  { 2721, 16, 28, 17, 0, -23 },
  { 2777, 17, 21, 17, 1, -21 },
  { 2822, 13, 21, 17, 2, -21 },
  { 2857, 17, 16, 17, 0, -16 },
  { 2891, 15, 16, 17, 1, -16 },
  { 2921, 15, 16, 17, 1, -16 },
  { 2951, 16, 21, 17, 0, -16 },
  { 2993, 15, 21, 17, 1, -16 },
  { 3033, 16, 16, 17, 1, -16 },
  { 3065, 15, 16, 17, 1, -16 },
  { 3095, 15, 20, 17, 2, -20 },
  { 3133, 15, 16, 17, 1, -16 },
  { 3163, 15, 16, 17, 2, -16 },
  { 3193, 16, 16, 17, 2, -16 },
  { 3225, 17, 16, 17, 0, -16 },
  { 3259, 15, 21, 17, 1, -16 },
  { 3299, 15, 16, 17, 1, -16 },
  { 3329, 16, 27, 17, 2, -24 },
  { 3383, 8, 27, 17, 5, -24 },
  { 3410, 15, 27, 17, 1, -24 },
  { 3461, 16, 7, 17, 1, -14 },
};

const GFXfont JetBrainsMono_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_BOLDITALIC29PT7B_H_
