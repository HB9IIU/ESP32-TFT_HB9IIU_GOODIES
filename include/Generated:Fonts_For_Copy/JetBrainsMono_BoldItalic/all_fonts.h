#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_BoldItalic
// Headers: 67

#include "JetBrainsMono_BoldItalic6pt7b.h"
#include "JetBrainsMono_BoldItalic7pt7b.h"
#include "JetBrainsMono_BoldItalic8pt7b.h"
#include "JetBrainsMono_BoldItalic9pt7b.h"
#include "JetBrainsMono_BoldItalic10pt7b.h"
#include "JetBrainsMono_BoldItalic11pt7b.h"
#include "JetBrainsMono_BoldItalic12pt7b.h"
#include "JetBrainsMono_BoldItalic13pt7b.h"
#include "JetBrainsMono_BoldItalic14pt7b.h"
#include "JetBrainsMono_BoldItalic15pt7b.h"
#include "JetBrainsMono_BoldItalic16pt7b.h"
#include "JetBrainsMono_BoldItalic17pt7b.h"
#include "JetBrainsMono_BoldItalic18pt7b.h"
#include "JetBrainsMono_BoldItalic19pt7b.h"
#include "JetBrainsMono_BoldItalic20pt7b.h"
#include "JetBrainsMono_BoldItalic21pt7b.h"
#include "JetBrainsMono_BoldItalic22pt7b.h"
#include "JetBrainsMono_BoldItalic23pt7b.h"
#include "JetBrainsMono_BoldItalic24pt7b.h"
#include "JetBrainsMono_BoldItalic25pt7b.h"
#include "JetBrainsMono_BoldItalic26pt7b.h"
#include "JetBrainsMono_BoldItalic27pt7b.h"
#include "JetBrainsMono_BoldItalic28pt7b.h"
#include "JetBrainsMono_BoldItalic29pt7b.h"
#include "JetBrainsMono_BoldItalic30pt7b.h"
#include "JetBrainsMono_BoldItalic31pt7b.h"
#include "JetBrainsMono_BoldItalic32pt7b.h"
#include "JetBrainsMono_BoldItalic33pt7b.h"
#include "JetBrainsMono_BoldItalic34pt7b.h"
#include "JetBrainsMono_BoldItalic35pt7b.h"
#include "JetBrainsMono_BoldItalic36pt7b.h"
#include "JetBrainsMono_BoldItalic37pt7b.h"
#include "JetBrainsMono_BoldItalic38pt7b.h"
#include "JetBrainsMono_BoldItalic39pt7b.h"
#include "JetBrainsMono_BoldItalic40pt7b.h"
#include "JetBrainsMono_BoldItalic41pt7b.h"
#include "JetBrainsMono_BoldItalic42pt7b.h"
#include "JetBrainsMono_BoldItalic43pt7b.h"
#include "JetBrainsMono_BoldItalic44pt7b.h"
#include "JetBrainsMono_BoldItalic45pt7b.h"
#include "JetBrainsMono_BoldItalic46pt7b.h"
#include "JetBrainsMono_BoldItalic47pt7b.h"
#include "JetBrainsMono_BoldItalic48pt7b.h"
#include "JetBrainsMono_BoldItalic49pt7b.h"
#include "JetBrainsMono_BoldItalic50pt7b.h"
#include "JetBrainsMono_BoldItalic51pt7b.h"
#include "JetBrainsMono_BoldItalic52pt7b.h"
#include "JetBrainsMono_BoldItalic53pt7b.h"
#include "JetBrainsMono_BoldItalic54pt7b.h"
#include "JetBrainsMono_BoldItalic55pt7b.h"
#include "JetBrainsMono_BoldItalic56pt7b.h"
#include "JetBrainsMono_BoldItalic57pt7b.h"
#include "JetBrainsMono_BoldItalic58pt7b.h"
#include "JetBrainsMono_BoldItalic59pt7b.h"
#include "JetBrainsMono_BoldItalic60pt7b.h"
#include "JetBrainsMono_BoldItalic61pt7b.h"
#include "JetBrainsMono_BoldItalic62pt7b.h"
#include "JetBrainsMono_BoldItalic63pt7b.h"
#include "JetBrainsMono_BoldItalic64pt7b.h"
#include "JetBrainsMono_BoldItalic65pt7b.h"
#include "JetBrainsMono_BoldItalic66pt7b.h"
#include "JetBrainsMono_BoldItalic67pt7b.h"
#include "JetBrainsMono_BoldItalic68pt7b.h"
#include "JetBrainsMono_BoldItalic69pt7b.h"
#include "JetBrainsMono_BoldItalic70pt7b.h"
#include "JetBrainsMono_BoldItalic71pt7b.h"
#include "JetBrainsMono_BoldItalic72pt7b.h"
