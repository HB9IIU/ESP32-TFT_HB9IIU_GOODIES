#ifndef _JETBRAINSMONO_BOLDITALIC35PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0xFC, 0x3C, 0x00, 0x78, 0x7B, 0xC7, 0xDE, 0x3F,
  0xF1, 0xFF, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x38,
  0x78, 0x00, 0x38, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3C, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x1E, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x0F, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xB3, 0xE1,
  0xF3, 0x1E, 0x1E, 0x31, 0xE1, 0xE3, 0x00, 0x1E, 0x30, 0x01, 0xF7, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xEF, 0xC0, 0x0C, 0x7C, 0x00, 0xC7, 0xC7, 0x8C,
  0x78, 0xF8, 0xC7, 0x87, 0xCC, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0xFE, 0x01, 0xE0,
  0x7F, 0xC0, 0x70, 0x1C, 0x70, 0x38, 0x0E, 0x1C, 0x1C, 0x03, 0x87, 0x0E,
  0x00, 0xE1, 0xC7, 0x00, 0x38, 0x73, 0xC0, 0x0E, 0x3D, 0xE0, 0x03, 0xFE,
  0x70, 0x00, 0x7F, 0x38, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x77, 0xFC,
  0x00, 0x3B, 0xC7, 0x00, 0x1C, 0xE1, 0xC0, 0x0E, 0x38, 0x70, 0x07, 0x0E,
  0x1C, 0x03, 0xC3, 0x87, 0x01, 0xE1, 0xE3, 0xC0, 0x70, 0x3F, 0xE0, 0x38,
  0x0F, 0xF0, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0x3E, 0xF1, 0xF3, 0xCF, 0x9E, 0x7C, 0x7B,
  0xC7, 0x87, 0xFC, 0x78, 0x3F, 0x87, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x83,
  0xF0, 0x7C, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xF7, 0xC1, 0xFC, 0x3E, 0x3C,
  0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80,
  0x04, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x04, 0x0E, 0x04, 0xF1, 0xC7, 0xBF, 0x33, 0xF7, 0xF6, 0xFF, 0x7F,
  0xFF, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x3C,
  0xF8, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x38, 0x3C, 0x02, 0x02, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xCF, 0x80,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x7D,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xE2, 0x1E, 0xF0,
  0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07,
  0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x78,
  0xF8, 0x38, 0x78, 0x10, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3E,
  0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x1E, 0x03, 0xDF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0xEF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF9, 0xC0, 0x7D, 0xFC, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xE0, 0xFD, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x00,
  0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE7, 0xF7, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF0, 0x0F, 0x1E, 0x03, 0xE7,
  0xC0, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF0, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C,
  0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF8,
  0x1F, 0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0xFB,
  0xE0, 0x7E, 0xFC, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7E, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x0F,
  0xC7, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xF8, 0xFE, 0x7F, 0x3F, 0x0F, 0x00, 0x00, 0xC0, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x18, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0x7E, 0x0F, 0x80, 0x78, 0x3C, 0x01,
  0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x7C, 0xE3,
  0xC3, 0xFB, 0x8F, 0x1F, 0xFE, 0x38, 0x78, 0x78, 0xE3, 0xC1, 0xC7, 0x8F,
  0x07, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0x83, 0xC7, 0x0E, 0x0F,
  0x1C, 0x78, 0x3C, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F, 0x0F, 0xEE, 0x3C,
  0x1F, 0x78, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3D, 0xC0, 0x0F, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0x03, 0xCF,
  0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x07, 0xE1,
  0xF0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x1E, 0x07, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xC0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF1, 0xFE, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x7F, 0x9E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E,
  0x07, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x1E, 0x03, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0,
  0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x7F, 0x7F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x78,
  0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x8F,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xB8, 0x3F,
  0x0F, 0xE0, 0xEC, 0x3F, 0x87, 0xB9, 0xDC, 0x1E, 0xE7, 0x70, 0x7B, 0xBB,
  0xC1, 0xEE, 0xEF, 0x07, 0xBF, 0x3C, 0x1C, 0xFC, 0xF0, 0xF1, 0xE3, 0xC3,
  0xC7, 0x9E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0xFC, 0x0F, 0x0F, 0xC0, 0xF0, 0xFC, 0x0F, 0x1F, 0xC1, 0xE1, 0xFC, 0x1E,
  0x1F, 0xC1, 0xE1, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xCE, 0x1E, 0x3C, 0xE3,
  0xC3, 0xCE, 0x3C, 0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0x73, 0xC3, 0xC7,
  0x3C, 0x7C, 0x73, 0x87, 0x87, 0xB8, 0x78, 0x7F, 0x87, 0x87, 0xF8, 0x78,
  0x3F, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x8F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01,
  0xF7, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9,
  0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1F, 0x3E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0x07, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x7C,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3C, 0x7C,
  0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE1,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x78, 0xF8, 0x07, 0x87, 0xC0, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x78,
  0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x1F, 0x01,
  0xE3, 0xE0, 0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3F, 0xBF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF3,
  0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78,
  0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x78, 0x7B, 0xC3, 0xC3,
  0xDE, 0x1E, 0x1C, 0xF1, 0xB1, 0xE7, 0x0F, 0x8F, 0x38, 0x7C, 0x79, 0xC7,
  0xE3, 0x8E, 0x3F, 0x3C, 0x71, 0xB9, 0xE3, 0x8D, 0x8F, 0x1C, 0xEC, 0x71,
  0xE6, 0x63, 0x8F, 0x33, 0x3C, 0x7B, 0x99, 0xC3, 0xDC, 0xCE, 0x1E, 0xC6,
  0x70, 0xF6, 0x37, 0x87, 0xF1, 0xB8, 0x3B, 0x8D, 0xC1, 0xD8, 0x6E, 0x0E,
  0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E,
  0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0xF8,
  0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x03, 0xC0, 0xF8, 0x01, 0xF7, 0x80, 0x3E,
  0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3E, 0x1F,
  0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1E, 0x1C, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF1,
  0xF0, 0x00, 0x80, 0x01, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F,
  0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xE0,
  0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0xC0, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0xFC, 0xFC,
  0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07,
  0x9F, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x07, 0xC7,
  0xF7, 0xF1, 0xFF, 0xF8, 0xFB, 0xFC, 0x3E, 0x7E, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x03, 0xE7, 0xC0,
  0x79, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFE, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x20, 0xF0, 0x3F,
  0xBE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0x7E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01,
  0xE3, 0xE0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x7E, 0x3F, 0xBF,
  0x87, 0xFF, 0xF0, 0x7F, 0xDE, 0x07, 0xF7, 0xC0, 0x00, 0x70, 0x03, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0xFC, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFD, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0x1F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9E,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0xC3,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xF7, 0x80, 0xF1, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x80, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF,
  0xF1, 0xF8, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x78,
  0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07,
  0xC0, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x1E, 0x03, 0xE1,
  0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x7C,
  0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0x81,
  0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x20,
  0x81, 0xEF, 0x3E, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E, 0x38, 0xF1, 0xC3,
  0x8F, 0x3C, 0x38, 0xF3, 0xC7, 0x8F, 0x3C, 0x70, 0xE3, 0xC7, 0x1E, 0x3C,
  0x71, 0xE3, 0x87, 0x1E, 0x78, 0x71, 0xE7, 0x8F, 0x1E, 0x78, 0xE1, 0xE7,
  0x8E, 0x1C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x70, 0xE3, 0xCF, 0x1E, 0x3C,
  0x00, 0x08, 0x07, 0x9F, 0xC1, 0xEF, 0xF8, 0x7F, 0xFF, 0x1F, 0x8F, 0xCF,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3E,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0x00, 0x70, 0x03,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xE0, 0x7D, 0xF0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x80,
  0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x01, 0xE7, 0xF0, 0x3D, 0xFF, 0x07,
  0xFF, 0xF0, 0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E,
  0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C,
  0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3F, 0xBF, 0x87, 0xFF, 0xE1, 0xF7,
  0xF8, 0x3E, 0x7E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFD, 0xF1, 0xFF,
  0x7C, 0x7F, 0xFE, 0x3F, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E,
  0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C,
  0x07, 0xCF, 0x01, 0xF3, 0xE0, 0xF8, 0xFE, 0xFE, 0x3F, 0xF7, 0x87, 0xFD,
  0xE0, 0xFC, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x08, 0x07, 0x9F, 0xC1, 0xFF, 0xF8,
  0xF7, 0xFF, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C,
  0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7B,
  0xE0, 0x3E, 0x7C, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0xF9,
  0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0E, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF, 0x3F,
  0x1C, 0xF3, 0x73, 0xCF, 0x37, 0x38, 0xF7, 0x73, 0x8F, 0x77, 0x78, 0xF6,
  0x77, 0x0F, 0x67, 0x70, 0xEE, 0x7F, 0x0E, 0xC7, 0xE0, 0xEC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x1F, 0x01,
  0xF8, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x00, 0x7C,
  0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF0,
  0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x1F, 0xC7, 0xFF, 0xE1, 0xFF, 0x78,
  0x3F, 0x9E, 0x01, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x3F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xDF, 0xF0, 0xF7, 0xFC, 0x3F, 0xCF,
  0x8F, 0xF1, 0xFF, 0xBC, 0x3F, 0xEE, 0x07, 0xF0, 0x00, 0x70,
};

const GFXglyph JetBrainsMono_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 13, 11, 21, 6, -26 },
  { 49, 22, 26, 21, 0, -26 },
  { 121, 20, 35, 21, 1, -30 },
  { 209, 26, 26, 21, -2, -26 },
  { 294, 20, 26, 21, 0, -26 },
  { 359, 6, 11, 21, 9, -26 },
  { 368, 15, 34, 21, 5, -30 },
  { 432, 15, 34, 21, 2, -30 },
  { 496, 19, 18, 21, 2, -21 },
  { 539, 18, 17, 21, 2, -20 },
  { 578, 10, 11, 21, 3, -5 },
  { 592, 12, 4, 21, 5, -14 },
  { 598, 7, 6, 21, 6, -6 },
  { 604, 22, 33, 21, 0, -29 },
  { 695, 18, 26, 21, 2, -26 },
  { 754, 17, 26, 21, 1, -26 },
  { 810, 19, 26, 21, 1, -26 },
  { 872, 19, 26, 21, 1, -26 },
  { 934, 18, 26, 21, 2, -26 },
  { 993, 18, 26, 21, 2, -26 },
  { 1052, 18, 26, 21, 1, -26 },
  { 1111, 19, 26, 21, 3, -26 },
  { 1173, 19, 26, 21, 1, -26 },
  { 1235, 18, 26, 21, 3, -26 },
  { 1294, 9, 20, 21, 6, -20 },
  { 1317, 12, 26, 21, 3, -20 },
  { 1356, 17, 19, 21, 3, -21 },
  { 1397, 17, 13, 21, 2, -18 },
  { 1425, 18, 19, 21, 1, -21 },
  { 1468, 16, 26, 21, 4, -26 },
  { 1520, 22, 32, 21, 0, -26 },
  { 1608, 18, 26, 21, 0, -26 },
  { 1667, 20, 26, 21, 1, -26 },
  { 1732, 18, 26, 21, 2, -26 },
  { 1791, 19, 26, 21, 1, -26 },
  { 1853, 19, 26, 21, 2, -26 },
  { 1915, 20, 26, 21, 1, -26 },
  { 1980, 18, 26, 21, 2, -26 },
  { 2039, 20, 26, 21, 1, -26 },
  { 2104, 18, 26, 21, 2, -26 },
  { 2163, 20, 26, 21, 0, -26 },
  { 2228, 21, 26, 21, 1, -26 },
  { 2297, 16, 26, 21, 2, -26 },
  { 2349, 22, 26, 21, 0, -26 },
  { 2421, 20, 26, 21, 1, -26 },
  { 2486, 18, 26, 21, 2, -26 },
  { 2545, 20, 26, 21, 1, -26 },
  { 2610, 18, 32, 21, 2, -26 },
  { 2682, 20, 26, 21, 1, -26 },
  { 2747, 20, 26, 21, 1, -26 },
  { 2812, 19, 26, 21, 3, -26 },
  { 2874, 19, 26, 21, 2, -26 },
  { 2936, 18, 26, 21, 4, -26 },
  { 2995, 21, 26, 21, 2, -26 },
  { 3064, 23, 26, 21, -1, -26 },
  { 3139, 20, 26, 21, 3, -26 },
  { 3204, 19, 26, 21, 1, -26 },
  { 3266, 15, 33, 21, 4, -29 },
  { 3328, 12, 33, 21, 5, -29 },
  { 3378, 15, 33, 21, 3, -29 },
  { 3440, 16, 14, 21, 3, -26 },
  { 3468, 17, 4, 21, 0, 1 },
  { 3477, 7, 4, 21, 9, -27 },
  { 3481, 18, 20, 21, 2, -20 },
  { 3526, 18, 26, 21, 1, -26 },
  { 3585, 18, 20, 21, 2, -20 },
  { 3630, 19, 26, 21, 2, -26 },
  { 3692, 17, 20, 21, 2, -20 },
  { 3735, 24, 32, 21, -2, -26 },
  { 3831, 18, 26, 21, 2, -20 },
  { 3890, 18, 26, 21, 1, -26 },
  { 3949, 18, 28, 21, 1, -28 },
  { 4012, 19, 34, 21, 0, -28 },
  { 4093, 20, 26, 21, 1, -26 },
  { 4158, 16, 26, 21, 3, -26 },
  { 4210, 20, 20, 21, 0, -20 },
  { 4260, 18, 20, 21, 1, -20 },
  { 4305, 17, 20, 21, 2, -20 },
  { 4348, 19, 26, 21, 0, -20 },
  { 4410, 18, 26, 21, 2, -20 },
  { 4469, 18, 20, 21, 2, -20 },
  { 4514, 18, 20, 21, 1, -20 },
  { 4559, 18, 25, 21, 2, -25 },
  { 4616, 18, 19, 21, 2, -19 },
  { 4659, 18, 19, 21, 3, -19 },
  { 4702, 20, 19, 21, 2, -19 },
  { 4750, 21, 19, 21, 0, -19 },
  { 4800, 18, 25, 21, 2, -19 },
  { 4857, 18, 19, 21, 1, -19 },
  { 4900, 18, 33, 21, 3, -29 },
  { 4975, 10, 33, 21, 6, -29 },
  { 5017, 18, 33, 21, 1, -29 },
  { 5092, 18, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_BOLDITALIC35PT7B_H_
