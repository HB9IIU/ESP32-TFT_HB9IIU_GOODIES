#ifndef _JETBRAINSMONO_BOLDITALIC48PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x03, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xB9, 0xFC, 0x0F, 0xE7, 0x1F, 0xC1, 0xF8, 0xE1, 0xF8,
  0x7F, 0x1C, 0x3F, 0x0F, 0xC3, 0x88, 0x01, 0xF8, 0x70, 0x00, 0x3F, 0x9E,
  0x00, 0x07, 0xF3, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xE7, 0xF0, 0x00,
  0x1C, 0x7F, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0xE1, 0xFC, 0x00, 0x1C, 0x3F,
  0x0F, 0xC3, 0x87, 0xE1, 0xF8, 0x70, 0xFC, 0x3F, 0x8E, 0x3F, 0x87, 0xF9,
  0xCF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xC0,
  0x3F, 0xF0, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0xF0, 0x0F, 0xDF, 0x80, 0x78,
  0x07, 0xC1, 0xE0, 0x3E, 0x01, 0xE0, 0x78, 0x1F, 0x00, 0x78, 0x1E, 0x0F,
  0x80, 0x1E, 0x07, 0x87, 0xC0, 0x07, 0x83, 0xE1, 0xE0, 0x01, 0xE0, 0xF0,
  0xF0, 0x00, 0xF8, 0x3C, 0x78, 0x00, 0x3E, 0x1F, 0x3C, 0x00, 0x07, 0xFF,
  0x9F, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xE7, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0xF0,
  0x00, 0x07, 0xCF, 0xFE, 0x00, 0x01, 0xE7, 0xFF, 0x80, 0x00, 0xF3, 0xE1,
  0xF0, 0x00, 0x78, 0xF0, 0x7C, 0x00, 0x3C, 0x3C, 0x1F, 0x00, 0x1F, 0x1F,
  0x07, 0x80, 0x0F, 0x87, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x03, 0xE0,
  0x78, 0x1E, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0xFF, 0xC0, 0x3C,
  0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x03, 0xF3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFE,
  0x0F, 0x80, 0xFF, 0x83, 0xF0, 0x1F, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xF8, 0xFC, 0x0F, 0xFC,
  0x1F, 0x80, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0x00, 0xF0, 0x18, 0xF8,
  0x3C, 0x3E, 0x7F, 0x0E, 0x1F, 0xDF, 0xF3, 0x9F, 0xFF, 0xFE, 0xDF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xF0, 0x1F, 0x00, 0x38, 0x07, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04,
  0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x78, 0x7E, 0x3F, 0x3F, 0x1F, 0x0F, 0xCF, 0xC7, 0xC3, 0xF3,
  0xF3, 0xF0, 0xF8, 0xFC, 0xFC, 0x3E, 0x1E, 0x3F, 0x1F, 0x83, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0x7E, 0x03, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x1C,
  0x0F, 0xC0, 0x30, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE7, 0xFE,
  0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF1, 0x80, 0x0F, 0xEF, 0xF0, 0x0F, 0xDF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC,
  0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xEF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x01,
  0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x20, 0xF8, 0x7C, 0x07, 0xF3, 0xE1, 0xF0, 0x3F, 0xEF, 0x87,
  0xC1, 0xFF, 0xBE, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0,
  0xF8, 0x1F, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x7C,
  0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x1F, 0x03,
  0xE1, 0xF0, 0xF8, 0x0F, 0x87, 0xC3, 0xE0, 0x3E, 0x1F, 0x0F, 0x81, 0xF8,
  0x7C, 0x3F, 0x07, 0xE1, 0xE0, 0xFE, 0x7F, 0x0F, 0x81, 0xFF, 0xBC, 0x3E,
  0x07, 0xFC, 0xF0, 0xF8, 0x0F, 0xE7, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF9, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0xE3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F,
  0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC7, 0xE0, 0xFF, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0xC1, 0xFF, 0x07, 0xBC, 0x0F,
  0x78, 0x7F, 0xE0, 0x79, 0xE3, 0xDF, 0x07, 0xCF, 0x1E, 0xF8, 0x3E, 0x79,
  0xE7, 0xC1, 0xF3, 0xCF, 0x7E, 0x0F, 0x9E, 0xF3, 0xE0, 0x7C, 0xF7, 0x9F,
  0x03, 0xE7, 0xF8, 0xF8, 0x3F, 0x1F, 0xC7, 0xC1, 0xF8, 0xFE, 0x7E, 0x0F,
  0xC7, 0xE3, 0xF0, 0x7E, 0x3F, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xFC, 0x03, 0xE0,
  0x7F, 0xC0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC,
  0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xC0, 0xFB, 0xE0, 0x7C,
  0x0F, 0xBE, 0x07, 0xC0, 0xF9, 0xE0, 0xFC, 0x0F, 0x9F, 0x0F, 0xC0, 0xF9,
  0xF0, 0xFC, 0x0F, 0x9F, 0x0F, 0x81, 0xF9, 0xF0, 0xF8, 0x1F, 0x8F, 0x0F,
  0x81, 0xF8, 0xF0, 0xF8, 0x1F, 0x0F, 0x9F, 0x81, 0xF0, 0xF9, 0xF8, 0x1F,
  0x0F, 0x9F, 0x83, 0xF0, 0xF9, 0xF0, 0x3F, 0x07, 0x9F, 0x03, 0xF0, 0x7D,
  0xF0, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x07, 0xDF, 0x03,
  0xE0, 0x3D, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x03,
  0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xC0,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xF0, 0x07,
  0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0xFF, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C, 0x1F,
  0x83, 0xF3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0xF8, 0x7F, 0x07,
  0xC7, 0xC3, 0xB8, 0x7C, 0x3E, 0x1D, 0xC3, 0xE1, 0xF0, 0xEE, 0x1F, 0x0F,
  0x8F, 0x70, 0xF8, 0x78, 0x73, 0x87, 0x83, 0xC3, 0x9C, 0x7C, 0x3E, 0x1C,
  0xE3, 0xE1, 0xF1, 0xE7, 0x1F, 0x0F, 0x8E, 0x78, 0xF0, 0x7C, 0x73, 0xCF,
  0x83, 0xE7, 0x9E, 0x7C, 0x1F, 0x38, 0xF3, 0xE0, 0xF9, 0xC7, 0x9E, 0x07,
  0xCE, 0x39, 0xF0, 0x3E, 0xF1, 0xCF, 0x81, 0xF7, 0x0E, 0x78, 0x0F, 0xB8,
  0x73, 0xC0, 0x7B, 0xC3, 0xBE, 0x03, 0xDE, 0x1D, 0xF0, 0x1E, 0xE0, 0xEF,
  0x00, 0xF7, 0x07, 0x78, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xE3, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x7F, 0x8E, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE,
  0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xFC,
  0x07, 0xE7, 0xFF, 0x03, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xE0,
  0x7E, 0xFF, 0xE0, 0x3F, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xCF, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0xF3, 0xF0, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xEF,
  0xC0, 0xFF, 0xFD, 0xF8, 0x1F, 0xE3, 0xBE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0xF8, 0x03,
  0xFF, 0xBF, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xCF,
  0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x7F, 0x8E,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF0, 0x3F, 0xF9, 0xF8, 0x0F, 0xF9, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xFC, 0x07, 0xE7, 0xFF, 0x03, 0xF7, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x21, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x10, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x07, 0x80, 0xF9, 0xF8, 0xFC, 0x0F,
  0xBF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xEF, 0xE7, 0xF0, 0xF8, 0x7C,
  0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0x83, 0xE1,
  0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x7E, 0x1F, 0x0F,
  0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x07, 0xC3, 0xF0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7E, 0x1E, 0x0F, 0x87, 0xE1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F,
  0x87, 0xC1, 0xE1, 0xF8, 0x7C, 0x1E, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC,
  0x3E, 0x1F, 0x00, 0x00, 0x43, 0xE0, 0x07, 0xC7, 0xFC, 0x07, 0xE7, 0xFF,
  0x03, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x10, 0xFC, 0x00, 0x7C, 0x7F, 0xC0, 0x1F, 0x9F, 0xFC, 0x03,
  0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F,
  0xF8, 0x07, 0xEF, 0xFE, 0x00, 0xFC, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0xFF, 0xF7,
  0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x7F, 0x8E, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x0F, 0xFE, 0xFC,
  0x03, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF1, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x3F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x08, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xE0, 0x7B, 0xE0, 0xFC,
  0x1F, 0x7C, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x79, 0xF0, 0xEE, 0x1F, 0x3E,
  0x1D, 0xC3, 0xE7, 0xC3, 0xB8, 0x78, 0xF8, 0xE7, 0x1F, 0x1F, 0x1C, 0xE3,
  0xE3, 0xE3, 0x9C, 0x78, 0x7C, 0xE3, 0x9F, 0x0F, 0x9C, 0x73, 0xE1, 0xF3,
  0x8E, 0x7C, 0x3E, 0xF1, 0xCF, 0x07, 0xDC, 0x3B, 0xE0, 0xFB, 0x8F, 0x7C,
  0x1E, 0xF1, 0xEF, 0x03, 0xDC, 0x3F, 0xE0, 0x7B, 0x87, 0xFC, 0x0F, 0x70,
  0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE1,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xC1, 0xFF, 0xE7, 0xE0, 0x7F,
  0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xF1, 0xFF, 0xC0,
  0xFC, 0xFF, 0xF0, 0x3E, 0x3F, 0xFE, 0x0F, 0x9F, 0x9F, 0xC3, 0xE7, 0xC3,
  0xF9, 0xF9, 0xF0, 0x7F, 0xFC, 0x7C, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0x8F,
  0x80, 0x7F, 0xC0, 0x00, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 35, 29, 9, -35 },
  { 54, 18, 14, 29, 8, -35 },
  { 86, 29, 35, 29, 1, -35 },
  { 213, 27, 49, 29, 1, -42 },
  { 379, 34, 35, 29, -2, -35 },
  { 528, 27, 36, 29, 1, -36 },
  { 650, 8, 14, 29, 13, -35 },
  { 664, 21, 47, 29, 7, -41 },
  { 788, 21, 47, 29, 2, -41 },
  { 912, 26, 25, 29, 2, -29 },
  { 994, 24, 23, 29, 3, -27 },
  { 1063, 14, 15, 29, 4, -7 },
  { 1090, 17, 6, 29, 6, -19 },
  { 1103, 10, 9, 29, 8, -9 },
  { 1115, 30, 45, 29, 0, -40 },
  { 1284, 26, 36, 29, 2, -36 },
  { 1401, 23, 35, 29, 2, -35 },
  { 1502, 26, 36, 29, 2, -36 },
  { 1619, 25, 35, 29, 2, -35 },
  { 1729, 25, 35, 29, 2, -35 },
  { 1839, 26, 35, 29, 2, -35 },
  { 1953, 24, 35, 29, 2, -35 },
  { 2058, 25, 35, 29, 5, -35 },
  { 2168, 26, 36, 29, 2, -36 },
  { 2285, 24, 36, 29, 4, -36 },
  { 2393, 13, 27, 29, 8, -27 },
  { 2437, 17, 35, 29, 4, -27 },
  { 2512, 24, 26, 29, 4, -29 },
  { 2590, 24, 17, 29, 3, -24 },
  { 2641, 24, 26, 29, 2, -29 },
  { 2719, 21, 35, 29, 6, -35 },
  { 2811, 30, 45, 29, 0, -36 },
  { 2980, 25, 35, 29, 0, -35 },
  { 3090, 26, 35, 29, 2, -35 },
  { 3204, 26, 36, 29, 2, -36 },
  { 3321, 27, 35, 29, 1, -35 },
  { 3440, 27, 35, 29, 2, -35 },
  { 3559, 27, 35, 29, 2, -35 },
  { 3678, 26, 36, 29, 2, -36 },
  { 3795, 27, 35, 29, 2, -35 },
  { 3914, 26, 35, 29, 2, -35 },
  { 4028, 28, 36, 29, 0, -35 },
  { 4154, 28, 35, 29, 2, -35 },
  { 4277, 22, 35, 29, 3, -35 },
  { 4374, 29, 35, 29, 1, -35 },
  { 4501, 28, 35, 29, 1, -35 },
  { 4624, 26, 36, 29, 2, -36 },
  { 4741, 27, 35, 29, 2, -35 },
  { 4860, 26, 45, 29, 2, -36 },
  { 5007, 27, 35, 29, 2, -35 },
  { 5126, 27, 36, 29, 1, -36 },
  { 5248, 25, 35, 29, 5, -35 },
  { 5358, 27, 35, 29, 2, -35 },
  { 5477, 26, 35, 29, 5, -35 },
  { 5591, 29, 35, 29, 2, -35 },
  { 5718, 31, 35, 29, -1, -35 },
  { 5854, 26, 35, 29, 5, -35 },
  { 5968, 26, 35, 29, 2, -35 },
  { 6082, 21, 45, 29, 6, -40 },
  { 6201, 16, 45, 29, 7, -40 },
  { 6291, 20, 45, 29, 4, -40 },
  { 6404, 22, 19, 29, 4, -35 },
  { 6457, 24, 6, 29, 0, 1 },
  { 6475, 10, 7, 29, 12, -38 },
  { 6484, 25, 27, 29, 2, -27 },
  { 6569, 25, 35, 29, 2, -35 },
  { 6679, 25, 27, 29, 2, -27 },
  { 6764, 27, 35, 29, 2, -35 },
  { 6883, 24, 27, 29, 2, -27 },
  { 6964, 33, 44, 29, -3, -35 },
  { 7146, 25, 36, 29, 2, -27 },
  { 7259, 25, 35, 29, 2, -35 },
  { 7369, 24, 38, 29, 1, -38 },
  { 7483, 26, 47, 29, 0, -38 },
  { 7636, 27, 35, 29, 2, -35 },
  { 7755, 22, 35, 29, 4, -35 },
  { 7852, 28, 27, 29, 0, -27 },
  { 7947, 25, 27, 29, 2, -27 },
  { 8032, 24, 27, 29, 2, -27 },
  { 8113, 27, 36, 29, 0, -27 },
  { 8235, 25, 36, 29, 2, -27 },
  { 8348, 26, 27, 29, 2, -27 },
  { 8436, 25, 27, 29, 2, -27 },
  { 8521, 24, 34, 29, 3, -34 },
  { 8623, 25, 26, 29, 2, -26 },
  { 8705, 25, 26, 29, 4, -26 },
  { 8787, 27, 26, 29, 3, -26 },
  { 8875, 28, 26, 29, 0, -26 },
  { 8966, 25, 35, 29, 2, -26 },
  { 9076, 25, 26, 29, 2, -26 },
  { 9158, 25, 45, 29, 4, -40 },
  { 9299, 14, 45, 29, 8, -40 },
  { 9378, 25, 45, 29, 1, -40 },
  { 9519, 26, 12, 29, 2, -23 },
};

const GFXfont JetBrainsMono_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_BOLDITALIC48PT7B_H_
