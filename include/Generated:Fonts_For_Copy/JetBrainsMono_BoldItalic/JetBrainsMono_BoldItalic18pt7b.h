#ifndef _JETBRAINSMONO_BOLDITALIC18PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x18, 0xC4, 0x60, 0x01, 0xCE, 0x00, 0xEF, 0xDF,
  0x36, 0x6C, 0xC0, 0x06, 0x61, 0x88, 0x33, 0x1F, 0xF3, 0xFE, 0x33, 0x04,
  0x61, 0x88, 0xFF, 0xDF, 0xF9, 0x88, 0x33, 0x04, 0x60, 0x02, 0x01, 0x00,
  0x40, 0x7C, 0x3F, 0x9D, 0x66, 0x41, 0xF0, 0x7C, 0x0F, 0xC0, 0xF0, 0x2E,
  0xCB, 0xB6, 0xCF, 0xF1, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x1E, 0x19, 0x91,
  0x8C, 0x98, 0x65, 0x83, 0xF8, 0x0E, 0x80, 0x08, 0x00, 0xFC, 0x0F, 0xE0,
  0xD9, 0x0C, 0xC8, 0xC6, 0xCC, 0x3C, 0x00, 0x0F, 0x87, 0xE1, 0x9C, 0xE0,
  0x18, 0x06, 0x07, 0xC1, 0xBB, 0x67, 0x99, 0xCE, 0x31, 0xFE, 0x7D, 0xC0,
  0xFF, 0x6C, 0x06, 0x1C, 0x71, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06,
  0x0C, 0x1C, 0x1C, 0x3C, 0x18, 0x10, 0x3C, 0x0E, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x38, 0xF0, 0xC0, 0x0C, 0x03,
  0x08, 0xCB, 0xAE, 0xFF, 0xC7, 0x03, 0x61, 0x98, 0xE7, 0x00, 0x0C, 0x06,
  0x03, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x1C, 0xE3, 0x1C, 0x63, 0x80,
  0x7F, 0xFC, 0x6F, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x1B, 0x4F, 0xF7,
  0x93, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x0E, 0x3E, 0x76, 0x46, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF, 0x1F, 0x1F, 0xDC, 0x6C,
  0x30, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x1F, 0xEF, 0xF0, 0x3F,
  0x9F, 0xC0, 0xC0, 0xC1, 0xC0, 0xF8, 0x7C, 0x06, 0x03, 0x61, 0xB0, 0xDF,
  0xC7, 0xC0, 0x03, 0x83, 0x83, 0x83, 0x81, 0x81, 0x9D, 0x8F, 0xC6, 0xFF,
  0x7F, 0x80, 0xC0, 0xE0, 0x70, 0x3F, 0x9F, 0xDC, 0x0C, 0x06, 0x63, 0xF9,
  0xCE, 0x07, 0x03, 0x01, 0xB0, 0xDF, 0xC7, 0xC0, 0x07, 0x07, 0x03, 0x03,
  0x03, 0x03, 0xF9, 0xFD, 0xC7, 0xC3, 0xE1, 0xF0, 0xDF, 0xC7, 0xC0, 0xFF,
  0xFF, 0xF0, 0xD8, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C,
  0x0E, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x37, 0x39, 0xF8, 0xF8, 0xEE, 0xE3,
  0x61, 0xB0, 0xDF, 0xE7, 0xC0, 0x1F, 0x0F, 0xE6, 0x19, 0x87, 0x61, 0x98,
  0xE7, 0xF8, 0xEC, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x33, 0xCC,
  0x00, 0x00, 0x0C, 0xF7, 0x00, 0x1C, 0xF1, 0x80, 0x00, 0x00, 0x0E, 0x71,
  0x86, 0x30, 0xC0, 0x00, 0x81, 0xC3, 0xE7, 0x87, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0x80, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x40, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x1C, 0x7C, 0xF0, 0xE0, 0x40, 0x00, 0x7E, 0x7E,
  0x07, 0x03, 0x07, 0x3E, 0x3C, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x0F,
  0xC3, 0x1C, 0xC1, 0xB0, 0x36, 0x36, 0xCF, 0xDB, 0x1B, 0x66, 0x4C, 0xD9,
  0x9B, 0x37, 0x67, 0x6C, 0x01, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x03, 0x83,
  0xC1, 0xA1, 0x98, 0xCC, 0x66, 0x63, 0x3F, 0xBF, 0xD8, 0x7C, 0x3C, 0x18,
  0x3F, 0x1F, 0xE6, 0x19, 0x86, 0x61, 0x9F, 0xC7, 0xF3, 0x8C, 0xC3, 0xB0,
  0xEC, 0x33, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0xCC, 0x33, 0xF8, 0x7C, 0x00, 0x3F, 0x3F,
  0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x87, 0xC7, 0xE3, 0xE1, 0xB1, 0xDF, 0xCF,
  0xC0, 0x3F, 0xCF, 0xE7, 0x01, 0xC0, 0x60, 0x1F, 0xC7, 0xF1, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xF7, 0x01, 0x80, 0x60,
  0x1F, 0xE7, 0xF1, 0xFC, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F,
  0x0F, 0xE7, 0x19, 0x86, 0x60, 0x18, 0x06, 0xFB, 0xBE, 0xC3, 0xB0, 0xCC,
  0x33, 0xF8, 0x7C, 0x00, 0x31, 0xDC, 0x67, 0x19, 0x86, 0x61, 0x9F, 0xE7,
  0xFB, 0x8C, 0xE3, 0x30, 0xCC, 0x33, 0x0C, 0xC7, 0x00, 0x3F, 0x9F, 0xC3,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x1F, 0xEF, 0xE0,
  0x07, 0xC1, 0xF0, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0xB8,
  0x6E, 0x39, 0xFC, 0x7E, 0x00, 0x30, 0xDC, 0x66, 0x39, 0x8C, 0x66, 0x1F,
  0x87, 0xC3, 0xB8, 0xE6, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0x00, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xFF, 0xFF, 0x38,
  0xE7, 0x1C, 0xE7, 0x9C, 0xB2, 0xFC, 0xDD, 0x9B, 0xB3, 0x06, 0x60, 0xCC,
  0x39, 0x86, 0x70, 0xCC, 0x18, 0x38, 0x67, 0x9C, 0xF3, 0x1E, 0x63, 0xCC,
  0x69, 0x8D, 0xB3, 0x36, 0x67, 0x8C, 0xF1, 0x8E, 0x31, 0xCE, 0x38, 0x1F,
  0x1F, 0xDC, 0x6C, 0x36, 0x1B, 0x0D, 0x8F, 0xC7, 0xC3, 0x61, 0xB0, 0xDF,
  0xC7, 0xC0, 0x3F, 0x1F, 0xE7, 0x1D, 0x83, 0x61, 0xD8, 0x67, 0xF3, 0xF8,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36,
  0x1B, 0x0F, 0x87, 0xC7, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x60, 0x38,
  0x0C, 0x3F, 0x1F, 0xE6, 0x1D, 0x87, 0x61, 0x98, 0xE7, 0xF3, 0xF0, 0xEE,
  0x31, 0x8C, 0x63, 0x1C, 0xC3, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x80, 0x70,
  0x1F, 0x03, 0xF0, 0x1C, 0x03, 0xB0, 0xEC, 0x33, 0xFC, 0x7C, 0x00, 0xFF,
  0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x00, 0x71, 0xDC, 0x76, 0x19, 0x86, 0x61, 0x98, 0x66, 0x3B, 0x8E,
  0xC3, 0x30, 0xCC, 0x33, 0xF8, 0x7C, 0x00, 0xC1, 0xE0, 0xF0, 0xD8, 0x6E,
  0x77, 0x31, 0x98, 0xD8, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x46, 0x79,
  0xDB, 0x3B, 0x66, 0x6D, 0xCD, 0xAB, 0x35, 0x66, 0xAC, 0xF5, 0x9C, 0xA3,
  0x9C, 0x73, 0x8C, 0x60, 0x38, 0xE3, 0x18, 0x67, 0x0F, 0xC0, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1B, 0x07, 0x61, 0xCE, 0x30, 0xCE, 0x1C, 0xC1, 0xF0,
  0xE6, 0x31, 0x98, 0x6E, 0x1F, 0x03, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x00, 0x3F, 0xBF, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70,
  0x30, 0x38, 0x38, 0x1F, 0xEF, 0xF0, 0x1F, 0x1F, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xFC, 0xF8, 0xC3,
  0x0C, 0x38, 0x61, 0x86, 0x1C, 0x70, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x1C,
  0x1F, 0x1F, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x7C, 0xF8, 0x0E, 0x05, 0x06, 0xC6, 0x63, 0x33, 0x1B,
  0x86, 0xFF, 0xFF, 0xC0, 0xE3, 0x3D, 0xBF, 0xD8, 0xEC, 0x7E, 0x3E, 0x1B,
  0x0D, 0x8E, 0xFF, 0x3F, 0x80, 0x30, 0x38, 0x1C, 0x0D, 0xE7, 0xFB, 0x1D,
  0x8F, 0xC7, 0xE3, 0x61, 0xB8, 0xDF, 0xED, 0xE0, 0x1F, 0x1F, 0xD8, 0xEC,
  0x3E, 0x06, 0x03, 0x01, 0x86, 0xFF, 0x3E, 0x00, 0x01, 0xC0, 0x60, 0x18,
  0xF6, 0x7F, 0x98, 0xE6, 0x3B, 0x8E, 0xC3, 0x30, 0xCC, 0x73, 0xFC, 0x7F,
  0x00, 0x1E, 0x1F, 0x98, 0xEC, 0x3F, 0xFF, 0xFB, 0x01, 0x86, 0xFE, 0x3E,
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0x00, 0x70, 0x1F, 0xE3, 0xFE, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFC, 0x0F,
  0x80, 0x3D, 0xBF, 0xD8, 0xEC, 0x7E, 0x3E, 0x1B, 0x0D, 0xFE, 0x7B, 0x03,
  0x81, 0xCF, 0xCF, 0xC0, 0x30, 0x38, 0x1C, 0x0D, 0xE7, 0xFB, 0x1D, 0x8F,
  0xC7, 0xE3, 0x61, 0xB0, 0xD8, 0x6C, 0x70, 0x06, 0x07, 0x00, 0x00, 0x07,
  0xE3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x8F, 0xFF, 0xF8, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x1F, 0x87, 0xE2, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x63, 0xF8, 0xFC, 0x00, 0x30, 0x1C, 0x07,
  0x01, 0x87, 0x63, 0x99, 0xC6, 0x61, 0xF0, 0xFC, 0x33, 0x8C, 0x63, 0x1C,
  0xC3, 0x00, 0xF8, 0xF8, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x7F, 0x3E, 0x3D, 0xDF, 0xF6, 0x6D, 0x93, 0x64, 0xD9, 0x36, 0xCD,
  0xB2, 0xCD, 0xB3, 0x60, 0x6F, 0x3F, 0xD8, 0xEC, 0x7E, 0x3F, 0x1B, 0x0D,
  0x86, 0xC3, 0x63, 0x80, 0x1E, 0x1F, 0x98, 0xEC, 0x7E, 0x3E, 0x1B, 0x0D,
  0x86, 0xFE, 0x3E, 0x00, 0x37, 0x8F, 0xF3, 0x1C, 0xC7, 0x71, 0xDC, 0x66,
  0x19, 0xC6, 0x7F, 0x1B, 0xC6, 0x03, 0x80, 0xC0, 0x00, 0x3D, 0xBF, 0xD8,
  0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x8E, 0xFF, 0x3F, 0x81, 0xC0, 0xC0, 0x60,
  0x7F, 0x37, 0xDC, 0x6C, 0x36, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00,
  0x3F, 0x3F, 0xD8, 0x6C, 0x07, 0xE0, 0xF8, 0x0D, 0x86, 0xFF, 0x3F, 0x00,
  0x0C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x07, 0xE1, 0xF0, 0x61, 0xB0, 0xD8, 0x6C, 0x7E, 0x3F, 0x1B, 0x0D, 0xCE,
  0xFE, 0x3E, 0x00, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE7, 0x61, 0xB0, 0xF0,
  0x78, 0x38, 0x00, 0xCC, 0xF3, 0x3C, 0xCB, 0x56, 0xD5, 0xB5, 0x6E, 0x73,
  0x9C, 0xE7, 0x39, 0x80, 0x30, 0xE7, 0x38, 0x6E, 0x0F, 0x80, 0xE0, 0x1C,
  0x07, 0xC1, 0x98, 0x73, 0x9C, 0x30, 0x61, 0xB0, 0xD8, 0x6C, 0x7E, 0x36,
  0x1B, 0x8D, 0xFE, 0x7B, 0x03, 0x81, 0x8F, 0xCF, 0xC0, 0x7F, 0xBF, 0xC0,
  0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0, 0xFF, 0x7F, 0x80, 0x01, 0xC0, 0xF0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x61, 0xF0, 0x78, 0x3F, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x7C, 0x0E, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6,
  0x33, 0x98, 0xC6, 0x31, 0x9C, 0xE0, 0x1C, 0x07, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x3F, 0x03, 0xC3, 0xE1, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x81, 0xE0, 0xF0, 0x00, 0x79, 0xEE, 0xF3, 0xE0, 0xE0,
};

const GFXglyph JetBrainsMono_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 7, 5, 11, 3, -13 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 10, 19, 11, 1, -16 },
  { 57, 13, 13, 11, -1, -13 },
  { 79, 10, 13, 11, 0, -13 },
  { 96, 3, 5, 11, 5, -13 },
  { 98, 7, 17, 11, 3, -15 },
  { 113, 8, 17, 11, 1, -15 },
  { 130, 10, 9, 11, 1, -11 },
  { 142, 9, 8, 11, 1, -10 },
  { 151, 6, 6, 11, 1, -3 },
  { 156, 7, 2, 11, 2, -7 },
  { 158, 4, 3, 11, 3, -3 },
  { 160, 11, 17, 11, 0, -15 },
  { 184, 9, 13, 11, 1, -13 },
  { 199, 8, 13, 11, 1, -13 },
  { 212, 9, 13, 11, 1, -13 },
  { 227, 9, 13, 11, 1, -13 },
  { 242, 9, 13, 11, 1, -13 },
  { 257, 9, 13, 11, 1, -13 },
  { 272, 9, 13, 11, 1, -13 },
  { 287, 9, 13, 11, 2, -13 },
  { 302, 9, 13, 11, 1, -13 },
  { 317, 10, 13, 11, 1, -13 },
  { 334, 5, 10, 11, 3, -10 },
  { 341, 6, 13, 11, 2, -10 },
  { 351, 9, 10, 11, 1, -11 },
  { 363, 9, 6, 11, 1, -9 },
  { 370, 9, 10, 11, 1, -11 },
  { 382, 8, 13, 11, 2, -13 },
  { 395, 11, 16, 11, 0, -13 },
  { 417, 9, 13, 11, 0, -13 },
  { 432, 10, 13, 11, 1, -13 },
  { 449, 10, 13, 11, 1, -13 },
  { 466, 9, 13, 11, 1, -13 },
  { 481, 10, 13, 11, 1, -13 },
  { 498, 10, 13, 11, 1, -13 },
  { 515, 10, 13, 11, 1, -13 },
  { 532, 10, 13, 11, 1, -13 },
  { 549, 9, 13, 11, 1, -13 },
  { 564, 10, 13, 11, 0, -13 },
  { 581, 10, 13, 11, 1, -13 },
  { 598, 8, 13, 11, 1, -13 },
  { 611, 11, 13, 11, 0, -13 },
  { 629, 11, 13, 11, 0, -13 },
  { 647, 9, 13, 11, 1, -13 },
  { 662, 10, 13, 11, 1, -13 },
  { 679, 9, 16, 11, 1, -13 },
  { 697, 10, 13, 11, 1, -13 },
  { 714, 10, 13, 11, 1, -13 },
  { 731, 9, 13, 11, 2, -13 },
  { 746, 10, 13, 11, 1, -13 },
  { 763, 9, 13, 11, 2, -13 },
  { 778, 11, 13, 11, 1, -13 },
  { 796, 11, 13, 11, 0, -13 },
  { 814, 10, 13, 11, 2, -13 },
  { 831, 9, 13, 11, 1, -13 },
  { 846, 8, 17, 11, 2, -15 },
  { 863, 6, 17, 11, 3, -15 },
  { 876, 8, 17, 11, 1, -15 },
  { 893, 9, 7, 11, 1, -13 },
  { 901, 9, 2, 11, 0, 0 },
  { 904, 4, 2, 11, 4, -14 },
  { 905, 9, 10, 11, 1, -10 },
  { 917, 9, 13, 11, 1, -13 },
  { 932, 9, 10, 11, 1, -10 },
  { 944, 10, 13, 11, 1, -13 },
  { 961, 9, 10, 11, 1, -10 },
  { 973, 12, 16, 11, -1, -13 },
  { 997, 9, 13, 11, 1, -10 },
  { 1012, 9, 13, 11, 1, -13 },
  { 1027, 9, 14, 11, 1, -14 },
  { 1043, 10, 17, 11, 0, -14 },
  { 1065, 10, 13, 11, 1, -13 },
  { 1082, 8, 13, 11, 2, -13 },
  { 1095, 10, 10, 11, 0, -10 },
  { 1108, 9, 10, 11, 1, -10 },
  { 1120, 9, 10, 11, 1, -10 },
  { 1132, 10, 13, 11, 0, -10 },
  { 1149, 9, 13, 11, 1, -10 },
  { 1164, 9, 10, 11, 1, -10 },
  { 1176, 9, 10, 11, 1, -10 },
  { 1188, 9, 13, 11, 1, -13 },
  { 1203, 9, 10, 11, 1, -10 },
  { 1215, 9, 10, 11, 2, -10 },
  { 1227, 10, 10, 11, 1, -10 },
  { 1240, 11, 10, 11, 0, -10 },
  { 1254, 9, 13, 11, 1, -10 },
  { 1269, 9, 10, 11, 1, -10 },
  { 1281, 10, 17, 11, 1, -15 },
  { 1303, 5, 17, 11, 3, -15 },
  { 1314, 10, 17, 11, 0, -15 },
  { 1336, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_BOLDITALIC18PT7B_H_
