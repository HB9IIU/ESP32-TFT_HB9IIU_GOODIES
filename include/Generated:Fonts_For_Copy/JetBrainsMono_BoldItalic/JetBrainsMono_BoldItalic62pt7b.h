#ifndef _JETBRAINSMONO_BOLDITALIC62PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x03,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x08, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0xF7, 0xFE, 0x03, 0xFE, 0x3C, 0x7F, 0xC0, 0xFF, 0x0F, 0x1F, 0xF0, 0x7F,
  0x83, 0x83, 0xFC, 0x1F, 0xE1, 0xE0, 0xFF, 0x07, 0xF8, 0x78, 0x3F, 0xC1,
  0xFE, 0x1E, 0x00, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x1F, 0xE1, 0xE0, 0x00,
  0x07, 0xFC, 0x78, 0x00, 0x01, 0xFF, 0xBC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xE7, 0xFE, 0x00, 0x00, 0x70, 0xFF, 0x80,
  0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x0F, 0x07, 0xF8, 0x00, 0x03, 0xC1, 0xFE,
  0x00, 0x00, 0xF0, 0x7F, 0x87, 0xF8, 0x3C, 0x1F, 0xE1, 0xFC, 0x0E, 0x07,
  0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x1F, 0xE1, 0xE1, 0xFF, 0x07, 0xFC, 0x78,
  0xFF, 0x81, 0xFF, 0xDE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xE3, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE3,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xF8, 0x00, 0x00, 0x01, 0xF9, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x9F, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x8F, 0xE7, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xC7, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x03, 0xFD, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0x03, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xEF,
  0xF0, 0x1F, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x10, 0x01, 0xF8, 0x01, 0x0F, 0x00, 0xF8, 0x07, 0x8F, 0xE0, 0x7C,
  0x1F, 0xC7, 0xFC, 0x3C, 0x1F, 0xF7, 0xFF, 0x1E, 0x3F, 0xFF, 0xFF, 0xCE,
  0x7F, 0xFF, 0xFF, 0xF7, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7,
  0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x78, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3F, 0x87, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xF3, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE0, 0xF8, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xDF, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x38, 0x07, 0xF8,
  0x00, 0xE0, 0x0F, 0xF0, 0x01, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x7F,
  0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x7C,
  0x00, 0x0F, 0xF1, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xF0, 0x03, 0xFB, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0x80, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFD, 0xFF,
  0xF0, 0x07, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xE8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF,
  0xE0, 0x0F, 0xFF, 0xBF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x20, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xF1, 0xF8, 0x3F, 0x00, 0x7F, 0xE7, 0xE0, 0xFC, 0x03, 0xFF, 0xDF, 0x87,
  0xF0, 0x1F, 0xFF, 0x7E, 0x1F, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0x03, 0xF8,
  0x1F, 0xE1, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x7F, 0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x7F, 0x00, 0xFE, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x1F,
  0xC1, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0x80,
  0xFF, 0xFB, 0xF0, 0xFE, 0x01, 0xFF, 0xCF, 0xC3, 0xF8, 0x03, 0xFE, 0x7E,
  0x0F, 0xE0, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8,
  0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x87, 0xF0,
  0x3F, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0,
  0x3F, 0x7C, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x7D, 0xF8, 0x0F, 0xCF, 0x87,
  0xEF, 0xC0, 0x7E, 0x7C, 0x3E, 0x7E, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x1F,
  0x9F, 0x1F, 0x3F, 0x81, 0xFC, 0xF8, 0xF9, 0xFC, 0x0F, 0xE7, 0xCF, 0xCF,
  0xE0, 0x7F, 0x3E, 0x7C, 0x7E, 0x03, 0xF8, 0xFF, 0xE7, 0xF0, 0x1F, 0xC7,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xF1, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0x0F, 0xE7, 0xE0,
  0x7F, 0x81, 0xFC, 0x7E, 0x0F, 0xE0, 0x3F, 0x8F, 0xC1, 0xFC, 0x07, 0xF1,
  0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x07, 0xF0, 0x3F, 0xC7, 0xE0, 0xFE, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0xFE,
  0x03, 0xF8, 0x3F, 0x1F, 0xC0, 0x7F, 0x07, 0xE3, 0xF8, 0x1F, 0xE0, 0xFE,
  0x7F, 0x03, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0,
  0x3F, 0x3F, 0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFD, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F,
  0xFE, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xC0,
  0x07, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x81, 0xFC, 0x3F, 0x03, 0xDE, 0x07,
  0xE0, 0xFC, 0x0F, 0x78, 0x1F, 0x83, 0xF0, 0x3D, 0xE0, 0xFE, 0x0F, 0xC1,
  0xF7, 0x83, 0xF8, 0x3F, 0x07, 0x9E, 0x0F, 0xC0, 0xFC, 0x1E, 0x78, 0x3F,
  0x03, 0xF0, 0x79, 0xE1, 0xFC, 0x0F, 0xC3, 0xE7, 0x87, 0xE0, 0x7F, 0x0F,
  0x3E, 0x1F, 0x81, 0xFC, 0x3C, 0xF8, 0x7E, 0x07, 0xF0, 0xF3, 0xE3, 0xF8,
  0x1F, 0xC7, 0xCF, 0x0F, 0xC0, 0x7E, 0x1E, 0x3C, 0x3F, 0x01, 0xF8, 0x78,
  0xF0, 0xFC, 0x07, 0xE3, 0xE3, 0xC7, 0xF0, 0x1F, 0x8F, 0x0F, 0x1F, 0x80,
  0x7E, 0x3C, 0x3C, 0x7E, 0x01, 0xF8, 0xF0, 0xF1, 0xF8, 0x07, 0xE7, 0xC3,
  0xCF, 0xE0, 0x1F, 0x9E, 0x0F, 0x3F, 0x00, 0x7E, 0x78, 0x3C, 0xFC, 0x01,
  0xFB, 0xE0, 0xF3, 0xF0, 0x07, 0xEF, 0x83, 0xDF, 0x80, 0x1F, 0xBC, 0x0F,
  0x7E, 0x00, 0x7E, 0xF0, 0x3D, 0xF8, 0x01, 0xFF, 0xC0, 0xF7, 0xE0, 0x0F,
  0xDE, 0x03, 0xDF, 0x00, 0x3F, 0x78, 0x0F, 0xFC, 0x00, 0xFD, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFE, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x9F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x07,
  0xF8, 0x7F, 0xE0, 0x07, 0xF9, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0xFF,
  0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xEF, 0xF0, 0x1F,
  0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF,
  0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFE,
  0x7F, 0x80, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xC7, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFE,
  0xFE, 0x07, 0xFF, 0xFE, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF7,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x07, 0xF8, 0x7F, 0xE0, 0x07, 0xF9, 0xFF, 0xF8, 0x07, 0xFB, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x04, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x10, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x3F, 0x1F, 0xC3, 0xFC, 0x03, 0xF7, 0xFC,
  0x7F, 0xC0, 0x7F, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF8,
  0x3F, 0x81, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x03, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x3E, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x7F, 0xE0, 0x07, 0xF9,
  0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xF7,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x87, 0xFE, 0x00, 0x1F, 0xE7, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xFC, 0x01,
  0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xF7, 0xFF,
  0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xC0, 0x3F, 0xCF,
  0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF,
  0xFC, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFF,
  0xFE, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF,
  0x9F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x3F, 0xF8, 0x01, 0xFE,
  0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x01, 0xFB, 0xF0,
  0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xF9,
  0xF8, 0x1F, 0xE0, 0x3F, 0x3F, 0x03, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x81,
  0xF8, 0xFC, 0x1E, 0xF0, 0x3F, 0x1F, 0x83, 0xDE, 0x07, 0xE3, 0xF0, 0x7B,
  0xC1, 0xF8, 0x7E, 0x0F, 0x78, 0x3F, 0x0F, 0xC3, 0xCF, 0x07, 0xE1, 0xF8,
  0x79, 0xE1, 0xF8, 0x3F, 0x0F, 0x3C, 0x3F, 0x07, 0xE3, 0xC7, 0x87, 0xE0,
  0xFC, 0x78, 0xF1, 0xF8, 0x1F, 0x8F, 0x1E, 0x3F, 0x03, 0xF3, 0xC3, 0xC7,
  0xE0, 0x7E, 0x78, 0x79, 0xF8, 0x0F, 0xCF, 0x0F, 0x3F, 0x01, 0xFB, 0xE1,
  0xE7, 0xE0, 0x3F, 0x78, 0x3C, 0xFC, 0x07, 0xEF, 0x07, 0xBF, 0x00, 0xFD,
  0xE0, 0xF7, 0xE0, 0x1F, 0xF8, 0x1E, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7D, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x1F,
  0xE0, 0x00, 0x20, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xC3, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xFE,
  0x03, 0xF3, 0xFF, 0xFF, 0x01, 0xF9, 0xFC, 0x3F, 0xC1, 0xFC, 0xFC, 0x0F,
  0xF0, 0xFE, 0x7E, 0x07, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x3F, 0x80,
  0xFF, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 45, 37, 11, -45 },
  { 91, 24, 18, 37, 10, -45 },
  { 145, 37, 45, 37, 1, -45 },
  { 354, 34, 63, 37, 2, -54 },
  { 622, 45, 46, 37, -3, -46 },
  { 881, 35, 47, 37, 1, -46 },
  { 1087, 10, 18, 37, 17, -45 },
  { 1110, 27, 60, 37, 9, -52 },
  { 1313, 27, 60, 37, 3, -52 },
  { 1516, 33, 33, 37, 3, -38 },
  { 1653, 31, 29, 37, 4, -35 },
  { 1766, 18, 19, 37, 5, -9 },
  { 1809, 22, 7, 37, 8, -24 },
  { 1829, 13, 12, 37, 10, -11 },
  { 1849, 39, 58, 37, 0, -51 },
  { 2132, 33, 47, 37, 3, -46 },
  { 2326, 31, 45, 37, 2, -45 },
  { 2501, 34, 46, 37, 2, -46 },
  { 2697, 33, 46, 37, 2, -45 },
  { 2887, 32, 45, 37, 3, -45 },
  { 3067, 33, 46, 37, 3, -45 },
  { 3257, 32, 46, 37, 2, -45 },
  { 3441, 32, 45, 37, 6, -45 },
  { 3621, 34, 47, 37, 2, -46 },
  { 3821, 32, 46, 37, 5, -46 },
  { 4005, 17, 36, 37, 10, -35 },
  { 4082, 22, 45, 37, 5, -35 },
  { 4206, 31, 34, 37, 5, -37 },
  { 4338, 30, 23, 37, 4, -32 },
  { 4425, 31, 34, 37, 3, -37 },
  { 4557, 27, 45, 37, 8, -45 },
  { 4709, 38, 57, 37, 0, -46 },
  { 4980, 33, 45, 37, -1, -45 },
  { 5166, 34, 45, 37, 2, -45 },
  { 5358, 33, 47, 37, 3, -46 },
  { 5552, 34, 45, 37, 2, -45 },
  { 5744, 34, 45, 37, 3, -45 },
  { 5936, 36, 45, 37, 2, -45 },
  { 6139, 33, 47, 37, 3, -46 },
  { 6333, 35, 45, 37, 2, -45 },
  { 6530, 33, 45, 37, 3, -45 },
  { 6716, 36, 46, 37, 0, -45 },
  { 6923, 37, 45, 37, 2, -45 },
  { 7132, 28, 45, 37, 4, -45 },
  { 7290, 37, 45, 37, 1, -45 },
  { 7499, 35, 45, 37, 2, -45 },
  { 7696, 33, 47, 37, 3, -46 },
  { 7890, 36, 45, 37, 2, -45 },
  { 8093, 33, 57, 37, 3, -46 },
  { 8329, 35, 45, 37, 2, -45 },
  { 8526, 34, 47, 37, 2, -46 },
  { 8726, 33, 45, 37, 6, -45 },
  { 8912, 34, 46, 37, 3, -45 },
  { 9108, 33, 45, 37, 7, -45 },
  { 9294, 38, 45, 37, 3, -45 },
  { 9508, 40, 45, 37, -1, -45 },
  { 9733, 34, 45, 37, 6, -45 },
  { 9925, 34, 45, 37, 2, -45 },
  { 10117, 26, 58, 37, 8, -51 },
  { 10306, 21, 58, 37, 9, -51 },
  { 10459, 26, 58, 37, 5, -51 },
  { 10648, 29, 24, 37, 5, -45 },
  { 10735, 31, 7, 37, 0, 2 },
  { 10763, 14, 9, 37, 15, -49 },
  { 10779, 32, 36, 37, 3, -35 },
  { 10923, 32, 46, 37, 2, -45 },
  { 11107, 32, 36, 37, 3, -35 },
  { 11251, 34, 46, 37, 3, -45 },
  { 11447, 31, 36, 37, 3, -35 },
  { 11587, 42, 56, 37, -3, -45 },
  { 11881, 32, 46, 37, 3, -35 },
  { 12065, 32, 45, 37, 2, -45 },
  { 12245, 31, 49, 37, 2, -49 },
  { 12435, 33, 60, 37, 1, -49 },
  { 12683, 36, 45, 37, 2, -45 },
  { 12886, 28, 45, 37, 5, -45 },
  { 13044, 36, 35, 37, 0, -35 },
  { 13202, 32, 35, 37, 2, -35 },
  { 13342, 31, 36, 37, 3, -35 },
  { 13482, 34, 46, 37, 0, -35 },
  { 13678, 32, 46, 37, 3, -35 },
  { 13862, 33, 35, 37, 3, -35 },
  { 14007, 32, 36, 37, 2, -35 },
  { 14151, 31, 43, 37, 4, -43 },
  { 14318, 32, 35, 37, 3, -34 },
  { 14458, 32, 34, 37, 5, -34 },
  { 14594, 35, 34, 37, 4, -34 },
  { 14743, 37, 34, 37, 0, -34 },
  { 14901, 32, 45, 37, 3, -34 },
  { 15081, 32, 34, 37, 2, -34 },
  { 15217, 33, 58, 37, 5, -51 },
  { 15457, 17, 58, 37, 11, -51 },
  { 15581, 33, 58, 37, 1, -51 },
  { 15821, 33, 14, 37, 3, -29 },
};

const GFXfont JetBrainsMono_BoldItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_BOLDITALIC62PT7B_H_
