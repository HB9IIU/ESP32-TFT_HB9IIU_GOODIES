#ifndef _JETBRAINSMONO_BOLDITALIC57PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xF9, 0xFE, 0x0F,
  0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xE7,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xBD, 0xFF, 0x01, 0xFE, 0x78, 0xFF, 0x07, 0xF8, 0xF1, 0xFE,
  0x0F, 0xE1, 0xE1, 0xFC, 0x1F, 0xC3, 0x83, 0xF8, 0x7F, 0x87, 0x00, 0x00,
  0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x07,
  0xFC, 0xF0, 0x00, 0x07, 0xFD, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x3C,
  0x7F, 0x80, 0x00, 0x78, 0x7F, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x01, 0xC1,
  0xFC, 0x7F, 0x87, 0x83, 0xF8, 0xFF, 0x0F, 0x07, 0xF1, 0xFE, 0x1E, 0x1F,
  0xC3, 0xFE, 0x3C, 0x7F, 0x83, 0xFE, 0x71, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xF3, 0xE0, 0x00, 0x07, 0xFF, 0xF3, 0xE0,
  0x00, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0xF9,
  0xFF, 0xFE, 0x00, 0x00, 0xF8, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x0F,
  0x80, 0x00, 0xFC, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0x00,
  0x7C, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF1, 0xF8, 0x7F,
  0x07, 0xFB, 0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F,
  0x01, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x87, 0xF0, 0x0F,
  0xFE, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x38, 0x07, 0xE0, 0x38, 0xFC, 0x1F, 0x03, 0xF7, 0xF8, 0x7C, 0x3F, 0xDF,
  0xF9, 0xE3, 0xFF, 0xFF, 0xF3, 0xBF, 0xFF, 0xFF, 0xED, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x1F, 0x87, 0xF9, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x1C, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xE7,
  0xF0, 0xFC, 0x3F, 0x9F, 0xE7, 0xF0, 0xFC, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF1, 0xFC, 0x7F, 0x07, 0x87, 0xF1, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x07,
  0x00, 0xFE, 0x00, 0x60, 0x0F, 0xE0, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0x80, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x0F,
  0xCF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x00,
  0xFE, 0x08, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x10, 0x00, 0x1F, 0xCF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE,
  0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFE, 0xFF,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x03,
  0xE1, 0xF0, 0x7C, 0x01, 0xFF, 0x3E, 0x1F, 0x80, 0xFF, 0xE7, 0xC3, 0xF0,
  0x1F, 0xFE, 0xF8, 0x7E, 0x07, 0xF9, 0xFF, 0x0F, 0xC1, 0xFC, 0x0F, 0xE1,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xE0,
  0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xF0, 0x3F, 0xEF, 0xF8, 0x7E, 0x03, 0xFF, 0xDF, 0x0F, 0xC0, 0x7F,
  0xF3, 0xE1, 0xF8, 0x07, 0xFC, 0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x07, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x07,
  0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x02, 0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFF, 0x1F, 0xE0, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF1, 0xFC, 0x1F,
  0xFF, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0x7D, 0xE0, 0x1F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF,
  0x81, 0xF7, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0, 0x7D, 0xF8, 0x1F, 0x3C, 0x3E,
  0x7C, 0x0F, 0xCF, 0x0F, 0xBF, 0x03, 0xF3, 0xC3, 0xCF, 0xC0, 0xFC, 0xF9,
  0xF3, 0xF0, 0x3F, 0x3E, 0x7C, 0xFC, 0x0F, 0xCF, 0xBE, 0x7F, 0x03, 0xF3,
  0xEF, 0x9F, 0x81, 0xFC, 0xFF, 0xC7, 0xE0, 0x7F, 0x1F, 0xF1, 0xF8, 0x1F,
  0x87, 0xF8, 0x7E, 0x07, 0xE1, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x0F, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00,
  0x7E, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x80,
  0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x0F, 0xDF, 0x80, 0xFC, 0x0F, 0xDF, 0x80,
  0xFC, 0x0F, 0xCF, 0x80, 0xFC, 0x0F, 0xCF, 0x81, 0xFC, 0x0F, 0xCF, 0xC1,
  0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0x1F, 0xC7, 0xC1,
  0xF8, 0x1F, 0xC7, 0xC1, 0xF8, 0x1F, 0xC7, 0xE3, 0xF8, 0x1F, 0x87, 0xE3,
  0xF8, 0x1F, 0x87, 0xE3, 0xF8, 0x1F, 0x83, 0xE3, 0xF8, 0x3F, 0x83, 0xE3,
  0xF0, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF3, 0xF0, 0x7F, 0x01, 0xF7,
  0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x07, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC3,
  0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x80, 0xFC, 0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x03, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x81, 0xF8, 0xF8, 0x1F, 0xE0, 0x7E,
  0x3E, 0x07, 0xF8, 0x3F, 0x1F, 0x81, 0xDE, 0x0F, 0xC7, 0xE0, 0xF7, 0x83,
  0xF1, 0xF8, 0x3D, 0xE0, 0xF8, 0x7E, 0x0F, 0x78, 0x7E, 0x1F, 0x87, 0x9E,
  0x1F, 0x87, 0xE1, 0xE7, 0x87, 0xE1, 0xF8, 0x79, 0xE1, 0xF0, 0x7E, 0x1E,
  0x78, 0xFC, 0x1F, 0x8F, 0x1C, 0x3F, 0x07, 0xE3, 0xC7, 0x0F, 0xC1, 0xF8,
  0xF1, 0xC3, 0xE0, 0x7E, 0x38, 0xF1, 0xF8, 0x1F, 0x1E, 0x3C, 0x7E, 0x07,
  0xC7, 0x8F, 0x1F, 0x81, 0xF1, 0xE3, 0xC7, 0xC0, 0x7C, 0xF0, 0xF3, 0xF0,
  0x1F, 0x3C, 0x3C, 0xFC, 0x07, 0xCF, 0x0F, 0x3E, 0x03, 0xF3, 0xC3, 0xCF,
  0x80, 0xFD, 0xE0, 0xF7, 0xE0, 0x3F, 0x78, 0x3D, 0xF8, 0x0F, 0xDE, 0x0F,
  0x7C, 0x03, 0xFF, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xBC, 0x0F, 0xF8, 0x03, 0xEE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0xFE,
  0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x87, 0xFF, 0xFD, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF,
  0x9F, 0xC0, 0x7F, 0xF8, 0xFE, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xF3,
  0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xEF, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0x80, 0xFE, 0x7F, 0xFC, 0x03, 0xF8,
  0x7F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC3, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xFF,
  0x7F, 0x01, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFD, 0xFC, 0x0F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x9F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x1F, 0xF8,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x07,
  0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xC0,
  0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x87, 0xFF,
  0xFD, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xDF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFE, 0x7F, 0x00, 0xFF, 0xE3,
  0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xF3,
  0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x7C,
  0x03, 0xF3, 0xF8, 0x7F, 0x01, 0xFB, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xFF, 0xBF, 0xF8, 0x3F, 0x8F, 0xF3, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xF0, 0xFE, 0x0F, 0x83, 0xF8, 0x7F, 0x07, 0xC1, 0xFC, 0x3F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x87, 0xF0, 0x7C, 0x1F, 0xC3, 0xF8, 0x3E, 0x0F, 0xE1, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3F, 0x83, 0xE0, 0x7E, 0x1F, 0xC1, 0xF0, 0x7F, 0x0F,
  0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xE1, 0xFC, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x0F,
  0xEF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x01, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0xF0,
  0x01, 0xFC, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xC0,
  0x3F, 0x9F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0x3F, 0x80, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xC0,
  0x7F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xBF, 0x87, 0xFF,
  0xFD, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xFC,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xF8, 0xFE, 0x01, 0xFF, 0x8F, 0xE0,
  0x00, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x10, 0x7F, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0x7E, 0x7F, 0xFE,
  0x03, 0xFB, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x40, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0xBE,
  0x03, 0xF0, 0x1F, 0x9F, 0x01, 0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0x07, 0xC7,
  0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x77, 0x03, 0xF1, 0xF0, 0x3B, 0x81, 0xF0,
  0xF8, 0x3D, 0xC1, 0xF8, 0x7C, 0x1E, 0xE0, 0xFC, 0x3E, 0x0E, 0x70, 0x7C,
  0x1F, 0x0F, 0x38, 0x3E, 0x0F, 0x87, 0x9C, 0x3F, 0x07, 0xC3, 0x9E, 0x1F,
  0x07, 0xE3, 0xCF, 0x0F, 0x83, 0xF1, 0xE7, 0x8F, 0xC1, 0xF8, 0xE3, 0xC7,
  0xE0, 0xFC, 0xF1, 0xE3, 0xE0, 0x7E, 0x78, 0xF3, 0xF0, 0x3F, 0x3C, 0x79,
  0xF8, 0x1F, 0xBC, 0x3C, 0xF8, 0x0F, 0xDE, 0x1E, 0xFC, 0x07, 0xEF, 0x0F,
  0x7E, 0x03, 0xF7, 0x07, 0xBE, 0x01, 0xFF, 0x83, 0xDF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xDF, 0x7F, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xFD,
  0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xF8, 0x7F, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xF1, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0x81, 0xF9,
  0xFF, 0xFF, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0xBF, 0x87, 0xF8, 0xFE, 0xFC,
  0x0F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFE, 0x3F, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 42, 34, 10, -42 },
  { 80, 22, 17, 34, 9, -42 },
  { 127, 34, 42, 34, 1, -42 },
  { 306, 31, 58, 34, 2, -50 },
  { 531, 41, 42, 34, -3, -42 },
  { 747, 32, 43, 34, 1, -42 },
  { 919, 10, 17, 34, 15, -42 },
  { 941, 25, 55, 34, 8, -48 },
  { 1113, 24, 55, 34, 3, -48 },
  { 1278, 30, 30, 34, 3, -35 },
  { 1391, 29, 27, 34, 3, -32 },
  { 1489, 16, 18, 34, 5, -9 },
  { 1525, 21, 7, 34, 7, -22 },
  { 1544, 11, 11, 34, 10, -10 },
  { 1560, 36, 53, 34, 0, -47 },
  { 1799, 30, 43, 34, 3, -42 },
  { 1961, 28, 42, 34, 2, -42 },
  { 2108, 31, 42, 34, 2, -42 },
  { 2271, 31, 43, 34, 2, -42 },
  { 2438, 29, 42, 34, 3, -42 },
  { 2591, 30, 43, 34, 3, -42 },
  { 2753, 29, 43, 34, 2, -42 },
  { 2909, 30, 42, 34, 5, -42 },
  { 3067, 31, 43, 34, 2, -42 },
  { 3234, 29, 42, 34, 5, -42 },
  { 3387, 15, 33, 34, 10, -32 },
  { 3449, 20, 41, 34, 5, -32 },
  { 3552, 29, 31, 34, 4, -34 },
  { 3665, 28, 20, 34, 4, -29 },
  { 3735, 29, 31, 34, 2, -34 },
  { 3848, 25, 42, 34, 7, -42 },
  { 3980, 35, 52, 34, 0, -42 },
  { 4208, 31, 42, 34, -1, -42 },
  { 4371, 31, 42, 34, 2, -42 },
  { 4534, 30, 43, 34, 3, -42 },
  { 4696, 31, 42, 34, 2, -42 },
  { 4859, 31, 42, 34, 3, -42 },
  { 5022, 33, 42, 34, 2, -42 },
  { 5196, 30, 43, 34, 3, -42 },
  { 5358, 32, 42, 34, 2, -42 },
  { 5526, 30, 42, 34, 3, -42 },
  { 5684, 33, 43, 34, 0, -42 },
  { 5862, 34, 42, 34, 2, -42 },
  { 6041, 26, 42, 34, 3, -42 },
  { 6178, 34, 42, 34, 1, -42 },
  { 6357, 32, 42, 34, 2, -42 },
  { 6525, 30, 43, 34, 3, -42 },
  { 6687, 33, 42, 34, 2, -42 },
  { 6861, 30, 52, 34, 3, -42 },
  { 7056, 32, 42, 34, 2, -42 },
  { 7224, 31, 43, 34, 2, -42 },
  { 7391, 30, 42, 34, 6, -42 },
  { 7549, 31, 43, 34, 3, -42 },
  { 7716, 30, 42, 34, 6, -42 },
  { 7874, 34, 42, 34, 3, -42 },
  { 8053, 37, 42, 34, -1, -42 },
  { 8248, 32, 42, 34, 5, -42 },
  { 8416, 31, 42, 34, 2, -42 },
  { 8579, 24, 53, 34, 7, -47 },
  { 8738, 19, 53, 34, 8, -47 },
  { 8864, 25, 53, 34, 4, -47 },
  { 9030, 27, 23, 34, 4, -42 },
  { 9108, 28, 7, 34, 0, 1 },
  { 9133, 12, 8, 34, 14, -45 },
  { 9145, 29, 33, 34, 3, -32 },
  { 9265, 30, 43, 34, 2, -42 },
  { 9427, 29, 33, 34, 3, -32 },
  { 9547, 31, 43, 34, 3, -42 },
  { 9714, 28, 33, 34, 3, -32 },
  { 9830, 39, 52, 34, -3, -42 },
  { 10084, 29, 42, 34, 3, -32 },
  { 10237, 30, 42, 34, 2, -42 },
  { 10395, 28, 45, 34, 2, -45 },
  { 10553, 30, 55, 34, 1, -45 },
  { 10760, 32, 42, 34, 2, -42 },
  { 10928, 25, 42, 34, 5, -42 },
  { 11060, 33, 32, 34, 0, -32 },
  { 11192, 30, 32, 34, 2, -32 },
  { 11312, 28, 33, 34, 3, -32 },
  { 11428, 32, 42, 34, 0, -32 },
  { 11596, 29, 42, 34, 3, -32 },
  { 11749, 30, 32, 34, 3, -32 },
  { 11869, 30, 33, 34, 2, -32 },
  { 11993, 29, 40, 34, 4, -40 },
  { 12138, 29, 32, 34, 3, -31 },
  { 12254, 29, 31, 34, 5, -31 },
  { 12367, 33, 31, 34, 3, -31 },
  { 12495, 34, 31, 34, 0, -31 },
  { 12627, 29, 41, 34, 3, -31 },
  { 12776, 30, 31, 34, 2, -31 },
  { 12893, 30, 53, 34, 5, -47 },
  { 13092, 16, 53, 34, 10, -47 },
  { 13198, 30, 53, 34, 1, -47 },
  { 13397, 30, 14, 34, 3, -27 },
};

const GFXfont JetBrainsMono_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_BOLDITALIC57PT7B_H_
