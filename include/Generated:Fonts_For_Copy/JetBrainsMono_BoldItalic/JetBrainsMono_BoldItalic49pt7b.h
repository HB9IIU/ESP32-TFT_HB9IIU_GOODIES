#ifndef _JETBRAINSMONO_BOLDITALIC49PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x00,
  0x3F, 0x0F, 0xE7, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xE0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xBB, 0xFC, 0x1F, 0xC7, 0x3F, 0x83, 0xF0,
  0xE3, 0xF0, 0x7E, 0x38, 0x7E, 0x1F, 0xC7, 0x0F, 0xC3, 0xF8, 0xE0, 0x00,
  0x7F, 0x1C, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xFE, 0x70, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x39, 0xFE, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0xE1, 0xF8, 0x00,
  0x1C, 0x3F, 0x1F, 0x87, 0x87, 0xE3, 0xF0, 0xE0, 0xFC, 0x7E, 0x1C, 0x3F,
  0x0F, 0xE3, 0x8F, 0xE1, 0xFE, 0x73, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0x1E, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x0F, 0x83,
  0xC0, 0x7C, 0x01, 0xE0, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x07, 0xC0, 0x07,
  0x81, 0xE1, 0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3E, 0x0F, 0x8F, 0x00,
  0x07, 0xC1, 0xE3, 0xC0, 0x00, 0x7C, 0xFC, 0xF8, 0x00, 0x0F, 0xFF, 0x3E,
  0x00, 0x00, 0xFF, 0xCF, 0x80, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0xF0,
  0x00, 0x07, 0xCF, 0xFF, 0x00, 0x01, 0xF3, 0xFF, 0xE0, 0x00, 0x3C, 0xF8,
  0x3C, 0x00, 0x0F, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0xF8,
  0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xF8, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x87, 0xC0, 0x1E, 0x00, 0xFF, 0xF8,
  0x07, 0x80, 0x1F, 0xFE, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x07, 0xF3, 0xFB, 0xF0, 0x7E,
  0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xF8, 0x7E, 0x1F, 0xDF, 0x87, 0xE0,
  0xFF, 0xF0, 0x7E, 0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0xFC, 0x03, 0xFC,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF7,
  0xF0, 0x3F, 0xFE, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x3F, 0x3F, 0x3F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x04, 0x03, 0xE0, 0x11, 0xE0, 0x78, 0x1E, 0x3F, 0x0F,
  0x0F, 0xCF, 0xF1, 0xE7, 0xF9, 0xFF, 0xB9, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xF8, 0x0F, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF,
  0xE0, 0x0E, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFE, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xFB, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0x07, 0xF0, 0x0E, 0x07, 0xE0, 0x08, 0x07, 0xE0, 0x10, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0xFB, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8,
  0x01, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x7C, 0x07, 0xF9, 0xE1,
  0xF0, 0x3F, 0xF7, 0x87, 0xC1, 0xFF, 0xFE, 0x1F, 0x07, 0xC1, 0xF8, 0xF8,
  0x3E, 0x07, 0xE3, 0xE0, 0xF8, 0x1F, 0x8F, 0x83, 0xE0, 0x7C, 0x3E, 0x1F,
  0x81, 0xF0, 0xF8, 0x7C, 0x07, 0xC3, 0xE1, 0xF0, 0x1F, 0x1F, 0x87, 0xC0,
  0x7C, 0x7C, 0x1F, 0x01, 0xF1, 0xF0, 0x7C, 0x0F, 0xC7, 0xC1, 0xF0, 0x3E,
  0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xE3, 0xF0, 0x7F, 0x7F, 0x8F,
  0x81, 0xFF, 0xBE, 0x3E, 0x03, 0xFE, 0xF8, 0xF8, 0x07, 0xE3, 0xC3, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFF, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x03, 0xF0, 0x0F, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F,
  0x87, 0xFF, 0xC3, 0xF0, 0xFF, 0xF8, 0x7E, 0x1F, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x81,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7B, 0xC1, 0xFF, 0x07, 0xFE, 0x0F,
  0xBC, 0x3D, 0xF0, 0x7D, 0xE1, 0xEF, 0x83, 0xEF, 0x1E, 0x7C, 0x3F, 0x78,
  0xF7, 0xC1, 0xF3, 0xCF, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x7C, 0xF7, 0xCF,
  0x83, 0xE3, 0xBC, 0xFC, 0x1F, 0x1F, 0xE7, 0xE0, 0xF8, 0xFE, 0x3E, 0x0F,
  0xC7, 0xF1, 0xF0, 0x7E, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xC0, 0x1F,
  0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xFC, 0x03, 0xF0, 0x7F,
  0xC0, 0x3F, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xE0, 0x7E, 0x0F, 0xDE, 0x07, 0xE0, 0xFD, 0xF0, 0x7E, 0x0F,
  0x9F, 0x07, 0xC0, 0xF9, 0xF0, 0x7C, 0x0F, 0x9F, 0x07, 0xC0, 0xF9, 0xF0,
  0xFC, 0x1F, 0x8F, 0x8F, 0xC1, 0xF8, 0xF8, 0xFC, 0x1F, 0x8F, 0x8F, 0xC1,
  0xF8, 0xF8, 0xF8, 0x1F, 0x0F, 0x8F, 0x81, 0xF0, 0x78, 0xF8, 0x1F, 0x07,
  0xDF, 0x83, 0xF0, 0x7D, 0xF8, 0x3F, 0x07, 0xDF, 0x83, 0xF0, 0x7D, 0xF0,
  0x3E, 0x03, 0xDF, 0x03, 0xE0, 0x3F, 0xF0, 0x3E, 0x03, 0xFF, 0x07, 0xE0,
  0x3F, 0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x01, 0xFE,
  0x07, 0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x7C, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x0F, 0xCF, 0x81, 0xF8, 0x3E,
  0x3E, 0x0E, 0xE0, 0xF8, 0xF8, 0x3F, 0x83, 0xE3, 0xE0, 0xFE, 0x1F, 0x0F,
  0x83, 0xF8, 0x7C, 0x3E, 0x1F, 0xC1, 0xF0, 0xF8, 0x77, 0x07, 0xC3, 0xE1,
  0xDC, 0x3E, 0x0F, 0x8F, 0x70, 0xF8, 0x3E, 0x3D, 0xC3, 0xE0, 0xF8, 0xE7,
  0x0F, 0x87, 0xC3, 0x9C, 0x7C, 0x1F, 0x1E, 0x71, 0xF0, 0x7C, 0x71, 0xC7,
  0xC1, 0xF1, 0xC7, 0x1F, 0x07, 0xC7, 0x1C, 0xF8, 0x1F, 0x3C, 0x73, 0xE0,
  0x7C, 0xE1, 0xCF, 0x81, 0xF3, 0x87, 0x3C, 0x07, 0xDE, 0x3D, 0xF0, 0x1F,
  0x78, 0xF7, 0xC0, 0x7D, 0xC3, 0xDF, 0x01, 0xF7, 0x0F, 0x78, 0x07, 0xFC,
  0x3F, 0xE0, 0x1E, 0xE0, 0xFF, 0x80, 0x7B, 0x83, 0xFE, 0x01, 0xEE, 0x0E,
  0xF0, 0x07, 0xF8, 0x3B, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C,
  0x3E, 0x00, 0xFC, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x8F, 0xC0, 0x7F, 0xF7, 0xF0, 0x3F, 0xFD, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFC, 0x07, 0xFF, 0x3F,
  0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xFC, 0x03,
  0xF3, 0xFF, 0x83, 0xFB, 0xFF, 0xC1, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE3, 0xFE, 0x0F, 0xF1, 0xFB, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0x7E,
  0xFF, 0xF8, 0x3F, 0x3F, 0xF8, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF1, 0xF8, 0x07, 0xFF, 0x7F, 0x01,
  0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xF0, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0x9F, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x7F, 0xF7, 0xF0, 0x3F, 0xFD, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xEF, 0xC0, 0x7F, 0xF3, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE3, 0xFC, 0x03, 0xF7, 0xFF, 0x83, 0xFB, 0xFF, 0xC1,
  0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7F,
  0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x0F, 0xC0,
  0x1F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xCF, 0x87, 0xE0,
  0x7D, 0xFE, 0x7F, 0x03, 0xEF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC,
  0x7E, 0x3F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xE0, 0xF8,
  0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xFC,
  0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x87, 0xE1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x78, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE0, 0x0F, 0xC7,
  0xF8, 0x07, 0xEF, 0xFF, 0x07, 0xE7, 0xFF, 0x83, 0xF7, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x7E, 0x7F, 0xF0, 0x1F, 0x9F, 0xFE, 0x03, 0xF7,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F,
  0xC1, 0xFE, 0x0F, 0xDF, 0xFF, 0x81, 0xFB, 0xFF, 0xF0, 0x3F, 0x7F, 0xFC,
  0x07, 0xE7, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x7F, 0xF7, 0xF0, 0x3F, 0xFD, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFC, 0x07,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0xFC, 0x07,
  0xFF, 0x3F, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xE3, 0xFC, 0x01, 0xF9, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFE,
  0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F,
  0x03, 0xEF, 0x83, 0xF0, 0x3C, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C,
  0xF8, 0x77, 0x07, 0xCF, 0x87, 0x70, 0xF8, 0xF8, 0x77, 0x0F, 0x8F, 0x8F,
  0x70, 0xF8, 0xF8, 0xE7, 0x1F, 0x0F, 0x8E, 0x71, 0xF0, 0xF9, 0xE7, 0x1F,
  0x0F, 0x9C, 0x71, 0xE0, 0xF9, 0xC7, 0x3E, 0x0F, 0xBC, 0x73, 0xE0, 0xFB,
  0x87, 0x3C, 0x0F, 0xB8, 0x77, 0xC0, 0xFB, 0x87, 0x7C, 0x0F, 0xF8, 0x77,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFF, 0x1D, 0xF8, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0xEF, 0xC0, 0x7F, 0xF3, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x40, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xF1,
  0xFF, 0xC0, 0x7C, 0xFF, 0xF8, 0x1F, 0x7F, 0xFF, 0x07, 0xDF, 0x8F, 0xC3,
  0xF7, 0xC1, 0xFD, 0xF9, 0xF0, 0x7F, 0xFE, 0x7C, 0x0F, 0xFF, 0x3F, 0x01,
  0xFF, 0x8F, 0x80, 0x3F, 0xC0,
};

const GFXglyph JetBrainsMono_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 13, 36, 29, 9, -36 },
  { 60, 19, 15, 29, 8, -36 },
  { 96, 29, 36, 29, 1, -36 },
  { 227, 27, 50, 29, 2, -43 },
  { 396, 35, 36, 29, -2, -36 },
  { 554, 28, 36, 29, 1, -36 },
  { 680, 8, 15, 29, 13, -36 },
  { 695, 21, 47, 29, 7, -41 },
  { 819, 21, 47, 29, 2, -41 },
  { 943, 27, 26, 29, 2, -30 },
  { 1031, 24, 23, 29, 3, -28 },
  { 1100, 14, 15, 29, 4, -7 },
  { 1127, 18, 6, 29, 6, -19 },
  { 1141, 10, 9, 29, 8, -9 },
  { 1153, 31, 46, 29, 0, -41 },
  { 1332, 26, 36, 29, 2, -36 },
  { 1449, 24, 36, 29, 2, -36 },
  { 1557, 26, 36, 29, 2, -36 },
  { 1674, 26, 36, 29, 2, -36 },
  { 1791, 25, 36, 29, 2, -36 },
  { 1904, 26, 36, 29, 2, -36 },
  { 2021, 25, 36, 29, 2, -36 },
  { 2134, 25, 36, 29, 5, -36 },
  { 2247, 26, 36, 29, 2, -36 },
  { 2364, 25, 36, 29, 4, -36 },
  { 2477, 13, 27, 29, 8, -27 },
  { 2521, 17, 35, 29, 4, -27 },
  { 2596, 24, 27, 29, 4, -30 },
  { 2677, 24, 18, 29, 3, -25 },
  { 2731, 25, 27, 29, 2, -30 },
  { 2816, 21, 36, 29, 6, -36 },
  { 2911, 30, 45, 29, 0, -36 },
  { 3080, 26, 36, 29, 0, -36 },
  { 3197, 27, 36, 29, 2, -36 },
  { 3319, 27, 36, 29, 2, -36 },
  { 3441, 27, 36, 29, 2, -36 },
  { 3563, 27, 36, 29, 2, -36 },
  { 3685, 28, 36, 29, 2, -36 },
  { 3811, 27, 36, 29, 2, -36 },
  { 3933, 27, 36, 29, 2, -36 },
  { 4055, 27, 36, 29, 2, -36 },
  { 4177, 29, 37, 29, 0, -36 },
  { 4312, 29, 36, 29, 2, -36 },
  { 4443, 22, 36, 29, 3, -36 },
  { 4542, 29, 36, 29, 1, -36 },
  { 4673, 28, 36, 29, 1, -36 },
  { 4799, 26, 36, 29, 2, -36 },
  { 4916, 28, 36, 29, 2, -36 },
  { 5042, 26, 45, 29, 2, -36 },
  { 5189, 27, 36, 29, 2, -36 },
  { 5311, 28, 36, 29, 1, -36 },
  { 5437, 26, 36, 29, 5, -36 },
  { 5554, 27, 36, 29, 2, -36 },
  { 5676, 26, 36, 29, 5, -36 },
  { 5793, 30, 36, 29, 2, -36 },
  { 5928, 32, 36, 29, -1, -36 },
  { 6072, 27, 36, 29, 5, -36 },
  { 6194, 27, 36, 29, 2, -36 },
  { 6316, 21, 46, 29, 6, -41 },
  { 6437, 16, 46, 29, 7, -41 },
  { 6529, 21, 46, 29, 4, -41 },
  { 6650, 23, 19, 29, 4, -36 },
  { 6705, 24, 6, 29, 0, 1 },
  { 6723, 11, 6, 29, 12, -38 },
  { 6732, 26, 27, 29, 2, -27 },
  { 6820, 25, 36, 29, 2, -36 },
  { 6933, 25, 27, 29, 2, -27 },
  { 7018, 27, 36, 29, 2, -36 },
  { 7140, 25, 27, 29, 2, -27 },
  { 7225, 34, 45, 29, -3, -36 },
  { 7417, 26, 36, 29, 2, -27 },
  { 7534, 25, 36, 29, 2, -36 },
  { 7647, 25, 39, 29, 1, -39 },
  { 7769, 27, 48, 29, 0, -39 },
  { 7931, 28, 36, 29, 2, -36 },
  { 8057, 22, 36, 29, 4, -36 },
  { 8156, 29, 27, 29, 0, -27 },
  { 8254, 25, 27, 29, 2, -27 },
  { 8339, 25, 27, 29, 2, -27 },
  { 8424, 27, 36, 29, 0, -27 },
  { 8546, 26, 36, 29, 2, -27 },
  { 8663, 27, 27, 29, 2, -27 },
  { 8755, 25, 27, 29, 2, -27 },
  { 8840, 25, 34, 29, 3, -34 },
  { 8947, 26, 27, 29, 2, -27 },
  { 9035, 26, 27, 29, 4, -27 },
  { 9123, 28, 27, 29, 3, -27 },
  { 9218, 29, 27, 29, 0, -27 },
  { 9316, 26, 36, 29, 2, -27 },
  { 9433, 25, 27, 29, 2, -27 },
  { 9518, 26, 46, 29, 4, -41 },
  { 9668, 13, 46, 29, 9, -41 },
  { 9743, 26, 46, 29, 1, -41 },
  { 9893, 26, 11, 29, 2, -23 },
};

const GFXfont JetBrainsMono_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_BOLDITALIC49PT7B_H_
