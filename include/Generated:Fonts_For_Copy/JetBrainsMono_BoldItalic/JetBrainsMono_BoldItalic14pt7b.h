#ifndef _JETBRAINSMONO_BOLDITALIC14PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x22, 0x60, 0x66, 0x6D, 0x2D, 0xB6, 0x09, 0x0D, 0x9F,
  0xEF, 0xE3, 0x61, 0x23, 0xFC, 0xD8, 0x48, 0x64, 0x00, 0x04, 0x04, 0x1F,
  0x3B, 0x28, 0x38, 0x3C, 0x1E, 0x0A, 0x52, 0x76, 0x7C, 0x10, 0x10, 0x3C,
  0x49, 0x22, 0x50, 0xE8, 0x04, 0x03, 0xC1, 0xF8, 0xD2, 0x24, 0xB1, 0xC0,
  0x1E, 0x32, 0x30, 0x30, 0x70, 0x7B, 0x4E, 0xCC, 0xCE, 0x7E, 0xFE, 0x04,
  0x73, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x18, 0x30, 0x40, 0x20, 0xC1,
  0x82, 0x0C, 0x20, 0x86, 0x18, 0x63, 0x1C, 0xC2, 0x00, 0x18, 0x32, 0x4F,
  0xF1, 0x0F, 0x33, 0x24, 0x18, 0x20, 0x47, 0xF3, 0x06, 0x0C, 0x00, 0x36,
  0x6C, 0xF8, 0x7C, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x3C, 0xCD, 0x1E, 0x3F, 0x7A,
  0xF1, 0x42, 0xCC, 0xF0, 0x3D, 0xA5, 0x86, 0x18, 0x61, 0x84, 0xFF, 0xF0,
  0x1E, 0x33, 0x63, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFE, 0x7E, 0x0C,
  0x61, 0x83, 0xC1, 0x81, 0x46, 0xCD, 0xF0, 0x0E, 0x30, 0x61, 0x86, 0x78,
  0xBF, 0x7E, 0x0C, 0x18, 0x7E, 0xC1, 0x82, 0xCF, 0xC0, 0x81, 0x06, 0xDD,
  0xF0, 0x06, 0x0C, 0x18, 0x30, 0x3E, 0x67, 0x43, 0x42, 0x66, 0x3C, 0x7F,
  0x42, 0xC6, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0x1E, 0x33, 0x23,
  0x32, 0x1C, 0x3E, 0x62, 0x42, 0x66, 0x7C, 0x3C, 0xCF, 0x1E, 0x3E, 0xEF,
  0x82, 0x0C, 0x30, 0xC0, 0x37, 0x20, 0x00, 0x6E, 0x19, 0xC4, 0x00, 0x00,
  0xCC, 0x66, 0x00, 0x06, 0x3B, 0xC6, 0x0F, 0x07, 0x83, 0x00, 0x7F, 0x00,
  0x07, 0xEF, 0xC0, 0x60, 0xF0, 0x78, 0x23, 0xDC, 0x20, 0x00, 0x7A, 0x70,
  0xC2, 0x79, 0x84, 0x00, 0xC3, 0x00, 0x1F, 0x10, 0x98, 0x69, 0xE4, 0x92,
  0xCB, 0x6D, 0xA6, 0xDF, 0x60, 0x30, 0x0F, 0x01, 0x80, 0x0C, 0x38, 0x78,
  0xB3, 0x64, 0xDF, 0xBF, 0xC7, 0x84, 0x3E, 0x33, 0x23, 0x23, 0x7C, 0x66,
  0x63, 0x62, 0x4E, 0xFC, 0x3E, 0xCD, 0x1E, 0x0C, 0x18, 0x30, 0x66, 0xDC,
  0xF0, 0x3E, 0x33, 0x23, 0x63, 0x63, 0x63, 0x62, 0x66, 0x7E, 0xFC, 0x7E,
  0xC1, 0x82, 0x0F, 0xD8, 0x30, 0x60, 0xFD, 0xF8, 0x3F, 0x30, 0x20, 0x20,
  0x7E, 0x7E, 0x60, 0x60, 0x40, 0xC0, 0x3E, 0xCD, 0x1E, 0x0C, 0x1B, 0xF1,
  0x66, 0xCC, 0xF0, 0x33, 0x33, 0x23, 0x23, 0x7F, 0x7E, 0x66, 0x66, 0x46,
  0xC6, 0x7E, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0xFD, 0xF8, 0x0F, 0x03,
  0x03, 0x03, 0x02, 0x06, 0x06, 0xC6, 0xEC, 0x78, 0x33, 0x99, 0x89, 0x8C,
  0xC7, 0xC3, 0xE1, 0xB0, 0xCC, 0x46, 0x63, 0x00, 0x61, 0x86, 0x18, 0x41,
  0x0C, 0x30, 0xFF, 0xF0, 0x33, 0x99, 0x9D, 0x4E, 0xA7, 0xF2, 0xD9, 0x0C,
  0x84, 0xC2, 0x63, 0x00, 0x31, 0x31, 0x3B, 0x7B, 0x6B, 0x6A, 0x6A, 0x4E,
  0x4E, 0xC6, 0x3C, 0xCD, 0x1E, 0x3C, 0x78, 0xB1, 0x66, 0xDC, 0xF0, 0x3F,
  0x19, 0x88, 0x44, 0x67, 0xF3, 0xF1, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x3C,
  0xCD, 0x1E, 0x3C, 0x78, 0xF1, 0x66, 0xDC, 0xF0, 0x60, 0xC0, 0xC0, 0x3E,
  0x33, 0x23, 0x63, 0x7E, 0x7C, 0x6C, 0x64, 0x46, 0xC6, 0x1F, 0x33, 0x20,
  0x30, 0x3C, 0x0E, 0x02, 0x42, 0x66, 0x7C, 0x7F, 0x98, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x62, 0xCD, 0x1E, 0x3C, 0x78, 0xB1, 0x66,
  0xDC, 0xF0, 0xC3, 0x46, 0x46, 0x64, 0x6C, 0x6C, 0x68, 0x78, 0x70, 0x70,
  0xD9, 0xDB, 0xDA, 0xAA, 0xAA, 0xAE, 0xAC, 0xCC, 0xCC, 0xCC, 0x33, 0x99,
  0x85, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x48, 0x66, 0x63, 0x00, 0xC3, 0x66,
  0x64, 0x6C, 0x28, 0x38, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x03, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0x7E, 0xFE, 0x3C, 0xF6, 0x18, 0x61, 0x86, 0x10,
  0x43, 0x0C, 0x30, 0xF3, 0xC0, 0xC6, 0x10, 0x86, 0x31, 0x84, 0x31, 0x8C,
  0x61, 0x0C, 0x3C, 0xF0, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x61, 0x04, 0xF3,
  0xC0, 0x18, 0x78, 0xB3, 0x2C, 0x60, 0xFF, 0xFC, 0xEC, 0x36, 0xFF, 0x1E,
  0x2C, 0x59, 0xB7, 0x7E, 0x30, 0x30, 0x2E, 0x3E, 0x63, 0x62, 0x62, 0x66,
  0x66, 0xDC, 0x3C, 0xFB, 0x1E, 0x0C, 0x19, 0xB3, 0x3C, 0x06, 0x0C, 0xDB,
  0xFC, 0x78, 0xB1, 0x66, 0xDD, 0xF8, 0x38, 0xFB, 0x1F, 0xEF, 0xD0, 0x33,
  0x3C, 0x07, 0xC1, 0x80, 0xC0, 0xFE, 0x3F, 0x83, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x83, 0xC0, 0xC0, 0x00, 0x36, 0xFF, 0x1E, 0x2C, 0x59, 0xBF,
  0x16, 0x0D, 0xF3, 0x80, 0x30, 0x30, 0x2E, 0x3E, 0x63, 0x62, 0x62, 0x66,
  0x46, 0xC6, 0x0E, 0x18, 0x01, 0xE3, 0xC1, 0x82, 0x04, 0x08, 0xFF, 0xF8,
  0x03, 0x06, 0x00, 0x3E, 0x3E, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0xF8, 0xE0, 0x30, 0x30, 0x23, 0x23, 0x66, 0x7C, 0x7C, 0x6C, 0x46, 0xC6,
  0xF8, 0x43, 0x0C, 0x30, 0xC2, 0x08, 0x3C, 0xF0, 0x7B, 0x6F, 0x6B, 0x4B,
  0x4B, 0x5A, 0xD2, 0xD2, 0x2E, 0x7E, 0x63, 0x62, 0x62, 0x66, 0x46, 0xC6,
  0x38, 0xFB, 0x1E, 0x2C, 0x59, 0xB7, 0x3C, 0x2E, 0x7E, 0x63, 0x62, 0x62,
  0x66, 0x66, 0x5C, 0xC0, 0xC0, 0xC0, 0x36, 0xFF, 0x1E, 0x2C, 0x59, 0xB7,
  0x7E, 0x0C, 0x10, 0x20, 0x7C, 0xFD, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0x1E,
  0x3F, 0x60, 0x78, 0x1E, 0x02, 0x66, 0x7C, 0x10, 0x63, 0xFF, 0xF3, 0x06,
  0x08, 0x30, 0x7C, 0x78, 0x47, 0x8F, 0x1E, 0x2C, 0x59, 0xB7, 0x3C, 0xC3,
  0x8D, 0x12, 0x66, 0x8F, 0x1C, 0x38, 0x93, 0x92, 0xAA, 0xB6, 0xB4, 0xD4,
  0xCC, 0xD8, 0x63, 0x36, 0x36, 0x1C, 0x18, 0x3C, 0x64, 0xC6, 0x47, 0x8F,
  0x1E, 0x2C, 0xD9, 0xBF, 0x06, 0x0D, 0xF3, 0x80, 0x3F, 0x3F, 0x06, 0x0C,
  0x18, 0x30, 0x7E, 0xFE, 0x03, 0x0E, 0x08, 0x08, 0x18, 0x18, 0xF0, 0xF0,
  0x18, 0x10, 0x30, 0x30, 0x3C, 0x08, 0x13, 0x33, 0x32, 0x26, 0x66, 0x66,
  0x4C, 0x30, 0x38, 0x0C, 0x08, 0x18, 0x18, 0x1F, 0x1E, 0x10, 0x10, 0x30,
  0x30, 0xF0, 0xC0, 0x61, 0xEE, 0x78, 0x60,
};

const GFXglyph JetBrainsMono_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 6, 4, 8, 2, -10 },
  { 9, 9, 10, 8, 0, -10 },
  { 21, 8, 14, 8, 0, -12 },
  { 35, 10, 10, 8, -1, -10 },
  { 48, 8, 10, 8, 0, -10 },
  { 58, 2, 4, 8, 4, -10 },
  { 59, 6, 14, 8, 2, -12 },
  { 70, 6, 14, 8, 1, -12 },
  { 81, 7, 8, 8, 1, -9 },
  { 88, 7, 7, 8, 1, -8 },
  { 95, 4, 4, 8, 1, -2 },
  { 97, 5, 1, 8, 2, -5 },
  { 98, 3, 2, 8, 2, -2 },
  { 99, 9, 14, 8, 0, -12 },
  { 115, 7, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 8, 10, 8, 0, -10 },
  { 142, 7, 10, 8, 1, -10 },
  { 151, 7, 10, 8, 1, -10 },
  { 160, 7, 10, 8, 1, -10 },
  { 169, 8, 10, 8, 0, -10 },
  { 179, 8, 10, 8, 1, -10 },
  { 189, 8, 10, 8, 0, -10 },
  { 199, 7, 10, 8, 1, -10 },
  { 208, 4, 8, 8, 2, -8 },
  { 212, 5, 10, 8, 1, -8 },
  { 219, 7, 7, 8, 1, -8 },
  { 226, 7, 5, 8, 1, -7 },
  { 231, 7, 7, 8, 1, -8 },
  { 238, 6, 10, 8, 2, -10 },
  { 246, 9, 13, 8, 0, -10 },
  { 261, 7, 10, 8, 0, -10 },
  { 270, 8, 10, 8, 0, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 8, 10, 8, 0, -10 },
  { 299, 7, 10, 8, 1, -10 },
  { 308, 8, 10, 8, 0, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 8, 10, 8, 0, -10 },
  { 337, 7, 10, 8, 1, -10 },
  { 346, 8, 10, 8, 0, -10 },
  { 356, 9, 10, 8, 0, -10 },
  { 368, 6, 10, 8, 1, -10 },
  { 376, 9, 10, 8, 0, -10 },
  { 388, 8, 10, 8, 0, -10 },
  { 398, 7, 10, 8, 1, -10 },
  { 407, 9, 10, 8, 0, -10 },
  { 419, 7, 13, 8, 1, -10 },
  { 431, 8, 10, 8, 0, -10 },
  { 441, 8, 10, 8, 0, -10 },
  { 451, 8, 10, 8, 1, -10 },
  { 461, 7, 10, 8, 1, -10 },
  { 470, 8, 10, 8, 1, -10 },
  { 480, 8, 10, 8, 1, -10 },
  { 490, 9, 10, 8, 0, -10 },
  { 502, 8, 10, 8, 1, -10 },
  { 512, 8, 10, 8, 0, -10 },
  { 522, 6, 14, 8, 2, -12 },
  { 533, 5, 14, 8, 2, -12 },
  { 542, 6, 14, 8, 1, -12 },
  { 553, 7, 5, 8, 1, -10 },
  { 558, 7, 2, 8, 0, 0 },
  { 560, 3, 2, 8, 3, -11 },
  { 561, 7, 8, 8, 1, -8 },
  { 568, 8, 10, 8, 0, -10 },
  { 578, 7, 8, 8, 1, -8 },
  { 585, 7, 10, 8, 1, -10 },
  { 594, 7, 8, 8, 1, -8 },
  { 601, 10, 13, 8, -1, -10 },
  { 618, 7, 11, 8, 1, -8 },
  { 628, 8, 10, 8, 0, -10 },
  { 638, 7, 11, 8, 0, -11 },
  { 648, 8, 14, 8, 0, -11 },
  { 662, 8, 10, 8, 0, -10 },
  { 672, 6, 10, 8, 1, -10 },
  { 680, 8, 8, 8, 0, -8 },
  { 688, 8, 8, 8, 0, -8 },
  { 696, 7, 8, 8, 1, -8 },
  { 703, 8, 11, 8, 0, -8 },
  { 714, 7, 11, 8, 1, -8 },
  { 724, 7, 8, 8, 1, -8 },
  { 731, 8, 8, 8, 0, -8 },
  { 739, 7, 10, 8, 1, -10 },
  { 748, 7, 8, 8, 1, -8 },
  { 755, 7, 8, 8, 1, -8 },
  { 762, 8, 8, 8, 1, -8 },
  { 770, 8, 8, 8, 0, -8 },
  { 778, 7, 11, 8, 1, -8 },
  { 788, 8, 8, 8, 0, -8 },
  { 796, 8, 14, 8, 1, -12 },
  { 810, 4, 14, 8, 2, -12 },
  { 817, 8, 14, 8, 0, -12 },
  { 831, 7, 4, 8, 1, -7 },
};

const GFXfont JetBrainsMono_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_BOLDITALIC14PT7B_H_
