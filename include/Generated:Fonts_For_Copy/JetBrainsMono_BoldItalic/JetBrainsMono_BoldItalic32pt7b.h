#ifndef _JETBRAINSMONO_BOLDITALIC32PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x1C,
  0x01, 0xC1, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0x87,
  0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xC3, 0x80, 0x38,
  0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x67, 0x87, 0x99, 0xE1, 0xE6,
  0x78, 0xF9, 0x80, 0x3E, 0x60, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0x7C, 0x01, 0x8F, 0x00,
  0x63, 0xCF, 0x18, 0xF3, 0xE6, 0x78, 0x7D, 0xBE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x00, 0x40, 0x01, 0x03, 0xF0, 0x0E, 0x07, 0xF8, 0x1C, 0x0E, 0x38, 0x38,
  0x0E, 0x18, 0x70, 0x0E, 0x38, 0xE0, 0x0E, 0x38, 0xE0, 0x0E, 0x39, 0xC0,
  0x0E, 0x73, 0x80, 0x0F, 0xF7, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x80, 0x00, 0x77, 0xE0, 0x00, 0xEF, 0xF0,
  0x01, 0xDE, 0x70, 0x03, 0x9C, 0x30, 0x07, 0x1C, 0x70, 0x0E, 0x1C, 0x70,
  0x0E, 0x1C, 0x70, 0x1C, 0x1E, 0xF0, 0x38, 0x1F, 0xE0, 0xF0, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x78,
  0x0E, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x1E, 0x7B, 0xC7, 0x9E, 0x3D, 0xE3,
  0xC7, 0xBC, 0x78, 0x7F, 0x0F, 0x0F, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07,
  0x87, 0xE0, 0xFF, 0xFE, 0x0F, 0xFB, 0xC0, 0xFC, 0x3C, 0x7F, 0xFD, 0xEF,
  0x7B, 0xDC, 0xE0, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7E, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x0F, 0xC1, 0xFC, 0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x38, 0xE7, 0xCC,
  0xFB, 0xFB, 0x7F, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1D, 0xC0,
  0x0F, 0x78, 0x07, 0x9F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x18, 0x10, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x18,
  0xF9, 0xFB, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81,
  0xE1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xCC, 0x78,
  0xF7, 0x9E, 0x39, 0xE7, 0x1E, 0x7B, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x7C, 0x7C, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0x78, 0x1C, 0x78, 0x18, 0x78, 0x20, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1,
  0xF0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0xE3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x08, 0x1F, 0x78, 0x0F, 0x3E, 0x07, 0x8F, 0x8F,
  0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x78, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x20, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0xFC, 0x0E, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x0F, 0x1E, 0x07,
  0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x9E,
  0x07, 0x8F, 0x87, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0xE0, 0xF8, 0x78, 0xF8, 0x3E, 0x78, 0x0F, 0x3C,
  0x07, 0xBE, 0x03, 0xDF, 0x03, 0xC7, 0xC3, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E,
  0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF8, 0x7E, 0xFF, 0xFC, 0x7F, 0xF8, 0x3E, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0xFC, 0x7C, 0x3E, 0x00, 0x03,
  0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x80, 0x7E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x0F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0x80,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xF3,
  0xC0, 0x0E, 0x3C, 0x1C, 0xE3, 0x87, 0xEE, 0x38, 0x7F, 0xE3, 0x8F, 0x1E,
  0x78, 0xE1, 0xE7, 0x8E, 0x1E, 0x71, 0xE1, 0xC7, 0x1E, 0x1C, 0x71, 0xC1,
  0xC7, 0x1C, 0x1C, 0x71, 0xC3, 0xCF, 0x1E, 0x7C, 0xF1, 0xFD, 0x8E, 0x0F,
  0xB8, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x0F, 0x38,
  0x07, 0x9C, 0x03, 0xCE, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0x8F,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x77, 0xC0, 0x3F, 0xC0, 0x1E, 0x0F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x8F, 0xC7, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x78, 0x7E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x8F, 0xF3, 0xCF, 0xF3, 0xC7,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F,
  0x87, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x3C, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x78, 0x3E, 0x3F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x0F,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x83, 0xF0, 0xF8, 0x3E, 0x0D, 0x83, 0xE1, 0xD8, 0x7E, 0x1D, 0x86, 0xE1,
  0xDC, 0xEE, 0x1D, 0xCF, 0xE1, 0xDD, 0xDC, 0x1D, 0xDD, 0xC1, 0xCF, 0x9C,
  0x3C, 0xFB, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC3, 0xC0, 0x3C, 0x38, 0x03,
  0x83, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x1F, 0x83, 0xC7,
  0xE0, 0xF1, 0xF8, 0x3C, 0x7E, 0x0F, 0x1F, 0x83, 0x87, 0xF0, 0xE1, 0xDC,
  0x78, 0xF7, 0x1E, 0x3D, 0xC7, 0x8F, 0x71, 0xE3, 0xDC, 0x70, 0xE3, 0x9C,
  0x38, 0xE7, 0x1E, 0x3B, 0xC7, 0x8E, 0xF1, 0xE3, 0xBC, 0x78, 0xFF, 0x1C,
  0x1F, 0x87, 0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x8F, 0x03,
  0xE0, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x8F, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x78,
  0x3F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x07,
  0xCF, 0x01, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x7C, 0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78,
  0x3F, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xCF, 0x00, 0xF3, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xF1, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x0F, 0x03, 0x8F, 0x01, 0xE7,
  0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x38, 0x78, 0xF3, 0x87,
  0x8E, 0x38, 0xF0, 0xE3, 0x8F, 0x0E, 0x38, 0xF1, 0xE7, 0x8F, 0x1C, 0x79,
  0xB1, 0xC7, 0x9B, 0x1C, 0x79, 0xB3, 0xC7, 0x3B, 0x38, 0x73, 0x33, 0x87,
  0x33, 0x38, 0x73, 0x37, 0x87, 0x73, 0x70, 0x76, 0x37, 0x07, 0x63, 0x70,
  0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C,
  0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x80,
  0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0x9E, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0,
  0x78, 0x1E, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xDE, 0x03, 0xE7,
  0x80, 0xF1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1,
  0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0x03, 0xCF, 0x0F, 0x0E, 0x1C,
  0x1C, 0x78, 0x3D, 0xE0, 0x7F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF0, 0xF0, 0xF1, 0xF0, 0x03, 0xE7, 0x83, 0xFB, 0xC7, 0xFD, 0xE3,
  0xFF, 0xF3, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xF1,
  0xF8, 0xFF, 0xFC, 0x3F, 0xDE, 0x0F, 0xDE, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xE0, 0x7B, 0xF8, 0x3B,
  0xFE, 0x3F, 0xFF, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07,
  0x8F, 0x8F, 0xCF, 0x7F, 0xC7, 0xBF, 0xC3, 0xCF, 0xC0, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF9, 0xE0, 0x7F,
  0x78, 0x7F, 0xDE, 0x1F, 0xFF, 0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F, 0xF7, 0x81, 0xFB,
  0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xCF, 0x0F,
  0xEF, 0x3F, 0xEF, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7F, 0xBC, 0x1E, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xE0, 0x7B, 0xF8,
  0x3B, 0xFE, 0x3F, 0xFF, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF0, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF1,
  0xE0, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF1,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x78, 0xF8,
  0x1E, 0x1E, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x3C, 0x07, 0x8F,
  0x01, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x1C, 0xE3, 0x83, 0xBE, 0xF8,
  0x7F, 0xFF, 0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0x8F, 0x18, 0xF1,
  0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x1C, 0x79, 0xE3, 0x8E, 0x3C, 0x71, 0xC7,
  0x8E, 0x78, 0xF3, 0x8F, 0x1C, 0x71, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x1E,
  0x38, 0xE0, 0x1E, 0x7C, 0x0F, 0x7F, 0x0F, 0x7F, 0xC7, 0xFF, 0xE3, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x1E, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0x3E, 0x03, 0xDF, 0xC1, 0xEF, 0xF8,
  0x7F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0xE3, 0xF1, 0xEF, 0xF8, 0x7B, 0xFC, 0x1E, 0x7E, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE3, 0xFF, 0xF3, 0xE0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xDE, 0x0F,
  0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x3C, 0x7C, 0x1E, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3, 0xC1,
  0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xE3, 0xE3, 0xC0, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xF7, 0x80, 0xF3, 0xE0,
  0x78, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x03, 0xF8, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xF8, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0,
  0x79, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0xE1, 0xE1, 0xF8, 0x78, 0xFE, 0x1E, 0x3B, 0x8F,
  0x8E, 0xE3, 0xE7, 0xB8, 0xF9, 0xCE, 0x7E, 0x73, 0x9B, 0x9C, 0xE6, 0xEE,
  0x39, 0xBB, 0x8E, 0xCE, 0xE3, 0xB3, 0x70, 0xEC, 0xDC, 0x3E, 0x37, 0x0F,
  0x8D, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x00, 0x1E, 0x03, 0xE1,
  0xE0, 0xF8, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFB, 0xC0, 0x3E, 0x78, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x7C,
  0x1F, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xBC, 0x7F, 0x3C,
  0x0E, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xE1, 0xDF, 0xF0,
  0xEF, 0x3C, 0x77, 0x1F, 0xFB, 0x87, 0xFB, 0xC1, 0xF8,
};

const GFXglyph JetBrainsMono_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 12, 9, 19, 5, -23 },
  { 38, 20, 23, 19, 0, -23 },
  { 96, 18, 32, 19, 1, -28 },
  { 168, 24, 24, 19, -2, -24 },
  { 240, 19, 24, 19, 0, -24 },
  { 297, 5, 9, 19, 9, -23 },
  { 303, 13, 31, 19, 5, -27 },
  { 354, 13, 31, 19, 2, -27 },
  { 405, 18, 17, 19, 1, -20 },
  { 444, 16, 15, 19, 2, -18 },
  { 474, 9, 10, 19, 3, -5 },
  { 486, 12, 3, 19, 4, -12 },
  { 491, 7, 6, 19, 5, -6 },
  { 497, 20, 31, 19, 0, -27 },
  { 575, 18, 24, 19, 1, -24 },
  { 629, 16, 23, 19, 1, -23 },
  { 675, 17, 24, 19, 1, -24 },
  { 726, 17, 23, 19, 1, -23 },
  { 775, 17, 23, 19, 1, -23 },
  { 824, 17, 23, 19, 1, -23 },
  { 873, 17, 23, 19, 1, -23 },
  { 922, 17, 23, 19, 3, -23 },
  { 971, 17, 24, 19, 1, -24 },
  { 1022, 16, 24, 19, 3, -24 },
  { 1070, 9, 18, 19, 5, -18 },
  { 1091, 11, 23, 19, 3, -18 },
  { 1123, 16, 17, 19, 2, -19 },
  { 1157, 16, 11, 19, 2, -16 },
  { 1179, 16, 17, 19, 1, -19 },
  { 1213, 14, 23, 19, 4, -23 },
  { 1254, 20, 30, 19, 0, -24 },
  { 1329, 17, 23, 19, 0, -23 },
  { 1378, 18, 23, 19, 1, -23 },
  { 1430, 17, 24, 19, 2, -24 },
  { 1481, 18, 23, 19, 1, -23 },
  { 1533, 18, 23, 19, 1, -23 },
  { 1585, 18, 23, 19, 1, -23 },
  { 1637, 17, 24, 19, 2, -24 },
  { 1688, 18, 23, 19, 1, -23 },
  { 1740, 18, 23, 19, 1, -23 },
  { 1792, 19, 23, 19, 0, -23 },
  { 1847, 19, 23, 19, 1, -23 },
  { 1902, 14, 23, 19, 2, -23 },
  { 1943, 20, 23, 19, 0, -23 },
  { 2001, 18, 23, 19, 1, -23 },
  { 2053, 17, 24, 19, 2, -24 },
  { 2104, 18, 23, 19, 1, -23 },
  { 2156, 18, 30, 19, 1, -24 },
  { 2224, 18, 23, 19, 1, -23 },
  { 2276, 18, 24, 19, 1, -24 },
  { 2330, 17, 23, 19, 3, -23 },
  { 2379, 18, 23, 19, 1, -23 },
  { 2431, 17, 23, 19, 3, -23 },
  { 2480, 20, 23, 19, 1, -23 },
  { 2538, 21, 23, 19, -1, -23 },
  { 2599, 18, 23, 19, 3, -23 },
  { 2651, 18, 23, 19, 1, -23 },
  { 2703, 14, 31, 19, 4, -27 },
  { 2758, 10, 31, 19, 5, -27 },
  { 2797, 14, 31, 19, 2, -27 },
  { 2852, 15, 12, 19, 2, -23 },
  { 2875, 16, 3, 19, 0, 1 },
  { 2881, 7, 4, 19, 8, -25 },
  { 2885, 17, 18, 19, 1, -18 },
  { 2924, 17, 23, 19, 1, -23 },
  { 2973, 16, 18, 19, 2, -18 },
  { 3009, 18, 23, 19, 1, -23 },
  { 3061, 16, 18, 19, 2, -18 },
  { 3097, 22, 29, 19, -2, -23 },
  { 3177, 16, 24, 19, 2, -18 },
  { 3225, 17, 23, 19, 1, -23 },
  { 3274, 16, 25, 19, 1, -25 },
  { 3324, 18, 31, 19, 0, -25 },
  { 3394, 18, 23, 19, 1, -23 },
  { 3446, 14, 23, 19, 3, -23 },
  { 3487, 19, 18, 19, 0, -18 },
  { 3530, 17, 18, 19, 1, -18 },
  { 3569, 16, 18, 19, 2, -18 },
  { 3605, 18, 24, 19, 0, -18 },
  { 3659, 17, 24, 19, 1, -18 },
  { 3710, 17, 18, 19, 2, -18 },
  { 3749, 17, 18, 19, 1, -18 },
  { 3788, 16, 22, 19, 2, -22 },
  { 3832, 16, 18, 19, 2, -18 },
  { 3868, 16, 18, 19, 3, -18 },
  { 3904, 18, 18, 19, 2, -18 },
  { 3945, 19, 18, 19, 0, -18 },
  { 3988, 16, 24, 19, 2, -18 },
  { 4036, 17, 18, 19, 1, -18 },
  { 4075, 16, 31, 19, 3, -27 },
  { 4137, 8, 31, 19, 6, -27 },
  { 4168, 16, 31, 19, 1, -27 },
  { 4230, 17, 7, 19, 1, -15 },
};

const GFXfont JetBrainsMono_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_BOLDITALIC32PT7B_H_
