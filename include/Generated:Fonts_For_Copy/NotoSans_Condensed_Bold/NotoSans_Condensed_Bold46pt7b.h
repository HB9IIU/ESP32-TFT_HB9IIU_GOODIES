#ifndef _NOTOSANS_CONDENSED_BOLD46PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0xFE,
  0x3F, 0xFF, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9,
  0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xDC, 0x33,
  0xF3, 0x80, 0x7E, 0x70, 0x0F, 0xCE, 0x01, 0xFD, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3B, 0xF8, 0x07, 0x3F, 0x00, 0xE7, 0xF0,
  0x1C, 0xFF, 0x03, 0x9F, 0xFC, 0x77, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xFC, 0x03, 0xE0,
  0x07, 0xCF, 0x80, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1F, 0x1F, 0x03,
  0xC0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x0F,
  0x87, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0xF0, 0xFC, 0x1F, 0x1F, 0x3E, 0x3F,
  0xC3, 0xE7, 0xC7, 0x8F, 0xFC, 0x3F, 0xF9, 0xF3, 0xFF, 0xC7, 0xFE, 0x3E,
  0x7C, 0xF8, 0x7F, 0xCF, 0x8F, 0x1F, 0x07, 0xE1, 0xF3, 0xE1, 0xF0, 0x00,
  0x7C, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x03, 0xE0, 0xF8,
  0x7C, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x1F, 0x01, 0xE1, 0xE0, 0x03, 0xE0,
  0x3E, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x03,
  0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xC7, 0xFF, 0xC3, 0xF8, 0xFF, 0xFC, 0x7F,
  0x3F, 0xBF, 0x8F, 0xC7, 0xF3, 0xFB, 0xF9, 0xFC, 0x3F, 0xFF, 0x3F, 0x83,
  0xFF, 0xC7, 0xF0, 0x7F, 0xF8, 0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0xC3,
  0xFC, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFE, 0x07, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x03,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x06,
  0x0F, 0x0E, 0x7C, 0xF7, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x9F,
  0x01, 0xF9, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0xF0, 0x06, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0xFE, 0x7F, 0x1F, 0x87, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xDF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F,
  0x7F, 0xFC, 0xFC, 0xF1, 0xF9, 0xC3, 0xF1, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF1,
  0xFE, 0x3C, 0x0F, 0xE1, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF8, 0x7F, 0x8C,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0x9F, 0x80,
  0x7D, 0xFC, 0x07, 0xCF, 0xE0, 0x3C, 0x7F, 0x03, 0xE3, 0xF8, 0x1E, 0x1F,
  0xC1, 0xF0, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x8F, 0x81, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0x9F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFA, 0x00, 0x7F, 0x78,
  0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7F, 0x07, 0xCF,
  0xF8, 0x7D, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F, 0x07, 0xF3, 0xF8, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0xFE, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07,
  0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xBF, 0x0F, 0xF3, 0xF0, 0x38, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7E, 0x7E,
  0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x7E, 0x08,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0x0F,
  0xE3, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0xC0, 0x7C, 0x3E, 0x0F, 0xFE, 0x3E, 0x7C, 0x1F, 0xFE, 0x3E,
  0x7C, 0x3F, 0xFE, 0x1E, 0x78, 0x3E, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x7E, 0x3E,
  0xF8, 0x7C, 0x7E, 0x3C, 0xF8, 0x7F, 0xFF, 0xFC, 0x78, 0x3F, 0xEF, 0xF8,
  0x7C, 0x1F, 0xC7, 0xF0, 0x7C, 0x07, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80,
  0x0F, 0xFC, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x03,
  0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x1F, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xF8, 0xF8, 0xFF, 0x00, 0x87, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x04, 0x7F, 0xE1,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x83, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0x87, 0xF8, 0x02, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0xFC, 0xFF, 0x01, 0xF8, 0xFF, 0x03, 0xF1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7,
  0xFC, 0x1F, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xBF,
  0xFB, 0xE0, 0x1F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0xEF, 0x80, 0xFB, 0xFF,
  0xDF, 0x81, 0xF7, 0xFF, 0x9F, 0x03, 0xEF, 0xFF, 0x3E, 0x0F, 0xDF, 0xFE,
  0x7C, 0x1F, 0x3F, 0xFC, 0xFC, 0x3E, 0x7F, 0xF8, 0xF8, 0x7C, 0xFF, 0xF1,
  0xF1, 0xF1, 0xFF, 0xE3, 0xF3, 0xE3, 0xFF, 0xC3, 0xE7, 0xC7, 0xFF, 0x87,
  0xDF, 0x8F, 0xFF, 0x0F, 0xBE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF,
  0x83, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8,
  0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xC0, 0x7E, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7E, 0x07, 0xFF, 0xBF, 0x83, 0xFF, 0xCF,
  0xC1, 0xFF, 0xE7, 0xF0, 0xFF, 0xF1, 0xF8, 0x7F, 0xF8, 0xFE, 0x3F, 0xFC,
  0x3F, 0x1F, 0xFE, 0x1F, 0x8F, 0xFF, 0x0F, 0xE7, 0xFF, 0x83, 0xF3, 0xFF,
  0xC1, 0xFD, 0xFF, 0xE0, 0x7E, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE0,
  0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0xEF, 0xCF, 0xE0, 0x33, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xFB, 0xF1, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x3F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xBF, 0x80, 0x7F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x07,
  0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x80, 0xFC,
  0x7F, 0x03, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x1F, 0xC3, 0xF0, 0x3D,
  0xF0, 0x7F, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x3F, 0x07, 0xDF, 0x07, 0xE0,
  0xFE, 0x1F, 0x7C, 0x1F, 0x81, 0xF8, 0x7D, 0xF8, 0xFE, 0x07, 0xE3, 0xF3,
  0xE3, 0xF0, 0x1F, 0x8F, 0xCF, 0x8F, 0xC0, 0x7E, 0x3E, 0x3E, 0x3F, 0x00,
  0xFC, 0xF8, 0xF8, 0xFC, 0x03, 0xF3, 0xE3, 0xF3, 0xF0, 0x0F, 0xDF, 0x87,
  0xDF, 0x80, 0x3F, 0x7C, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x01,
  0xF7, 0xC1, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xDF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x00,
  0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x3F, 0xC3, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xF9, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0x7F, 0xDF,
  0xFF, 0xF9, 0xFF, 0xDF, 0x3F, 0xF3, 0xE3, 0xFC, 0x3C, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0x80, 0xFC, 0xFF,
  0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0,
  0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x9F, 0xF8, 0xF8, 0xFE,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFC, 0x08, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x17, 0xF0, 0x33, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x30, 0x3F, 0x0F, 0xF3,
  0xF1, 0xFF, 0xBF, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0x9F, 0x0F, 0xE1,
  0xF0, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFF, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x0C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xC4, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0x80, 0x00, 0xFF, 0x1F, 0x1F, 0xFB, 0xF3, 0xFF, 0xBF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xBF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x40, 0x0F, 0xE7, 0xC1, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0x83, 0xF3, 0xFC,
  0x7E, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFB,
  0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0xF8, 0xFF, 0x07, 0xF8,
  0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x0F, 0xF8, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0x1C, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFC, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0xFE,
  0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0,
  0x1F, 0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x18, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7E, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFD,
  0xFF, 0x8F, 0xC7, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0x1F, 0x1F, 0xFB, 0xF3, 0xFF, 0xBF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0xE1, 0xFF, 0x9F, 0xFE, 0x7F,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFC, 0xFE, 0x3C, 0xFC, 0x04, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0xC0, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x82, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF,
  0x9F, 0x1F, 0xE3, 0xE0, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xBF, 0x03, 0xFC, 0x0F, 0xDF, 0x81, 0xFE,
  0x07, 0xEF, 0xC0, 0xFF, 0x07, 0xF7, 0xF0, 0xFF, 0x83, 0xF1, 0xF8, 0x7F,
  0xC1, 0xF8, 0xFC, 0x3D, 0xF0, 0xFC, 0x7E, 0x1E, 0xF8, 0x7E, 0x3F, 0x0F,
  0x3C, 0x7E, 0x0F, 0xCF, 0x9E, 0x3F, 0x07, 0xE7, 0xCF, 0x1F, 0x83, 0xF3,
  0xC7, 0xCF, 0xC1, 0xF9, 0xE3, 0xEF, 0xC0, 0x7C, 0xF0, 0xF7, 0xE0, 0x3E,
  0x78, 0x7B, 0xF0, 0x1F, 0xFC, 0x3D, 0xF8, 0x0F, 0xFE, 0x1E, 0xF8, 0x07,
  0xFE, 0x0F, 0x7C, 0x01, 0xFF, 0x07, 0xBE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFB,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE7,
  0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xF3, 0xF0, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x02, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x17, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xE8, 0x00, 0x10,
};

const GFXglyph NotoSans_Condensed_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 34, 12, 2, -33 },
  { 35, 17, 12, 21, 2, -33 },
  { 61, 23, 33, 25, 1, -33 },
  { 156, 19, 38, 23, 2, -35 },
  { 247, 35, 33, 37, 1, -33 },
  { 392, 27, 33, 28, 1, -33 },
  { 504, 7, 12, 11, 2, -33 },
  { 515, 12, 40, 15, 2, -33 },
  { 575, 12, 40, 15, 1, -33 },
  { 635, 20, 19, 22, 1, -35 },
  { 683, 19, 22, 23, 2, -27 },
  { 736, 9, 11, 12, 1, -5 },
  { 749, 12, 6, 14, 1, -15 },
  { 758, 8, 8, 12, 2, -7 },
  { 766, 18, 33, 19, 0, -33 },
  { 841, 19, 33, 23, 2, -33 },
  { 920, 15, 33, 23, 2, -33 },
  { 982, 20, 33, 23, 1, -33 },
  { 1065, 19, 33, 23, 2, -33 },
  { 1144, 21, 33, 23, 1, -33 },
  { 1231, 19, 33, 23, 2, -33 },
  { 1310, 20, 33, 23, 1, -33 },
  { 1393, 20, 33, 23, 1, -33 },
  { 1476, 20, 33, 23, 1, -33 },
  { 1559, 20, 33, 23, 1, -33 },
  { 1642, 8, 26, 12, 2, -25 },
  { 1668, 8, 31, 12, 2, -25 },
  { 1699, 20, 23, 23, 1, -28 },
  { 1757, 20, 14, 23, 1, -23 },
  { 1792, 19, 23, 23, 2, -28 },
  { 1847, 18, 34, 18, 0, -33 },
  { 1924, 32, 37, 36, 2, -33 },
  { 2072, 26, 33, 27, 0, -33 },
  { 2180, 21, 33, 26, 3, -33 },
  { 2267, 21, 33, 24, 2, -33 },
  { 2354, 23, 33, 28, 3, -33 },
  { 2449, 16, 33, 22, 3, -33 },
  { 2515, 16, 33, 21, 3, -33 },
  { 2581, 23, 33, 28, 2, -33 },
  { 2676, 23, 33, 29, 3, -33 },
  { 2771, 13, 33, 16, 1, -33 },
  { 2825, 13, 43, 13, -3, -33 },
  { 2895, 23, 33, 26, 3, -33 },
  { 2990, 17, 33, 21, 3, -33 },
  { 3061, 31, 33, 38, 3, -33 },
  { 3189, 25, 33, 32, 3, -33 },
  { 3293, 26, 33, 30, 2, -33 },
  { 3401, 20, 33, 24, 3, -33 },
  { 3484, 26, 41, 30, 2, -33 },
  { 3618, 22, 33, 26, 3, -33 },
  { 3709, 18, 33, 21, 2, -33 },
  { 3784, 20, 33, 22, 1, -33 },
  { 3867, 23, 33, 29, 3, -33 },
  { 3962, 25, 33, 25, 0, -33 },
  { 4066, 38, 33, 37, 0, -33 },
  { 4223, 24, 33, 24, 0, -33 },
  { 4322, 24, 33, 24, 0, -33 },
  { 4421, 19, 33, 21, 1, -33 },
  { 4500, 10, 40, 15, 3, -33 },
  { 4550, 18, 33, 19, 0, -33 },
  { 4625, 11, 40, 15, 1, -33 },
  { 4680, 23, 21, 25, 1, -33 },
  { 4741, 19, 3, 19, 0, 4 },
  { 4749, 11, 7, 15, 2, -35 },
  { 4759, 19, 26, 23, 1, -26 },
  { 4821, 20, 35, 25, 3, -35 },
  { 4909, 17, 26, 20, 2, -26 },
  { 4965, 20, 35, 25, 2, -35 },
  { 5053, 19, 26, 23, 2, -26 },
  { 5115, 16, 35, 15, 1, -35 },
  { 5185, 20, 37, 25, 2, -26 },
  { 5278, 19, 35, 25, 3, -35 },
  { 5362, 6, 35, 12, 3, -35 },
  { 5389, 11, 46, 12, -2, -35 },
  { 5453, 21, 35, 24, 3, -35 },
  { 5545, 6, 35, 12, 3, -35 },
  { 5572, 32, 26, 37, 3, -26 },
  { 5676, 19, 26, 25, 3, -26 },
  { 5738, 21, 26, 24, 2, -26 },
  { 5807, 20, 37, 25, 3, -26 },
  { 5900, 20, 37, 25, 2, -26 },
  { 5993, 14, 26, 17, 3, -26 },
  { 6039, 16, 26, 19, 2, -26 },
  { 6091, 15, 30, 17, 1, -30 },
  { 6148, 19, 25, 25, 3, -25 },
  { 6208, 22, 25, 22, 0, -25 },
  { 6277, 33, 25, 34, 0, -25 },
  { 6381, 21, 25, 22, 0, -25 },
  { 6447, 22, 36, 22, 0, -25 },
  { 6546, 16, 25, 18, 1, -25 },
  { 6596, 15, 40, 17, 0, -33 },
  { 6671, 5, 46, 22, 8, -35 },
  { 6700, 14, 40, 17, 2, -33 },
  { 6770, 20, 8, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_Bold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_BOLD46PT7B_H_
