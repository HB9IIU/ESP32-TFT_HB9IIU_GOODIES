#ifndef _NOTOSANS_CONDENSED_BOLD37PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B, 0xE3, 0xDF, 0x1E, 0x78, 0xF0,
  0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xE0,
  0x0F, 0x1C, 0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07,
  0x9E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0xC3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFF, 0x7D, 0x84, 0xFB, 0x01, 0xF6, 0x03, 0xEC, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0C, 0xF8, 0x19, 0xF8, 0x33, 0xF8, 0x67, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x04, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x78, 0x07, 0xFC, 0x07,
  0x00, 0x79, 0xE0, 0xF0, 0x0F, 0x1E, 0x0F, 0x00, 0xF1, 0xE1, 0xE0, 0x0F,
  0x1E, 0x1E, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE7,
  0x80, 0x0F, 0x1E, 0x78, 0xF8, 0x79, 0xE7, 0x3F, 0xC7, 0xFC, 0xF3, 0xFE,
  0x3F, 0xCF, 0x7D, 0xE3, 0xF9, 0xE7, 0x8E, 0x0E, 0x1E, 0x78, 0xF0, 0x03,
  0xC7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x78, 0x78,
  0xF0, 0x07, 0x87, 0x8F, 0x00, 0xF0, 0x78, 0xF0, 0x0F, 0x07, 0xDE, 0x01,
  0xE0, 0x3F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFD,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xE3, 0xFF, 0x1F, 0x9F, 0xFC, 0x7C, 0x7C, 0xF9, 0xF3, 0xF3, 0xFF, 0xCF,
  0x87, 0xFE, 0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F,
  0x07, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x63, 0xCE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0x7C, 0x78, 0x0C,
  0x30, 0x00, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0x9F, 0x71, 0xF2, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x1F,
  0xF0, 0x3F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0x20, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x30, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0E, 0xF8, 0x0F, 0x7C, 0x07, 0x3E, 0x07, 0x9F, 0x03, 0x8F, 0x83, 0xC7,
  0xC3, 0xC3, 0xE1, 0xE1, 0xF1, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xCF, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xD8, 0x1F, 0xBF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x79, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7E, 0x3E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7E, 0x7E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xC0, 0x21, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0xFB, 0xFF, 0xFF, 0x78, 0x08, 0x79, 0xFB, 0xF7,
  0xE7, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xE0, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x3E, 0x1E, 0x78, 0x7F, 0xC7, 0x38,
  0x7F, 0xE3, 0xFC, 0x7C, 0xF1, 0xFE, 0x3C, 0x78, 0xFF, 0x3C, 0x3C, 0x7F,
  0x1E, 0x1E, 0x3F, 0x8F, 0x0F, 0x1F, 0xC7, 0x87, 0x8F, 0xE3, 0xC3, 0xC7,
  0xF1, 0xE1, 0xE3, 0xF8, 0xF0, 0xF1, 0xDE, 0x3C, 0xFD, 0xEF, 0x1F, 0xEF,
  0xE7, 0x87, 0xE7, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x08, 0x07, 0xF0, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x3F,
  0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x11, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x08, 0xFE, 0x1C, 0x7F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xF8, 0x7F, 0x3E, 0x0F, 0xEF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0,
  0x7E, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xE0, 0x67, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF3, 0xF0, 0x7C, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3F, 0x0F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xF8, 0x0F, 0xFE,
  0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE7, 0xE0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3F, 0x0F, 0x8F, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x83,
  0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xDE, 0x03,
  0xFF, 0xEF, 0x03, 0xDF, 0xF7, 0x81, 0xEF, 0xFB, 0xE0, 0xF7, 0xFC, 0xF0,
  0xFB, 0xFF, 0x78, 0x79, 0xFF, 0xBC, 0x3C, 0xFF, 0xDF, 0x1E, 0x7F, 0xE7,
  0x9E, 0x3F, 0xF3, 0xCF, 0x1F, 0xF9, 0xE7, 0x8F, 0xFC, 0xFF, 0xC7, 0xFE,
  0x3F, 0xC3, 0xFF, 0x1F, 0xE1, 0xFF, 0x8F, 0xF0, 0xFF, 0xC3, 0xF0, 0x7F,
  0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x1E, 0x07,
  0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x7C, 0x1F, 0xF7, 0xC1, 0xFF,
  0x3E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3F, 0x1F, 0xF1, 0xF1, 0xFF, 0x9F, 0x9F,
  0xF8, 0xF9, 0xFF, 0x8F, 0xDF, 0xF8, 0x7D, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0,
  0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8,
  0x7E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x87, 0xE3, 0xE7, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7E, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x07,
  0xF0, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xC3,
  0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x3F, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xBF, 0x8F, 0xE7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0,
  0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07,
  0x9F, 0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xDF,
  0x03, 0xF0, 0x3F, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x83, 0xE7, 0xC1,
  0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F,
  0x87, 0xC3, 0xE3, 0xCF, 0x1F, 0x0F, 0x8F, 0x3C, 0x7C, 0x3E, 0x3C, 0xF1,
  0xF0, 0x7C, 0xF3, 0xCF, 0x81, 0xF7, 0xCF, 0xBE, 0x07, 0xDF, 0x1E, 0xF8,
  0x1F, 0x78, 0x7B, 0xE0, 0x3D, 0xE1, 0xEF, 0x80, 0xF7, 0x87, 0xBC, 0x03,
  0xDE, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8,
  0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0x9F, 0x01, 0xF9, 0xF0, 0x1F, 0x1F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0xF9,
  0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0,
  0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xE1, 0xF0, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0xC0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF1, 0xE7, 0xE2, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFE,
  0xF3, 0xF8, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x40, 0xF9, 0xF8, 0x7D, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xC3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7,
  0xE0, 0xFB, 0xF0, 0x7D, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0xFF,
  0x1E, 0x3F, 0x00, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF9,
  0xF8, 0x27, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x0C, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x04, 0x1F, 0x0F, 0xCF, 0x8F,
  0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0,
  0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFB, 0xE1, 0xF8, 0xF0, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0x00, 0x07, 0xE7,
  0xC7, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8,
  0x3F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFD, 0xF0, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x40,
  0x1F, 0x3E, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x60, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7B, 0xEF, 0xFE, 0x78,
  0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x0F, 0x0F, 0x87, 0xE3, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0xBF, 0x7F, 0xBF, 0x9F, 0xCF, 0x80, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0x83, 0xE3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xF8, 0x3E, 0x3F,
  0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xFB,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x1C, 0x3C,
  0x7F, 0x1F, 0xCF, 0xBF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xE3, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x1F, 0xF8, 0x1F,
  0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8,
  0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F,
  0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x60, 0xF1, 0xFC, 0xFB, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00,
  0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xF9,
  0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7E, 0x1F, 0x1F,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x60, 0x7C, 0xFC,
  0x3E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF8,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7,
  0xC0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFE, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0x7F, 0x8F, 0x9F, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x03, 0x00, 0x07, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0,
  0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0, 0xFC, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x6F, 0x1F, 0xFB, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0x00, 0xFF, 0x9F, 0xFE, 0xFF, 0xEF, 0xCF, 0x7C, 0x0B, 0xE0, 0x1F,
  0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xCF,
  0x1F, 0x8F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xF8,
  0x1F, 0x83, 0xEF, 0x87, 0xF0, 0x79, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3,
  0xE7, 0xC3, 0xB8, 0x7C, 0x7C, 0x77, 0x8F, 0x0F, 0x9E, 0xF3, 0xE1, 0xF3,
  0xDE, 0x7C, 0x3E, 0x79, 0xCF, 0x83, 0xCE, 0x39, 0xF0, 0x79, 0xC7, 0x3C,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xBF, 0x0F, 0x8F,
  0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x7D, 0xF0, 0x7E, 0x7C, 0x3E, 0x3E, 0x3F, 0x0F, 0x9F, 0x07, 0xDF,
  0x81, 0xF0, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0xFF, 0x0F, 0xC0, 0xFE, 0x0F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0x80,
  0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 9, 17, 2, -26 },
  { 36, 19, 26, 20, 1, -26 },
  { 98, 15, 30, 18, 2, -28 },
  { 155, 28, 27, 30, 1, -27 },
  { 250, 22, 27, 23, 1, -27 },
  { 325, 5, 9, 9, 2, -26 },
  { 331, 9, 32, 12, 2, -26 },
  { 367, 9, 32, 12, 1, -26 },
  { 403, 16, 16, 18, 1, -28 },
  { 435, 16, 18, 18, 1, -22 },
  { 471, 7, 9, 10, 1, -4 },
  { 479, 9, 4, 11, 1, -12 },
  { 484, 6, 6, 10, 2, -6 },
  { 489, 15, 27, 15, 0, -27 },
  { 540, 16, 27, 18, 1, -27 },
  { 594, 12, 26, 18, 2, -26 },
  { 633, 16, 27, 18, 1, -27 },
  { 687, 16, 27, 18, 1, -27 },
  { 741, 17, 26, 18, 1, -26 },
  { 797, 15, 26, 18, 2, -26 },
  { 846, 16, 27, 18, 1, -27 },
  { 900, 16, 26, 18, 1, -26 },
  { 952, 16, 27, 18, 1, -27 },
  { 1006, 16, 27, 18, 1, -27 },
  { 1060, 6, 21, 10, 2, -21 },
  { 1076, 7, 26, 10, 1, -21 },
  { 1099, 16, 18, 18, 1, -22 },
  { 1135, 16, 12, 18, 1, -19 },
  { 1159, 16, 18, 18, 1, -22 },
  { 1195, 14, 27, 15, 0, -27 },
  { 1243, 25, 30, 29, 2, -27 },
  { 1337, 21, 26, 21, 0, -26 },
  { 1406, 16, 26, 21, 3, -26 },
  { 1458, 17, 27, 20, 2, -27 },
  { 1516, 18, 26, 23, 3, -26 },
  { 1575, 13, 26, 18, 3, -26 },
  { 1618, 13, 26, 17, 3, -26 },
  { 1661, 18, 27, 23, 2, -27 },
  { 1722, 18, 26, 24, 3, -26 },
  { 1781, 10, 26, 12, 1, -26 },
  { 1814, 10, 34, 11, -2, -26 },
  { 1857, 18, 26, 21, 3, -26 },
  { 1916, 13, 26, 17, 3, -26 },
  { 1959, 25, 26, 30, 3, -26 },
  { 2041, 20, 26, 25, 3, -26 },
  { 2106, 20, 27, 24, 2, -27 },
  { 2174, 15, 26, 20, 3, -26 },
  { 2223, 20, 33, 24, 2, -27 },
  { 2306, 18, 26, 21, 3, -26 },
  { 2365, 15, 27, 17, 1, -27 },
  { 2416, 16, 26, 18, 1, -26 },
  { 2468, 18, 26, 23, 3, -26 },
  { 2527, 20, 26, 20, 0, -26 },
  { 2592, 30, 26, 30, 0, -26 },
  { 2690, 20, 26, 20, 0, -26 },
  { 2755, 19, 26, 19, 0, -26 },
  { 2817, 15, 26, 17, 1, -26 },
  { 2866, 9, 32, 12, 2, -26 },
  { 2902, 15, 27, 15, 0, -27 },
  { 2953, 8, 32, 12, 1, -26 },
  { 2985, 18, 16, 20, 1, -26 },
  { 3021, 15, 3, 15, 0, 3 },
  { 3027, 10, 6, 12, 1, -28 },
  { 3035, 15, 21, 19, 1, -21 },
  { 3075, 17, 28, 20, 2, -28 },
  { 3135, 14, 21, 16, 1, -21 },
  { 3172, 17, 28, 20, 1, -28 },
  { 3232, 16, 21, 18, 1, -21 },
  { 3274, 13, 28, 12, 0, -28 },
  { 3320, 17, 30, 20, 1, -21 },
  { 3384, 16, 28, 20, 2, -28 },
  { 3440, 6, 28, 10, 2, -28 },
  { 3461, 9, 37, 10, -1, -28 },
  { 3503, 18, 28, 19, 2, -28 },
  { 3566, 5, 28, 10, 2, -28 },
  { 3584, 26, 21, 30, 2, -21 },
  { 3653, 16, 21, 20, 2, -21 },
  { 3695, 17, 21, 20, 1, -21 },
  { 3740, 17, 30, 20, 2, -21 },
  { 3804, 17, 30, 20, 1, -21 },
  { 3868, 12, 21, 14, 2, -21 },
  { 3900, 13, 21, 15, 1, -21 },
  { 3935, 11, 25, 13, 1, -25 },
  { 3970, 16, 20, 20, 2, -20 },
  { 4010, 18, 20, 18, 0, -20 },
  { 4055, 27, 20, 27, 0, -20 },
  { 4123, 17, 20, 17, 0, -20 },
  { 4166, 18, 29, 18, 0, -20 },
  { 4232, 13, 20, 15, 1, -20 },
  { 4265, 12, 32, 13, 0, -26 },
  { 4313, 4, 37, 18, 7, -28 },
  { 4332, 12, 32, 13, 1, -26 },
  { 4380, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Bold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_BOLD37PT7B_H_
