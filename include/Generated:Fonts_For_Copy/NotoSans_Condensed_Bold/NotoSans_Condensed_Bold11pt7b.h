#ifndef _NOTOSANS_CONDENSED_BOLD11PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x73, 0xF5, 0x14, 0x33, 0xF8,
  0xC3, 0x97, 0xE4, 0x20, 0x66, 0x7A, 0x3D, 0x1F, 0x66, 0xF0, 0xAC, 0x5E,
  0x66, 0x30, 0xB1, 0x63, 0x97, 0x5B, 0xB3, 0x3F, 0xE0, 0x2D, 0x2C, 0x92,
  0x64, 0xC9, 0x92, 0x4B, 0x58, 0x27, 0xCC, 0xB0, 0x21, 0x09, 0xF2, 0x10,
  0x70, 0xFC, 0xC0, 0x11, 0x32, 0x64, 0x4C, 0x72, 0xF7, 0x9C, 0xED, 0x6E,
  0x7E, 0x92, 0x49, 0x76, 0xC6, 0x33, 0x11, 0x1F, 0xF2, 0xC6, 0xE7, 0x8E,
  0x7E, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xF8, 0x8E, 0x33, 0xBE, 0x3B, 0x11,
  0xFD, 0xE5, 0x6E, 0xF8, 0x46, 0x23, 0x18, 0x8C, 0x72, 0xD6, 0xE7, 0x67,
  0x2E, 0x72, 0xF7, 0xB7, 0x8C, 0x6E, 0xCC, 0x50, 0x1C, 0x08, 0xD9, 0xC3,
  0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x3E, 0x40, 0xF9, 0x13, 0x60, 0x66,
  0x1C, 0x62, 0x5D, 0x55, 0xF5, 0x75, 0x5A, 0x62, 0x3C, 0x30, 0xE3, 0x9A,
  0x49, 0xFC, 0xF1, 0xF4, 0xE7, 0xEF, 0x4E, 0x7E, 0x7E, 0xA1, 0x08, 0x43,
  0x2E, 0xF5, 0xE7, 0x18, 0xCE, 0x7E, 0xF8, 0x8E, 0xE8, 0x8F, 0xF8, 0x88,
  0xE8, 0x88, 0x7E, 0x61, 0x0B, 0xCF, 0x6F, 0x8C, 0x63, 0xFF, 0xC6, 0x31,
  0xED, 0xB6, 0xDF, 0x24, 0x92, 0x49, 0x3C, 0x9C, 0xAD, 0xCE, 0x5A, 0x53,
  0x88, 0x88, 0x88, 0x8F, 0xC7, 0x8F, 0xBD, 0x5A, 0xB5, 0x6C, 0xC9, 0xCF,
  0x3E, 0xEB, 0xBE, 0x79, 0xE3, 0x73, 0x68, 0xE3, 0x8E, 0x3D, 0x9C, 0xEB,
  0x99, 0xF8, 0x88, 0x73, 0x68, 0xE3, 0x8E, 0x3D, 0x9C, 0x18, 0x30, 0xF5,
  0xA7, 0x2E, 0x5A, 0x53, 0x7A, 0xB0, 0xC3, 0x0E, 0x7E, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x8C, 0x63, 0x18, 0xC7, 0x6E, 0xCF, 0x34, 0x92, 0x79, 0xE3,
  0x0C, 0x89, 0xE4, 0xF7, 0x6A, 0xA5, 0x52, 0xB9, 0xDC, 0xCC, 0xCD, 0x67,
  0x8C, 0x31, 0xE5, 0xB3, 0xCD, 0x27, 0x9C, 0x30, 0xC3, 0x0C, 0xF8, 0xC4,
  0x66, 0x23, 0x1F, 0xEA, 0xAA, 0xB0, 0xC4, 0x46, 0x22, 0x31, 0xED, 0xB6,
  0xDB, 0x7C, 0x20, 0xC7, 0x12, 0xCC, 0xF8, 0xE0, 0x70, 0xDF, 0xBD, 0xB4,
  0x84, 0x3D, 0x29, 0xCA, 0x5E, 0x7A, 0x31, 0x84, 0xB8, 0x08, 0x5E, 0x9C,
  0xE5, 0x2F, 0x72, 0x7F, 0x84, 0xBC, 0x74, 0xF4, 0x44, 0x44, 0x7A, 0x73,
  0x94, 0xBC, 0x2F, 0x70, 0x88, 0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x78,
  0x84, 0x27, 0x6E, 0x72, 0xD3, 0xFF, 0xFF, 0x36, 0x4C, 0x99, 0x32, 0x40,
  0xF9, 0x99, 0x99, 0x7A, 0x73, 0x94, 0xBC, 0xF4, 0xA5, 0x39, 0x7A, 0x10,
  0x80, 0x7A, 0x73, 0x94, 0xBC, 0x21, 0x08, 0xFA, 0x49, 0x00, 0x7C, 0x63,
  0x9F, 0x4F, 0x44, 0x44, 0x70, 0x99, 0x99, 0x9F, 0xCE, 0xD6, 0xA7, 0x18,
  0xDB, 0xDB, 0x5A, 0x56, 0x66, 0x66, 0xDA, 0x9C, 0xE5, 0x6C, 0xCA, 0xD6,
  0xE7, 0x18, 0x9C, 0xC0, 0xF3, 0x26, 0x4F, 0x36, 0x66, 0xCE, 0x66, 0x63,
  0xFF, 0xE0, 0xC6, 0x66, 0x77, 0x66, 0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 9, 8, 9, 0, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 1, 3, 3, 1, -8 },
  { 33, 3, 10, 4, 0, -8 },
  { 37, 3, 10, 4, 0, -8 },
  { 41, 5, 4, 5, 0, -8 },
  { 44, 5, 6, 5, 0, -7 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 1, 2, 3, 1, -2 },
  { 51, 4, 8, 4, 0, -8 },
  { 55, 5, 8, 5, 0, -8 },
  { 60, 3, 8, 5, 1, -8 },
  { 63, 5, 8, 5, 0, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 4, 8, 5, 1, -8 },
  { 82, 5, 8, 5, 0, -8 },
  { 87, 5, 8, 5, 0, -8 },
  { 92, 5, 8, 5, 0, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 1, 6, 3, 1, -6 },
  { 103, 2, 7, 3, 0, -6 },
  { 105, 5, 6, 5, 0, -7 },
  { 109, 5, 4, 5, 0, -6 },
  { 112, 5, 6, 5, 0, -7 },
  { 116, 4, 8, 4, 0, -8 },
  { 120, 8, 9, 9, 0, -8 },
  { 129, 6, 8, 6, 0, -8 },
  { 135, 5, 8, 6, 1, -8 },
  { 140, 5, 8, 6, 1, -8 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 4, 8, 5, 1, -8 },
  { 154, 4, 8, 5, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 3, 8, 4, 0, -8 },
  { 171, 3, 10, 3, -1, -8 },
  { 175, 5, 8, 6, 1, -8 },
  { 180, 4, 8, 5, 1, -8 },
  { 184, 7, 8, 9, 1, -8 },
  { 191, 6, 8, 8, 1, -8 },
  { 197, 6, 8, 7, 1, -8 },
  { 203, 4, 8, 6, 1, -8 },
  { 207, 6, 10, 7, 1, -8 },
  { 215, 5, 8, 6, 1, -8 },
  { 220, 5, 8, 5, 0, -8 },
  { 225, 5, 8, 5, 0, -8 },
  { 230, 5, 8, 7, 1, -8 },
  { 235, 6, 8, 6, 0, -8 },
  { 241, 9, 8, 9, 0, -8 },
  { 250, 6, 8, 6, 0, -8 },
  { 256, 6, 8, 6, 0, -8 },
  { 262, 5, 8, 5, 0, -8 },
  { 267, 2, 10, 3, 1, -8 },
  { 270, 4, 8, 4, 0, -8 },
  { 274, 3, 10, 3, 0, -8 },
  { 278, 6, 5, 6, 0, -8 },
  { 282, 5, 1, 5, 0, 1 },
  { 283, 3, 1, 4, 0, -8 },
  { 284, 5, 6, 6, 0, -6 },
  { 288, 5, 8, 6, 1, -8 },
  { 293, 5, 6, 5, 0, -6 },
  { 297, 5, 8, 6, 0, -8 },
  { 302, 5, 6, 5, 0, -6 },
  { 306, 4, 8, 4, 0, -8 },
  { 310, 5, 9, 6, 0, -6 },
  { 316, 4, 8, 6, 1, -8 },
  { 320, 1, 8, 3, 1, -8 },
  { 321, 2, 11, 3, 0, -8 },
  { 324, 5, 8, 6, 1, -8 },
  { 329, 1, 8, 3, 1, -8 },
  { 330, 7, 6, 9, 1, -6 },
  { 336, 4, 6, 6, 1, -6 },
  { 339, 5, 6, 6, 0, -6 },
  { 343, 5, 9, 6, 1, -6 },
  { 349, 5, 9, 6, 0, -6 },
  { 355, 3, 6, 4, 1, -6 },
  { 358, 4, 6, 5, 0, -6 },
  { 361, 4, 7, 4, 0, -7 },
  { 365, 4, 6, 6, 1, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 8, 6, 8, 0, -6 },
  { 378, 5, 6, 5, 0, -6 },
  { 382, 5, 9, 5, 0, -6 },
  { 388, 4, 6, 4, 0, -6 },
  { 391, 4, 10, 4, 0, -8 },
  { 396, 1, 11, 5, 2, -8 },
  { 398, 4, 10, 4, 0, -8 },
  { 403, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_Bold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_BOLD11PT7B_H_
