#ifndef _NOTOSANS_CONDENSED_BOLD23PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x76, 0x66, 0x60, 0x2F, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0x67, 0x67, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF,
  0x1D, 0xC1, 0x98, 0x19, 0x8F, 0xFF, 0xFF, 0xF1, 0x98, 0x3B, 0x83, 0xB8,
  0x33, 0x03, 0x30, 0x08, 0x0F, 0x1F, 0xFF, 0xFE, 0x8F, 0x43, 0xE0, 0xF8,
  0x3E, 0x07, 0xC2, 0xE1, 0x78, 0xBF, 0x7F, 0xFC, 0xFC, 0x08, 0x04, 0x00,
  0x30, 0x00, 0x3E, 0x1C, 0x3F, 0x0C, 0x19, 0x8E, 0x0C, 0xE6, 0x06, 0x73,
  0x03, 0x3B, 0x01, 0x99, 0x9C, 0xFD, 0xDF, 0x3E, 0xDD, 0xCC, 0xEE, 0xE0,
  0x66, 0x70, 0x73, 0x38, 0x31, 0xDC, 0x18, 0xEE, 0x1C, 0x3E, 0x1C, 0x0E,
  0x00, 0x0C, 0x01, 0xF8, 0x1F, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xFC,
  0x07, 0xC0, 0x3C, 0x7B, 0xF3, 0xBB, 0xDD, 0xCF, 0xEE, 0x3E, 0x70, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0x78, 0xFF, 0xF6, 0xC0, 0x1C, 0xE3, 0x1C, 0x71,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0xE1, 0x87, 0xF0,
  0xC3, 0x8E, 0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0xC6, 0x38,
  0xC7, 0x38, 0x1C, 0x0E, 0x07, 0x1B, 0xBF, 0xFF, 0xFC, 0xF8, 0xEC, 0xF7,
  0x11, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x77, 0xEE, 0xEC, 0xFF, 0xFE, 0x2F, 0xFF, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x1C, 0x0F, 0xC7, 0xF3, 0xCE,
  0xE3, 0xB8, 0xEE, 0x3B, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0xB8,
  0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0x0F, 0x1F, 0x3F, 0x7F, 0xEF, 0x4F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1C, 0x3F, 0xBF,
  0xFC, 0xF4, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x87, 0x83, 0x83,
  0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x7F, 0xBF, 0xE8, 0x70, 0x38, 0x1C,
  0x0E, 0x7E, 0x3C, 0x1F, 0x80, 0xE0, 0x70, 0x38, 0x1F, 0xBF, 0xFE, 0xFE,
  0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x37, 0x0E, 0xE1, 0x9C,
  0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x7F,
  0x3F, 0x9C, 0x0E, 0x06, 0x07, 0x03, 0xFD, 0xFF, 0x47, 0x81, 0xC0, 0xE0,
  0x78, 0x3F, 0xFF, 0xFD, 0xFC, 0x07, 0x07, 0xE3, 0xF9, 0xE0, 0x70, 0x38,
  0x0E, 0x63, 0xFC, 0xFF, 0xBC, 0xEE, 0x3F, 0x87, 0xE3, 0xF8, 0xE7, 0x79,
  0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x1C,
  0x1F, 0xC7, 0xFB, 0x8E, 0xE3, 0xB8, 0xE7, 0x79, 0xFC, 0x3E, 0x1F, 0xCF,
  0x7B, 0x8E, 0xE1, 0xF8, 0x7F, 0x3B, 0xFE, 0x3F, 0x00, 0x1C, 0x1F, 0xCF,
  0xF3, 0x9E, 0xE3, 0xB8, 0xEE, 0x3F, 0x8F, 0xF7, 0xFF, 0x67, 0xD8, 0x0E,
  0x03, 0x81, 0xE8, 0xF1, 0xF8, 0x7C, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x02,
  0xFF, 0xF0, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x77, 0xEE, 0xEC, 0x00, 0x40,
  0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F,
  0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x7C, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x1C,
  0x7F, 0xBF, 0xC8, 0xF0, 0x38, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x06, 0x03,
  0x00, 0x00, 0x80, 0xF0, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x1E,
  0x3C, 0x38, 0x0C, 0x70, 0x06, 0x63, 0xF6, 0xE7, 0xF7, 0xEE, 0x73, 0xCE,
  0x63, 0xCC, 0x63, 0xCC, 0x67, 0xCE, 0x66, 0xEF, 0xFE, 0xE7, 0xBC, 0x60,
  0x00, 0x70, 0x00, 0x3C, 0x10, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x73, 0x87, 0x1C, 0x38, 0xE1,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x07, 0x38, 0x3F, 0xC1, 0xFE, 0x07, 0xFF,
  0x3F, 0xEE, 0x3F, 0x8F, 0xE3, 0xF8, 0xEF, 0xFB, 0xFC, 0xFF, 0xB8, 0xFE,
  0x1F, 0x87, 0xE3, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0x03, 0xFC, 0xFF, 0x3C,
  0x27, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xF3, 0x9F, 0x70,
  0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xEE,
  0x3D, 0xFF, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x03, 0x81, 0xFF, 0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE3, 0xFE, 0x3F, 0xF3, 0xFF, 0x0F, 0x70, 0xF7, 0x8F, 0x7F, 0xF3,
  0xFF, 0x1F, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xEF,
  0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0xFF, 0xBE, 0xE0, 0xE1, 0xFC, 0x7B, 0x8E, 0x73, 0x8E, 0xF1,
  0xDC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0x9C, 0x73, 0xCE, 0x39, 0xC7,
  0xB8, 0x77, 0x0F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1B, 0xF6, 0x37, 0xEE, 0xEF,
  0xDD, 0x9F, 0xBB, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC, 0xF1, 0xF8, 0xE3, 0xF1,
  0xC7, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE, 0x7E,
  0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x0F, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0x3C, 0x79,
  0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xFF, 0x7F, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xFF, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x07,
  0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0x3C, 0x79, 0xFF, 0xC7,
  0xFC, 0x1F, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0x1F,
  0xF3, 0x9E, 0x71, 0xCE, 0x3D, 0xC7, 0x38, 0xE7, 0xFC, 0xFE, 0x1F, 0xC3,
  0x9C, 0x73, 0x8E, 0x79, 0xC7, 0x38, 0xF7, 0x0F, 0x1C, 0x3F, 0xDF, 0xDE,
  0x6E, 0x07, 0x03, 0xC0, 0xF0, 0x7E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x3F,
  0xFD, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xFF, 0x9F, 0xF1, 0xF8,
  0xE0, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0E, 0x1C, 0x70, 0xE3, 0x87,
  0x18, 0x39, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0xE0, 0xE1, 0xFC, 0x1C, 0x3B, 0xC7, 0x87, 0x38, 0xF8, 0xE7,
  0x1F, 0x1C, 0xE3, 0x67, 0x9C, 0xEC, 0xE1, 0xDD, 0x9C, 0x3B, 0xBB, 0x87,
  0x67, 0x70, 0xEC, 0x6E, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0x87, 0xC0, 0xF0, 0x70, 0xF0, 0xF7, 0x9E, 0x39, 0xC3, 0x9C, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xDC, 0x39, 0xC7,
  0x8E, 0x70, 0xEF, 0x0F, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xDF, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xFF, 0xFF, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xF0,
  0x0C, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xB0, 0x67, 0x1C, 0x63, 0x0E, 0xE0,
  0xD8, 0x1C, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87, 0x1E, 0x3F, 0x9F, 0xE8,
  0x70, 0x38, 0xFD, 0xFF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFF, 0xF7, 0x98, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x71, 0xDF, 0x3F, 0xF7, 0x8E, 0xF1, 0xDE,
  0x3B, 0xC7, 0xF8, 0xEF, 0x1D, 0xE3, 0xBE, 0xF7, 0xFC, 0xEF, 0x80, 0x1E,
  0x3F, 0x7F, 0xF1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x7B, 0x7F, 0x3F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x39, 0xDF, 0xF7, 0xFF, 0xCF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x3D, 0xC0, 0x1E, 0x0F,
  0xC7, 0xFB, 0x8E, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x07, 0x19,
  0xFE, 0x3F, 0x80, 0x06, 0x1F, 0x3F, 0x38, 0x38, 0x3E, 0xFE, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0xDF, 0xF7,
  0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF,
  0x3D, 0xC0, 0x70, 0x1D, 0x0F, 0x7F, 0x9F, 0xC0, 0x80, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF7, 0x3B, 0xEF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0x2F, 0xF6, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF3, 0xC6, 0x00, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3B, 0xEF, 0x90, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE1, 0xF8, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F, 0xC3,
  0xF8, 0xEF, 0x39, 0xCE, 0x7B, 0x8E, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1C, 0xEF, 0xBF, 0xFF, 0xFF, 0xF3,
  0xE7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1,
  0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xE7, 0x3B, 0xEF, 0xFF, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0,
  0x1E, 0x0F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0x77, 0x3D, 0xFE, 0x3F, 0x00, 0xE7, 0x1D, 0xF3, 0xFF, 0x78, 0xEF, 0x1D,
  0xE3, 0xBC, 0x7F, 0x8E, 0xF1, 0xDE, 0x3B, 0xEF, 0x77, 0xCF, 0xF9, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x19, 0xDF, 0xF7, 0xFF,
  0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x3D,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xE7, 0xDF, 0xFF, 0xDF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x3C, 0x7F, 0xFE, 0xE2,
  0xE0, 0xF8, 0x7E, 0x3E, 0x0F, 0x07, 0xCF, 0xFE, 0xFC, 0x18, 0x38, 0x3F,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x77, 0xFD, 0xFF, 0x3C, 0xC0, 0xE0, 0xFE, 0x1D, 0xC7, 0x38, 0xE7, 0x1C,
  0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x83, 0x60, 0x7C, 0x0F, 0x80, 0xE0, 0xE1,
  0xC3, 0xF1, 0xE3, 0x9C, 0xF9, 0xCE, 0x6C, 0xE7, 0x36, 0x73, 0x9B, 0x70,
  0xFD, 0xB8, 0x7C, 0xFC, 0x3E, 0x3E, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xEE, 0x39, 0xEF, 0x1D, 0xC3, 0xF0, 0x3E, 0x07,
  0x80, 0xF8, 0x3F, 0x07, 0x71, 0xEE, 0x38, 0xEF, 0x1E, 0xE0, 0xFE, 0x1D,
  0xC7, 0x38, 0xE7, 0x1C, 0x77, 0x8E, 0xE1, 0xDC, 0x1B, 0x83, 0xE0, 0x7C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x7C, 0x0F, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0xF9, 0xE3, 0xE1, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3E,
  0x1C, 0xF9, 0xC3, 0x06, 0x0C, 0x18, 0x31, 0xE3, 0xC6, 0x00, 0x78, 0x7F,
  0xFD, 0xFE, 0x1C,
};

const GFXglyph NotoSans_Condensed_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 12, 16, 13, 0, -16 },
  { 39, 9, 18, 11, 1, -17 },
  { 60, 17, 17, 19, 1, -17 },
  { 97, 13, 17, 14, 1, -17 },
  { 125, 3, 6, 6, 1, -16 },
  { 128, 6, 20, 7, 1, -16 },
  { 143, 6, 20, 7, 0, -16 },
  { 158, 9, 10, 11, 1, -18 },
  { 170, 10, 11, 11, 1, -14 },
  { 184, 4, 6, 6, 1, -3 },
  { 187, 5, 3, 7, 1, -8 },
  { 189, 4, 4, 6, 1, -4 },
  { 191, 9, 17, 9, 0, -17 },
  { 211, 10, 17, 11, 1, -17 },
  { 233, 8, 16, 11, 1, -16 },
  { 249, 9, 17, 11, 1, -17 },
  { 269, 9, 17, 11, 1, -17 },
  { 289, 11, 16, 11, 0, -16 },
  { 311, 9, 16, 11, 1, -16 },
  { 329, 10, 17, 11, 1, -17 },
  { 351, 10, 16, 11, 1, -16 },
  { 371, 10, 17, 11, 1, -17 },
  { 393, 10, 17, 11, 1, -17 },
  { 415, 4, 13, 6, 1, -13 },
  { 422, 4, 16, 6, 1, -13 },
  { 430, 10, 11, 11, 1, -14 },
  { 444, 10, 7, 11, 1, -12 },
  { 453, 10, 11, 11, 1, -14 },
  { 467, 9, 17, 9, 0, -17 },
  { 487, 16, 19, 18, 1, -17 },
  { 525, 13, 16, 13, 0, -16 },
  { 551, 10, 16, 13, 2, -16 },
  { 571, 11, 17, 12, 1, -17 },
  { 595, 11, 16, 14, 2, -16 },
  { 617, 8, 16, 11, 2, -16 },
  { 633, 8, 16, 11, 2, -16 },
  { 649, 12, 17, 14, 1, -17 },
  { 675, 11, 16, 15, 2, -16 },
  { 697, 6, 16, 8, 1, -16 },
  { 709, 6, 21, 7, -1, -16 },
  { 725, 11, 16, 13, 2, -16 },
  { 747, 8, 16, 10, 2, -16 },
  { 763, 15, 16, 19, 2, -16 },
  { 793, 12, 16, 16, 2, -16 },
  { 817, 13, 17, 15, 1, -17 },
  { 845, 9, 16, 12, 2, -16 },
  { 863, 13, 21, 15, 1, -17 },
  { 898, 11, 16, 13, 2, -16 },
  { 920, 9, 17, 11, 1, -17 },
  { 940, 11, 16, 11, 0, -16 },
  { 962, 11, 16, 14, 2, -16 },
  { 984, 13, 16, 13, 0, -16 },
  { 1010, 19, 16, 19, 0, -16 },
  { 1048, 12, 16, 12, 0, -16 },
  { 1072, 12, 16, 12, 0, -16 },
  { 1096, 10, 16, 11, 0, -16 },
  { 1116, 6, 20, 7, 1, -16 },
  { 1131, 9, 17, 9, 0, -17 },
  { 1151, 5, 20, 7, 1, -16 },
  { 1164, 11, 10, 12, 1, -16 },
  { 1178, 9, 2, 9, 0, 2 },
  { 1181, 6, 4, 8, 1, -18 },
  { 1184, 9, 13, 12, 1, -13 },
  { 1199, 11, 17, 12, 1, -17 },
  { 1223, 8, 13, 10, 1, -13 },
  { 1236, 10, 17, 12, 1, -17 },
  { 1258, 10, 13, 11, 1, -13 },
  { 1275, 8, 18, 7, 0, -18 },
  { 1293, 10, 19, 12, 1, -13 },
  { 1317, 10, 17, 13, 1, -17 },
  { 1339, 4, 18, 6, 1, -18 },
  { 1348, 6, 24, 6, -1, -18 },
  { 1366, 10, 17, 12, 2, -17 },
  { 1388, 4, 17, 6, 1, -17 },
  { 1397, 16, 13, 19, 1, -13 },
  { 1423, 10, 13, 13, 1, -13 },
  { 1440, 10, 13, 12, 1, -13 },
  { 1457, 11, 19, 12, 1, -13 },
  { 1484, 10, 19, 12, 1, -13 },
  { 1508, 7, 13, 9, 1, -13 },
  { 1520, 8, 13, 9, 1, -13 },
  { 1533, 8, 15, 8, 0, -15 },
  { 1548, 10, 13, 13, 1, -13 },
  { 1565, 11, 13, 11, 0, -13 },
  { 1583, 17, 13, 17, 0, -13 },
  { 1611, 11, 13, 11, 0, -13 },
  { 1629, 11, 19, 11, 0, -13 },
  { 1656, 8, 13, 9, 1, -13 },
  { 1669, 7, 20, 8, 0, -16 },
  { 1687, 3, 23, 11, 4, -18 },
  { 1696, 7, 20, 8, 1, -16 },
  { 1714, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Bold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_BOLD23PT7B_H_
