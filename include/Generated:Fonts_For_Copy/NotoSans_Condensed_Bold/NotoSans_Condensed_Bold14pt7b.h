#ifndef _NOTOSANS_CONDENSED_BOLD14PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF5, 0x20, 0x16, 0x68, 0xD3, 0xF2, 0xC5,
  0xBF, 0x94, 0x68, 0xD0, 0x21, 0xBF, 0xDE, 0x78, 0xE7, 0xBF, 0xC8, 0x40,
  0x71, 0x8A, 0x63, 0x68, 0x6D, 0x05, 0x7C, 0xEA, 0xC3, 0x58, 0x4B, 0x19,
  0x62, 0x38, 0x38, 0x36, 0x1B, 0x0D, 0x83, 0x83, 0xDB, 0x3D, 0x9C, 0x7E,
  0x3F, 0xC0, 0xFE, 0x6B, 0x69, 0x24, 0xD9, 0x30, 0xC6, 0x23, 0x33, 0x33,
  0x32, 0x6C, 0x30, 0x47, 0xFF, 0x39, 0xB0, 0x10, 0x4F, 0xFF, 0x10, 0x40,
  0x6D, 0x60, 0xFF, 0xF0, 0x0C, 0x61, 0x84, 0x30, 0xC6, 0x18, 0x43, 0x00,
  0x39, 0xF6, 0xD3, 0xCF, 0x34, 0xDB, 0x7C, 0xE0, 0x37, 0xFB, 0x33, 0x33,
  0x33, 0x7B, 0xF4, 0xC3, 0x0C, 0x63, 0x18, 0x7F, 0xF0, 0xF9, 0xF0, 0xC3,
  0x38, 0xF0, 0xC3, 0xFF, 0xE0, 0x0C, 0x38, 0xF1, 0x66, 0xC9, 0xBF, 0xFF,
  0x0C, 0x18, 0xFF, 0xF1, 0x8F, 0x8C, 0x63, 0xFF, 0x80, 0x3D, 0xF6, 0x12,
  0xFF, 0xBC, 0x59, 0x7C, 0xE0, 0xFF, 0xF0, 0xC3, 0x18, 0x61, 0x8C, 0x31,
  0x80, 0x79, 0xB6, 0xDB, 0x39, 0xF4, 0xF1, 0x6D, 0xF0, 0x79, 0xFC, 0xF3,
  0x6D, 0xF2, 0x43, 0x5D, 0xE0, 0xF8, 0x0F, 0x6D, 0x00, 0x1B, 0x58, 0x06,
  0x39, 0xC7, 0x81, 0xC0, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0xE0, 0x70,
  0xF7, 0x18, 0x00, 0xFF, 0xC2, 0x33, 0x10, 0x80, 0x63, 0x80, 0x3E, 0x31,
  0xB2, 0x73, 0xDB, 0x6D, 0xB6, 0xDB, 0x77, 0xC0, 0x31, 0x0F, 0x80, 0x18,
  0x3C, 0x3C, 0x3C, 0x26, 0x66, 0x7E, 0x7E, 0xE3, 0xC3, 0xFB, 0xFC, 0xF3,
  0xFB, 0xFC, 0xF3, 0xFF, 0xE0, 0x3D, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xFD,
  0xF0, 0xF9, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE6, 0xFD, 0xF0, 0xFF, 0xF1,
  0x8F, 0xFF, 0x18, 0xFF, 0xC0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00,
  0x3E, 0xFB, 0x06, 0x0D, 0xFB, 0xF1, 0xE3, 0xFE, 0xFC, 0xC7, 0x8F, 0x1E,
  0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xF7, 0x66, 0x66, 0x66, 0x7F, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xCF, 0x9B, 0x67, 0xCF, 0x1F, 0x36,
  0x66, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE1, 0xF1,
  0xF8, 0xFE, 0x5F, 0x6E, 0xB7, 0x73, 0xB9, 0xDC, 0xE6, 0x40, 0xE3, 0xE3,
  0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF, 0xC7, 0x7D, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xFE, 0xF8, 0xFB, 0xFC, 0xF3, 0xDF, 0xEC, 0x30, 0xC3,
  0x00, 0x7D, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xF8, 0x30, 0x70,
  0xF9, 0xFB, 0x36, 0x6D, 0xDF, 0x36, 0x6C, 0xCD, 0x9C, 0x3D, 0xF6, 0x18,
  0x70, 0xE0, 0xC3, 0xFF, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFC, 0xF8, 0xC3, 0xC6,
  0x66, 0x66, 0x64, 0x2C, 0x3C, 0x3C, 0x38, 0x18, 0xC6, 0x7C, 0x66, 0xCE,
  0x64, 0xE6, 0x6B, 0x66, 0xBC, 0x7B, 0xC7, 0x9C, 0x39, 0xC3, 0x18, 0xE6,
  0xD9, 0xB1, 0xE3, 0x87, 0x0F, 0x36, 0x67, 0x8C, 0xC6, 0xCD, 0xB3, 0x63,
  0x87, 0x06, 0x0C, 0x18, 0x30, 0xFF, 0xF0, 0xC6, 0x30, 0xC6, 0x18, 0xFF,
  0xF0, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x06, 0x18, 0x30, 0xC1, 0x06,
  0x18, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x30, 0xE1, 0x66,
  0x58, 0xC0, 0xFC, 0xC8, 0x80, 0x39, 0xF0, 0xCF, 0x6F, 0x36, 0xDD, 0xC3,
  0x0C, 0x36, 0xFB, 0x3C, 0xF3, 0xCF, 0xFF, 0x80, 0x7F, 0xB1, 0x88, 0x63,
  0xEF, 0x0C, 0x30, 0xDB, 0xFF, 0x3C, 0xE3, 0xCF, 0x7F, 0xC0, 0x77, 0xF3,
  0xFF, 0xE3, 0x2F, 0x3B, 0xD8, 0xEF, 0x31, 0x8C, 0x63, 0x18, 0x6F, 0xFC,
  0xF3, 0x8F, 0x3D, 0xFB, 0x0E, 0x6F, 0x80, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0xB3, 0xFF, 0xFC, 0x23, 0x03, 0x33, 0x33, 0x33,
  0x33, 0x3E, 0xC3, 0x0C, 0x33, 0xDB, 0x6F, 0x3C, 0xDB, 0x7C, 0xC0, 0xFF,
  0xFF, 0xFC, 0xBB, 0xBF, 0xEC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33,
  0xBB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x73, 0xEC, 0xF3, 0x8F, 0x3D, 0x9E,
  0xBB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3, 0x0C, 0x00, 0x6F, 0xFC, 0xF3,
  0x8F, 0x3D, 0xFB, 0x0C, 0x30, 0xC0, 0x9F, 0xCC, 0xCC, 0xCC, 0x3B, 0xF0,
  0xE3, 0x8F, 0x7F, 0x63, 0xFE, 0xC6, 0x31, 0x8D, 0x38, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFF, 0xC7, 0x99, 0xB3, 0x66, 0x87, 0x0E, 0x1C, 0xCC, 0xF3,
  0x34, 0xED, 0xFA, 0x7B, 0x9C, 0xE3, 0x38, 0xCC, 0xCC, 0xD9, 0xE1, 0xC3,
  0x8F, 0x1B, 0x67, 0xC7, 0x99, 0xB3, 0x66, 0x87, 0x0E, 0x1C, 0x30, 0x63,
  0x80, 0xFF, 0xC6, 0x63, 0x31, 0xFF, 0x39, 0x88, 0x42, 0x73, 0x84, 0x21,
  0x0C, 0x70, 0xFF, 0xFC, 0xCC, 0x44, 0x47, 0x74, 0x44, 0xCC, 0x73, 0x3C,
};

const GFXglyph NotoSans_Condensed_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 6, 1, -10 },
  { 7, 7, 10, 8, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 11, 10, 11, 0, -10 },
  { 38, 9, 10, 9, 0, -10 },
  { 50, 2, 4, 3, 1, -10 },
  { 51, 3, 12, 5, 1, -10 },
  { 56, 4, 12, 5, 0, -10 },
  { 62, 6, 6, 7, 0, -11 },
  { 67, 6, 6, 7, 0, -8 },
  { 72, 3, 4, 4, 0, -2 },
  { 74, 4, 2, 4, 0, -5 },
  { 75, 2, 2, 4, 1, -2 },
  { 76, 6, 10, 6, 0, -10 },
  { 84, 6, 10, 7, 0, -10 },
  { 92, 4, 10, 7, 1, -10 },
  { 97, 6, 10, 7, 0, -10 },
  { 105, 6, 10, 7, 0, -10 },
  { 113, 7, 10, 7, 0, -10 },
  { 122, 5, 10, 7, 1, -10 },
  { 129, 6, 10, 7, 0, -10 },
  { 137, 6, 10, 7, 0, -10 },
  { 145, 6, 10, 7, 0, -10 },
  { 153, 6, 10, 7, 0, -10 },
  { 161, 2, 8, 4, 1, -8 },
  { 163, 3, 10, 4, 0, -8 },
  { 167, 7, 6, 7, 0, -8 },
  { 173, 7, 4, 7, 0, -7 },
  { 177, 7, 6, 7, 0, -8 },
  { 183, 5, 10, 6, 0, -10 },
  { 190, 9, 11, 11, 1, -10 },
  { 203, 8, 10, 8, 0, -10 },
  { 213, 6, 10, 8, 1, -10 },
  { 221, 6, 10, 7, 1, -10 },
  { 229, 7, 10, 9, 1, -10 },
  { 238, 5, 10, 7, 1, -10 },
  { 245, 5, 10, 7, 1, -10 },
  { 252, 7, 10, 9, 1, -10 },
  { 261, 7, 10, 9, 1, -10 },
  { 270, 4, 10, 5, 0, -10 },
  { 275, 4, 13, 4, -1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 5, 10, 6, 1, -10 },
  { 298, 9, 10, 12, 1, -10 },
  { 310, 8, 10, 10, 1, -10 },
  { 320, 7, 10, 9, 1, -10 },
  { 329, 6, 10, 7, 1, -10 },
  { 337, 7, 12, 9, 1, -10 },
  { 348, 7, 10, 8, 1, -10 },
  { 357, 6, 10, 6, 0, -10 },
  { 365, 6, 10, 7, 0, -10 },
  { 373, 7, 10, 9, 1, -10 },
  { 382, 8, 10, 8, 0, -10 },
  { 392, 12, 10, 11, 0, -10 },
  { 407, 7, 10, 7, 0, -10 },
  { 416, 7, 10, 7, 0, -10 },
  { 425, 6, 10, 6, 0, -10 },
  { 433, 3, 12, 4, 1, -10 },
  { 438, 6, 10, 6, 0, -10 },
  { 446, 4, 12, 4, 0, -10 },
  { 452, 7, 6, 8, 0, -10 },
  { 458, 6, 1, 6, 0, 1 },
  { 459, 3, 3, 5, 1, -11 },
  { 461, 6, 8, 7, 0, -8 },
  { 467, 6, 11, 8, 1, -11 },
  { 476, 5, 8, 6, 1, -8 },
  { 481, 6, 11, 8, 1, -11 },
  { 490, 5, 8, 7, 1, -8 },
  { 495, 5, 11, 5, 0, -11 },
  { 502, 6, 11, 8, 1, -8 },
  { 511, 6, 11, 8, 1, -11 },
  { 520, 2, 11, 4, 1, -11 },
  { 523, 4, 14, 4, -1, -11 },
  { 530, 6, 11, 7, 1, -11 },
  { 539, 2, 11, 4, 1, -11 },
  { 542, 10, 8, 11, 1, -8 },
  { 552, 6, 8, 8, 1, -8 },
  { 558, 6, 8, 7, 1, -8 },
  { 564, 6, 11, 8, 1, -8 },
  { 573, 6, 11, 8, 1, -8 },
  { 582, 4, 8, 5, 1, -8 },
  { 586, 5, 8, 6, 0, -8 },
  { 591, 5, 9, 5, 0, -9 },
  { 597, 6, 8, 8, 1, -8 },
  { 603, 7, 8, 7, 0, -8 },
  { 610, 10, 8, 10, 0, -8 },
  { 620, 7, 8, 7, 0, -8 },
  { 627, 7, 11, 7, 0, -8 },
  { 637, 5, 8, 6, 0, -8 },
  { 642, 5, 12, 5, 0, -10 },
  { 650, 1, 14, 7, 3, -11 },
  { 652, 4, 12, 5, 1, -10 },
  { 658, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_Bold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_BOLD14PT7B_H_
