#ifndef _NOTOSANS_CONDENSED_BOLD59PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0x83, 0x00, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0x8F, 0xC7, 0xF9, 0xC0,
  0xC3, 0xFC, 0xE0, 0x01, 0xFC, 0x70, 0x00, 0xFE, 0x38, 0x00, 0x7F, 0x9C,
  0x00, 0x3F, 0xEE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xDF, 0xF0, 0x00, 0xE7, 0xFC, 0x00, 0x71, 0xFE, 0x00, 0x38, 0xFF,
  0x80, 0x1C, 0x7F, 0xE0, 0x0E, 0x3F, 0xFC, 0x07, 0x1F, 0xDF, 0xC3, 0xBF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC3, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x8F, 0xC3, 0xFF, 0x0F, 0xE1,
  0xF8, 0xFC, 0x7F, 0xF8, 0x7E, 0x3F, 0x9F, 0xC7, 0xFF, 0xC7, 0xFF, 0xF1,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xE3, 0xF1,
  0xFC, 0x7E, 0x1F, 0xFC, 0x3F, 0x1F, 0x87, 0xE0, 0xFF, 0x87, 0xE1, 0xF8,
  0x7F, 0x01, 0xE0, 0x7E, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x1F, 0xE1, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xF7, 0xFC, 0x3F, 0xCF, 0xF8, 0xFF, 0x9F, 0xE3, 0xFE,
  0x1F, 0xF7, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x0F,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x03, 0xF0,
  0x10, 0xF0, 0xFC, 0x3C, 0x7F, 0xBF, 0x7F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xA7, 0xFF, 0xFF, 0x90,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7C, 0x0F, 0x80, 0x07, 0x03, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x06,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07,
  0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFF, 0x7F,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0x7F, 0xFF, 0xCF, 0xF7, 0xF1, 0xFE, 0x7C, 0x3F, 0xC7, 0x07, 0xF8, 0x40,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0x8F, 0xFC, 0x3F, 0x01, 0xFF, 0x0E, 0x00, 0xFF, 0x86, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xFE, 0x1C, 0x01, 0xFF, 0x08, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xDC, 0x00, 0x7F, 0xEF, 0xE1,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xDF, 0xE0, 0x01, 0xFB, 0xFC, 0x00,
  0x7E, 0x7F, 0x80, 0x0F, 0xCF, 0xF0, 0x03, 0xF1, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x3F,
  0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE,
  0x0F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x38, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x80, 0x03, 0xFE, 0xE0, 0x07, 0xFE, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC, 0x04, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x7F, 0x9F, 0xFC, 0x3F, 0xDF, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3,
  0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC,
  0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x1F, 0xF7, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x1F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0xCF, 0xF0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF,
  0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x8F, 0xFF, 0xBF, 0xC3, 0xFF, 0x9F,
  0xE0, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x82, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x1F, 0xC7, 0xFB, 0xFE, 0xFF,
  0xBF, 0xFF, 0xF9, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x1F, 0xE7, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x03,
  0x00, 0x0E, 0x03, 0xF0, 0xFF, 0x3F, 0xE7, 0xFE, 0xFF, 0xDF, 0xF1, 0xFE,
  0x3F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xC7, 0xFE,
  0x3C, 0x03, 0xFC, 0x20, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xCF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xFF, 0x83, 0xF0, 0xFC, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFC, 0x7E, 0x07, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xF8, 0xFC, 0x1F, 0xBF,
  0x07, 0xF0, 0x7E, 0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x07, 0xEF, 0xC1, 0xF8,
  0x1F, 0x83, 0xF7, 0xE1, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0, 0xFC, 0x07, 0xE0,
  0xFD, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xFF, 0x07, 0xE0,
  0x3F, 0x07, 0xEF, 0x83, 0xF0, 0x3F, 0x83, 0xF7, 0xE1, 0xF8, 0x1F, 0xC1,
  0xF3, 0xF0, 0xFE, 0x0F, 0xE1, 0xF9, 0xF8, 0x3F, 0x0F, 0xF0, 0xFC, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xBF, 0xFE, 0x3F, 0x83, 0xFF,
  0xCF, 0xFE, 0x0F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xFC, 0xFF, 0x80,
  0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF9, 0xFC, 0x1F, 0xF8, 0x03, 0x87, 0xFE, 0x00, 0x10, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x1F, 0xFC, 0x01,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x07, 0xFF, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0xFE,
  0x1F, 0xFC, 0x00, 0xE0, 0xFF, 0xC0, 0x01, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xFC,
  0x01, 0xFE, 0x3F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xCF, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0x7F, 0xFF, 0x7E, 0x00, 0x7E, 0xFF, 0xFF, 0x7F, 0x00, 0x7E, 0xFF, 0xFF,
  0x7F, 0x00, 0xFE, 0xFF, 0xFF, 0x3F, 0x00, 0xFE, 0xFF, 0xFF, 0x3F, 0x80,
  0xFC, 0xFF, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0xFF, 0x3F, 0x81, 0xFC, 0xFF,
  0xFF, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0x1F, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF,
  0x0F, 0xE7, 0xE0, 0xFF, 0xFF, 0x07, 0xF7, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0x01,
  0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xC0, 0x78, 0xFF, 0x00, 0x31, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x0F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFD, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x3F, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0x9F, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE,
  0x00, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF3, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xF0, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x7E, 0x1F,
  0xE0, 0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x1F, 0xCF,
  0xF0, 0x01, 0xFE, 0x7E, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0x03, 0xF3,
  0xFC, 0x00, 0x7F, 0xBF, 0x81, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x3F,
  0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0x04, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0x7F, 0x3F, 0xFE, 0x3F, 0x1F, 0xFC, 0x3F, 0x0F, 0xF8, 0x3F,
  0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x3F, 0xC7, 0xFC,
  0x0F, 0xF7, 0xFF, 0x83, 0xF9, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F,
  0xE0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xC3, 0xF9,
  0xFF, 0xE0, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFC, 0x1C, 0x3F, 0xE0, 0x11, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x04, 0xFF, 0x80, 0x23, 0xFF, 0x07, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x58, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xF8,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x3F, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFF,
  0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFF,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xF0,
  0xFF, 0xF9, 0xFC, 0x1F, 0xFC, 0x7F, 0x03, 0xFE, 0x0F, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0x8F, 0xFC,
  0x03, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF0,
  0x7F, 0xF9, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xFC, 0x1F, 0xFC,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x08, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF2, 0x00, 0x07, 0xF8,
  0xF0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7C, 0x07, 0xF9, 0xFF, 0x83, 0xF9, 0xFF,
  0xF1, 0xFD, 0xFF, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFC, 0x7F, 0xEF, 0xFC, 0x0F, 0xF7, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x3E,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F,
  0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xCF,
  0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0xC7, 0xFE, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0xF8, 0x3F,
  0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0x07, 0xFC, 0x0F, 0xE7, 0xFF, 0x83, 0xF9, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x7F, 0xCF, 0xFE, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0x8F, 0xE7, 0xFF,
  0xC3, 0xFC, 0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC0, 0xC0, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF0,
  0x7F, 0xF9, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xFC, 0x1F, 0xFC,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x08, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFE, 0xFE,
  0xFF, 0xBF, 0xBF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xF8, 0xBF, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xCF, 0xEF, 0xF0,
  0x0C, 0xFF, 0x00, 0x4F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x61, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x03, 0xFF, 0x7F,
  0xC1, 0xFF, 0xDF, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xE7, 0xF0, 0xFF, 0xF1, 0xFC, 0x1F, 0xF8,
  0x7F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xDF, 0x83, 0xFC, 0x3F, 0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0x7E, 0x0F, 0xE0, 0x7F, 0x87, 0xEF, 0xC1, 0xFC, 0x0F, 0xF0, 0xF8, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0x1F, 0x8F, 0xF0, 0x1F, 0xC7, 0xE3, 0xF1, 0xFE,
  0x03, 0xFC, 0xFC, 0x7E, 0x3F, 0x80, 0x7F, 0x9F, 0x87, 0xCF, 0xF0, 0x0F,
  0xF3, 0xE0, 0xF9, 0xFE, 0x00, 0xFE, 0x7C, 0x1F, 0x3F, 0xC0, 0x1F, 0xCF,
  0x83, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x07,
  0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0xFB, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x37, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xC0, 0x0F, 0xFF, 0x20, 0x00, 0x7F,
  0x00,
};

const GFXglyph NotoSans_Condensed_Bold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 43, 16, 3, -42 },
  { 50, 21, 15, 27, 3, -42 },
  { 90, 30, 42, 32, 1, -42 },
  { 248, 25, 48, 29, 2, -45 },
  { 398, 44, 44, 48, 2, -43 },
  { 640, 34, 44, 36, 2, -43 },
  { 827, 8, 15, 14, 3, -42 },
  { 842, 15, 51, 19, 3, -42 },
  { 938, 15, 51, 19, 1, -42 },
  { 1034, 26, 25, 28, 1, -45 },
  { 1116, 25, 28, 29, 2, -35 },
  { 1204, 10, 15, 15, 2, -7 },
  { 1223, 15, 7, 18, 2, -19 },
  { 1237, 9, 10, 16, 3, -9 },
  { 1249, 23, 43, 24, 1, -43 },
  { 1373, 25, 44, 29, 2, -43 },
  { 1511, 19, 42, 29, 3, -42 },
  { 1611, 25, 43, 29, 2, -43 },
  { 1746, 25, 44, 29, 2, -43 },
  { 1884, 27, 42, 29, 1, -42 },
  { 2026, 24, 43, 29, 3, -42 },
  { 2155, 25, 44, 29, 2, -43 },
  { 2293, 26, 42, 29, 1, -42 },
  { 2430, 25, 44, 29, 2, -43 },
  { 2568, 25, 44, 29, 2, -43 },
  { 2706, 10, 34, 16, 3, -33 },
  { 2749, 11, 41, 16, 2, -33 },
  { 2806, 25, 29, 29, 2, -36 },
  { 2897, 25, 18, 29, 2, -30 },
  { 2954, 26, 29, 29, 2, -36 },
  { 3049, 23, 44, 24, 0, -43 },
  { 3176, 41, 48, 46, 2, -43 },
  { 3422, 34, 42, 34, 0, -42 },
  { 3601, 27, 42, 34, 4, -42 },
  { 3743, 27, 44, 31, 3, -43 },
  { 3892, 29, 42, 36, 4, -42 },
  { 4045, 21, 42, 28, 4, -42 },
  { 4156, 21, 42, 28, 4, -42 },
  { 4267, 29, 44, 36, 3, -43 },
  { 4427, 29, 42, 38, 4, -42 },
  { 4580, 16, 42, 20, 2, -42 },
  { 4664, 16, 54, 17, -3, -42 },
  { 4772, 29, 42, 33, 4, -42 },
  { 4925, 21, 42, 27, 4, -42 },
  { 5036, 40, 42, 49, 4, -42 },
  { 5246, 32, 42, 40, 4, -42 },
  { 5414, 33, 44, 39, 3, -43 },
  { 5596, 25, 42, 31, 4, -42 },
  { 5728, 33, 53, 39, 3, -43 },
  { 5947, 29, 42, 33, 4, -42 },
  { 6100, 23, 44, 27, 2, -43 },
  { 6227, 26, 42, 28, 1, -42 },
  { 6364, 29, 43, 37, 4, -42 },
  { 6520, 32, 42, 32, 0, -42 },
  { 6688, 49, 42, 48, -1, -42 },
  { 6946, 31, 42, 31, 0, -42 },
  { 7109, 31, 42, 31, 0, -42 },
  { 7272, 25, 42, 27, 1, -42 },
  { 7404, 13, 51, 19, 4, -42 },
  { 7487, 24, 43, 24, 0, -43 },
  { 7616, 14, 51, 19, 1, -42 },
  { 7706, 30, 26, 32, 1, -42 },
  { 7804, 24, 4, 24, 0, 5 },
  { 7816, 15, 9, 19, 2, -45 },
  { 7833, 24, 34, 30, 2, -33 },
  { 7935, 26, 46, 32, 4, -45 },
  { 8085, 22, 34, 26, 2, -33 },
  { 8179, 26, 46, 32, 2, -45 },
  { 8329, 25, 34, 29, 2, -33 },
  { 8436, 20, 45, 19, 1, -45 },
  { 8549, 26, 47, 32, 2, -33 },
  { 8702, 25, 45, 32, 4, -45 },
  { 8843, 9, 45, 15, 3, -45 },
  { 8894, 14, 59, 15, -2, -45 },
  { 8998, 27, 45, 31, 4, -45 },
  { 9150, 8, 45, 15, 4, -45 },
  { 9195, 41, 33, 48, 4, -33 },
  { 9365, 25, 33, 32, 4, -33 },
  { 9469, 27, 34, 31, 2, -33 },
  { 9584, 26, 47, 32, 4, -33 },
  { 9737, 26, 47, 32, 2, -33 },
  { 9890, 18, 33, 22, 4, -33 },
  { 9965, 20, 34, 24, 2, -33 },
  { 10050, 19, 40, 21, 1, -39 },
  { 10145, 26, 33, 32, 3, -32 },
  { 10253, 28, 32, 28, 0, -32 },
  { 10365, 43, 32, 43, 0, -32 },
  { 10537, 28, 32, 28, 0, -32 },
  { 10649, 28, 46, 28, 0, -32 },
  { 10810, 21, 32, 24, 1, -32 },
  { 10894, 18, 51, 21, 1, -42 },
  { 11009, 6, 59, 28, 11, -45 },
  { 11054, 19, 51, 21, 2, -42 },
  { 11176, 26, 10, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_Bold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_BOLD59PT7B_H_
