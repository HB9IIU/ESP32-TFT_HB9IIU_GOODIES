#ifndef _NOTOSANS_CONDENSED_BOLD6PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xE0, 0x5F, 0x3C, 0xD7, 0x8E, 0xB0, 0xE5, 0xAF,
  0x80, 0x6A, 0x40, 0x95, 0x80, 0x5F, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xA0, 0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x57, 0x90, 0xD8, 0xE0,
  0xFA, 0xF0, 0xE9, 0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xD5, 0x7F, 0xFF, 0x4F, 0xD0, 0xFE, 0xF0, 0x72, 0x30,
  0xF6, 0xF0, 0xFA, 0x70, 0xFA, 0x40, 0x72, 0xB0, 0xBE, 0xD0, 0xD7, 0xF8,
  0xBA, 0xD0, 0x92, 0x70, 0xDD, 0xBB, 0xDD, 0xBB, 0x69, 0x96, 0xF7, 0x40,
  0x69, 0x96, 0x30, 0xF7, 0xD0, 0xF8, 0xE0, 0xE9, 0x20, 0xB6, 0xB0, 0xB5,
  0xA0, 0xAD, 0x54, 0xA0, 0xA9, 0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0,
  0x95, 0xD5, 0xC0, 0x54, 0xC0, 0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xEC, 0x27,
  0xDE, 0xFD, 0x80, 0x6E, 0x80, 0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x92,
  0xEA, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90,
  0xE8, 0xDC, 0xBB, 0xB7, 0x80, 0xB9, 0x00, 0xBF, 0x50, 0xEA, 0x80, 0xB9,
  0x60, 0xDC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 4, 4, 5, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 1, 5, 2, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 4, 4, 5, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 4, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 4, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 5, 4, 5, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 3, 4, 3, 0, -4 },
  { 104, 3, 4, 3, 0, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 2, 4, 2, 0, -4 },
  { 109, 2, 5, 2, 0, -4 },
  { 111, 3, 2, 3, 0, -4 },
  { 112, 2, 1, 2, 0, 0 },
  { 113, 2, 1, 2, 0, -5 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 2, 3, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 2, 5, 2, 0, -5 },
  { 125, 3, 4, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 1, 5, 2, 0, -5 },
  { 130, 1, 6, 2, 0, -5 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 1, 5, 2, 0, -5 },
  { 134, 5, 3, 5, 0, -3 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 4, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 2, 3, 2, 0, -3 },
  { 146, 2, 4, 2, 0, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 4, 3, 4, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 2, 3, 2, 0, -3 },
  { 158, 2, 5, 2, 0, -4 },
  { 160, 1, 6, 3, 1, -5 },
  { 161, 2, 5, 2, 0, -4 },
  { 163, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Bold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_BOLD6PT7B_H_
