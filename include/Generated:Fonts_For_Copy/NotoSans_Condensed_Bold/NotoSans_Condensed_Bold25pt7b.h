#ifndef _NOTOSANS_CONDENSED_BOLD25PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x00, 0x6F, 0xF7, 0xF7, 0xF9,
  0xFC, 0xEE, 0x77, 0x3B, 0x1D, 0x8E, 0x0C, 0xE0, 0xCC, 0x1C, 0xC1, 0xCC,
  0x1C, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0x83, 0x98, 0x39, 0x8F, 0xFF,
  0xFF, 0xF3, 0x38, 0x33, 0x07, 0x30, 0x73, 0x07, 0x70, 0x04, 0x01, 0x03,
  0xF9, 0xFF, 0xFF, 0xFD, 0x1E, 0x43, 0xD0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x05, 0xC1, 0x7C, 0x5F, 0xFF, 0xFF, 0x8F, 0x80, 0x40, 0x10, 0x38, 0x0C,
  0x0F, 0x83, 0x83, 0xB8, 0x60, 0x77, 0x1C, 0x0C, 0x63, 0x01, 0x8C, 0xE0,
  0x31, 0x9C, 0x07, 0x77, 0x38, 0xEE, 0xEF, 0x8F, 0x9B, 0xB8, 0xE7, 0x73,
  0x00, 0xCE, 0x60, 0x39, 0xCE, 0x06, 0x39, 0x81, 0xC7, 0x30, 0x38, 0xEE,
  0x06, 0x0F, 0xC1, 0xC0, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xFC, 0x1C, 0x70,
  0x71, 0xC1, 0xCF, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0xFF, 0xF3,
  0xBD, 0xFE, 0xE3, 0xFB, 0x87, 0xCF, 0x1F, 0x3F, 0xFC, 0x7F, 0xF8, 0xFC,
  0xF0, 0xFF, 0xF7, 0x76, 0x60, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x78,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE0, 0xE1, 0xC1, 0xC3,
  0xC0, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x00, 0x1C, 0x03, 0x00,
  0xC3, 0xB7, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x73, 0x8C, 0xC1, 0x20, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x77, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0, 0x6F, 0xF7,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x1F,
  0x0F, 0xE7, 0xF9, 0xCF, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xFC, 0x77, 0x3D, 0xFE, 0x7F, 0x8F, 0xC0, 0x07, 0x0F,
  0x1F, 0x3F, 0x7F, 0xF7, 0x27, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x3F, 0x1F, 0xEF, 0xFD, 0x8F, 0x41, 0xC0, 0x70,
  0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x3F, 0xEF, 0xFD, 0x0F, 0x01, 0xC0, 0x70, 0x38,
  0xFE, 0x3E, 0x0F, 0xE0, 0x7C, 0x07, 0x01, 0xC0, 0x78, 0x3F, 0xFF, 0xFF,
  0xBF, 0xC0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1D,
  0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xFC, 0xFF, 0x9F, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x3F,
  0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x01, 0xC0,
  0x38, 0x87, 0x7C, 0xFF, 0xDE, 0x7B, 0xC7, 0x70, 0xFE, 0x1F, 0xE3, 0xBC,
  0x73, 0xFE, 0x3F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE,
  0x1D, 0xE3, 0x9E, 0xF3, 0xFC, 0x3F, 0x07, 0xF1, 0xFF, 0x79, 0xEE, 0x1D,
  0xC3, 0xF8, 0x77, 0xFE, 0x7F, 0xC7, 0xE0, 0x3E, 0x0F, 0xF3, 0xFE, 0x79,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0F, 0xF3, 0xDF, 0xF9, 0xFF, 0x1E, 0xE0,
  0x1C, 0x07, 0x80, 0xE3, 0xFC, 0x7F, 0x0F, 0x80, 0x7F, 0xF7, 0x00, 0x00,
  0x00, 0x6F, 0xF7, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x77, 0xFE, 0xE0,
  0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x3C, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0xF8, 0x7E, 0x7E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x3F, 0x3F, 0xE7,
  0xF9, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x70,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x07, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0x87, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x9F, 0xDD, 0x9F, 0xE7, 0xCE,
  0x73, 0xE6, 0x39, 0xF7, 0x1C, 0xFB, 0x8E, 0x7C, 0xC6, 0x3E, 0x67, 0xBF,
  0x3F, 0xF9, 0x8F, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x0E, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x7B, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xF1, 0xC3, 0xC7, 0x0F, 0xFE,
  0x3F, 0xF9, 0xFF, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0xFE, 0xFF, 0x1F,
  0xFB, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFE, 0xFF, 0xDF, 0xE0,
  0x0F, 0xE1, 0xFF, 0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x23, 0xFE,
  0x3F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1, 0xEE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E,
  0xE3, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xFE, 0xFF, 0x7F, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xE0, 0xFF,
  0xCF, 0xFC, 0xF8, 0x27, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE0, 0xF7, 0x07, 0xBC, 0x3D, 0xE1, 0xE7, 0xFF, 0x1F,
  0xF8, 0x7F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xFF, 0xFC, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xCF, 0xFF, 0xEF, 0x00, 0xE0, 0xFE, 0x1E, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E,
  0x78, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xE3, 0x8E,
  0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xB0, 0xFF, 0xDC, 0x7F, 0xEE, 0x77, 0xF7,
  0x3B, 0xF9, 0x9D, 0xFC, 0xEC, 0xFE, 0x7E, 0x7F, 0x3F, 0x3F, 0x8F, 0x9F,
  0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xC0, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD, 0xE7, 0xE7, 0x3F, 0x3D, 0xF9,
  0xEF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xE0, 0xF7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0xFE, 0x3F, 0xEF,
  0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE7, 0xFF, 0xEF, 0xF3, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9E, 0x1E, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0x87, 0x8F, 0xFE,
  0x3F, 0xF0, 0x3F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0xFE,
  0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF,
  0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1E, 0xE1,
  0xEE, 0x0F, 0x3F, 0x1F, 0xF7, 0xFB, 0xC6, 0xF0, 0x3C, 0x0F, 0x01, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xFC, 0x3F, 0xFE, 0xFF, 0xBF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E,
  0x70, 0x79, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x3C, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x78, 0x1D, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0xE0, 0x70, 0x7F, 0x07, 0x83, 0xBC, 0x3C, 0x1D, 0xE1, 0xE1, 0xE7,
  0x0F, 0x8F, 0x38, 0xFC, 0x71, 0xC7, 0xE3, 0x8F, 0x3B, 0x1C, 0x39, 0xD9,
  0xE1, 0xCC, 0xEF, 0x0E, 0xE7, 0x70, 0x77, 0x3B, 0x83, 0xF8, 0xDC, 0x0F,
  0xC6, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x3C,
  0x00, 0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0x79, 0xC3, 0xDE, 0x0E, 0xE0, 0x7F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xDC, 0x1E, 0xF0,
  0xE3, 0x8F, 0x1E, 0x78, 0x77, 0x83, 0xC0, 0xF0, 0x7B, 0x83, 0x9E, 0x3C,
  0xF1, 0xE3, 0x8E, 0x1E, 0xF0, 0x77, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xFF, 0xFC, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCF, 0xFF, 0xFC, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F,
  0x83, 0xB8, 0x39, 0xC7, 0x1C, 0x70, 0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE3, 0x87, 0x1F, 0x1F, 0xE7, 0xFC, 0x8F, 0x01, 0xC0, 0xF7,
  0xFF, 0xFF, 0xF1, 0xF8, 0x7E, 0x3F, 0xDF, 0xFF, 0xDF, 0x70, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F, 0xE7, 0xFE, 0xF3, 0xDC, 0x3B,
  0x87, 0x70, 0xEE, 0x1F, 0xC3, 0xB8, 0x77, 0x9E, 0xFF, 0xDF, 0xF3, 0x3C,
  0x00, 0x1F, 0x1F, 0xDF, 0xEF, 0x1F, 0x07, 0x83, 0x81, 0xC0, 0xF0, 0x78,
  0x3C, 0x2F, 0xF7, 0xF8, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x39, 0xDF, 0xBB, 0xFF, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE1,
  0xFC, 0x7F, 0x8F, 0x7F, 0xEF, 0xFC, 0xFB, 0x80, 0x1F, 0x07, 0xF1, 0xFF,
  0x38, 0xEF, 0x1D, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x3E,
  0xE3, 0xFC, 0x3F, 0x80, 0x0F, 0x8F, 0xCF, 0xC7, 0x83, 0x81, 0xFB, 0xFD,
  0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0x1C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x3F,
  0x07, 0xF0, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xEE, 0x7D, 0xC0, 0x38, 0x0F,
  0x41, 0xEF, 0xF9, 0xFE, 0x1F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3B, 0xCF, 0xFB, 0xFF, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x7F, 0xF2, 0x07, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x1C, 0xF3, 0xC2, 0x00, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xFE, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF8, 0xF7, 0x1C, 0xE7, 0x9D,
  0xE3, 0xB8, 0x7F, 0x0F, 0xE1, 0xFE, 0x39, 0xE7, 0x1C, 0xE3, 0xDC, 0x3B,
  0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xCF, 0x1E,
  0x6F, 0xDF, 0xBF, 0xFF, 0xFE, 0x7C, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8F,
  0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xFE,
  0x3C, 0x7F, 0x1E, 0x3C, 0xCF, 0x37, 0xEF, 0xFF, 0xCF, 0xE3, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x1F, 0x07,
  0xF1, 0xFF, 0x38, 0xFF, 0x1F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F,
  0xC7, 0xBF, 0xE3, 0xFC, 0x3E, 0x00, 0xCF, 0x1F, 0xF3, 0xFF, 0x79, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0x0F, 0xE1, 0xDC, 0x3B, 0x8F, 0x7F, 0xEF, 0xF9,
  0xDE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1C, 0xEF,
  0xDD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x3F,
  0xC7, 0xBF, 0xF7, 0xEE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xC7, 0xBF, 0xFF, 0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x3E, 0x3F, 0xBF, 0xDC, 0x2E, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0x03, 0xE1, 0xFF, 0xEF, 0xF7, 0xF0, 0x18, 0x18, 0x38, 0x3F, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x3D, 0xC7, 0xBF, 0xF7, 0xFE, 0x7D, 0xC0, 0xF0, 0xFF, 0x0F, 0x70,
  0xE7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xF1, 0xE1, 0xFC, 0x78, 0x77, 0x1F, 0x3D,
  0xC7, 0xCE, 0x73, 0xF3, 0x9E, 0xEC, 0xE3, 0xB3, 0x78, 0xEC, 0xDC, 0x3B,
  0x3F, 0x0E, 0xCF, 0xC1, 0xB1, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x80, 0xF0, 0xF7, 0x1E, 0x79, 0xC3, 0xBC, 0x3F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x83, 0xF8, 0x3B, 0xC7, 0x9C, 0x71, 0xEF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xDC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C,
  0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8, 0x7C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C,
  0x1F, 0x1F, 0x3E, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xE0,
  0x78, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 9, 7, 11, 1, -18 },
  { 18, 12, 18, 14, 1, -18 },
  { 45, 10, 20, 12, 1, -19 },
  { 70, 19, 18, 20, 1, -18 },
  { 113, 14, 18, 15, 1, -18 },
  { 145, 4, 7, 6, 1, -18 },
  { 149, 7, 22, 8, 1, -18 },
  { 169, 7, 22, 8, 0, -18 },
  { 189, 10, 11, 12, 1, -19 },
  { 203, 11, 12, 12, 1, -15 },
  { 220, 4, 6, 6, 1, -3 },
  { 223, 6, 3, 8, 1, -8 },
  { 226, 4, 4, 7, 1, -4 },
  { 228, 10, 18, 10, 0, -18 },
  { 251, 10, 18, 12, 1, -18 },
  { 274, 8, 18, 12, 1, -18 },
  { 292, 10, 18, 12, 1, -18 },
  { 315, 10, 18, 12, 1, -18 },
  { 338, 12, 18, 12, 0, -18 },
  { 365, 10, 18, 12, 1, -18 },
  { 388, 11, 18, 12, 1, -18 },
  { 413, 11, 18, 12, 1, -18 },
  { 438, 11, 18, 12, 1, -18 },
  { 463, 11, 18, 12, 1, -18 },
  { 488, 4, 14, 7, 1, -14 },
  { 495, 4, 17, 7, 1, -14 },
  { 504, 11, 12, 12, 1, -15 },
  { 521, 11, 8, 12, 1, -13 },
  { 532, 11, 12, 12, 1, -15 },
  { 549, 10, 18, 10, 0, -18 },
  { 572, 17, 20, 19, 1, -18 },
  { 615, 14, 18, 14, 0, -18 },
  { 647, 11, 18, 14, 2, -18 },
  { 672, 12, 18, 13, 1, -18 },
  { 699, 12, 18, 15, 2, -18 },
  { 726, 9, 18, 12, 2, -18 },
  { 747, 8, 18, 12, 2, -18 },
  { 765, 13, 18, 15, 1, -18 },
  { 795, 12, 18, 16, 2, -18 },
  { 822, 7, 18, 8, 1, -18 },
  { 838, 6, 23, 7, -1, -18 },
  { 856, 12, 18, 14, 2, -18 },
  { 883, 9, 18, 11, 2, -18 },
  { 904, 17, 18, 21, 2, -18 },
  { 943, 13, 18, 17, 2, -18 },
  { 973, 14, 18, 16, 1, -18 },
  { 1005, 10, 18, 13, 2, -18 },
  { 1028, 14, 22, 16, 1, -18 },
  { 1067, 12, 18, 14, 2, -18 },
  { 1094, 10, 18, 12, 1, -18 },
  { 1117, 11, 18, 12, 0, -18 },
  { 1142, 12, 18, 16, 2, -18 },
  { 1169, 14, 18, 14, 0, -18 },
  { 1201, 21, 18, 20, 0, -18 },
  { 1249, 13, 18, 13, 0, -18 },
  { 1279, 13, 18, 13, 0, -18 },
  { 1309, 11, 18, 12, 0, -18 },
  { 1334, 5, 22, 8, 2, -18 },
  { 1348, 10, 18, 10, 0, -18 },
  { 1371, 5, 22, 8, 1, -18 },
  { 1385, 12, 11, 14, 1, -18 },
  { 1402, 10, 2, 10, 0, 2 },
  { 1405, 6, 4, 8, 1, -19 },
  { 1408, 10, 14, 13, 1, -14 },
  { 1426, 11, 19, 13, 2, -19 },
  { 1453, 9, 14, 11, 1, -14 },
  { 1469, 11, 19, 13, 1, -19 },
  { 1496, 11, 14, 12, 1, -14 },
  { 1516, 9, 19, 8, 0, -19 },
  { 1538, 11, 20, 13, 1, -14 },
  { 1566, 10, 19, 14, 2, -19 },
  { 1590, 4, 19, 7, 1, -19 },
  { 1600, 6, 25, 7, -1, -19 },
  { 1619, 11, 19, 13, 2, -19 },
  { 1646, 3, 19, 6, 2, -19 },
  { 1654, 17, 14, 20, 2, -14 },
  { 1684, 10, 14, 14, 2, -14 },
  { 1702, 11, 14, 13, 1, -14 },
  { 1722, 11, 20, 13, 2, -14 },
  { 1750, 11, 20, 13, 1, -14 },
  { 1778, 7, 14, 9, 2, -14 },
  { 1791, 9, 14, 10, 1, -14 },
  { 1807, 8, 17, 9, 0, -17 },
  { 1824, 11, 14, 14, 1, -14 },
  { 1844, 12, 14, 12, 0, -14 },
  { 1865, 18, 14, 18, 0, -14 },
  { 1897, 12, 14, 12, 0, -14 },
  { 1918, 12, 20, 12, 0, -14 },
  { 1948, 8, 14, 10, 1, -14 },
  { 1962, 8, 22, 9, 0, -18 },
  { 1984, 3, 25, 12, 4, -19 },
  { 1994, 8, 22, 9, 1, -18 },
  { 2016, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Bold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_BOLD25PT7B_H_
