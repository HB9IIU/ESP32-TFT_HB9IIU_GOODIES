#ifndef _NOTOSANS_CONDENSED_BOLD34PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00,
  0x01, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC3,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x03, 0xFE, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0x9E, 0x42, 0x79,
  0x01, 0xE4, 0x07, 0xD0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x01, 0x7C, 0x04, 0xF0, 0x13, 0xF0, 0x4F, 0xF1, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x0F, 0xC0, 0x3C, 0x07, 0xF8, 0x1E, 0x01, 0xFE, 0x07, 0x80, 0xF3,
  0xC1, 0xC0, 0x3C, 0xF0, 0xF0, 0x0F, 0x1C, 0x38, 0x03, 0xC7, 0x1E, 0x00,
  0xF1, 0xC7, 0x00, 0x3C, 0x73, 0xC0, 0x0F, 0x3C, 0xF3, 0xC3, 0xCF, 0x39,
  0xFC, 0x7F, 0x9E, 0xFF, 0x1F, 0xE7, 0x3D, 0xE3, 0xF3, 0xCE, 0x38, 0x30,
  0xE7, 0x8E, 0x00, 0x79, 0xE3, 0x80, 0x1C, 0x78, 0xF0, 0x0F, 0x1E, 0x3C,
  0x03, 0xC7, 0x8E, 0x00, 0xE0, 0xE3, 0x80, 0x78, 0x39, 0xE0, 0x1C, 0x0F,
  0xF8, 0x0F, 0x01, 0xFC, 0x03, 0x80, 0x3E, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C,
  0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC3, 0xE3, 0xFE, 0x3E, 0x7F, 0xE3, 0xEF, 0xDF, 0x7C,
  0xF8, 0xFF, 0xCF, 0x87, 0xF8, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE3, 0xF0, 0xFF,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE7, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0x3C,
  0x7C, 0xF8, 0x61, 0x80, 0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7,
  0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7, 0xEF, 0x8F, 0x8F, 0x9E, 0x1F,
  0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7B, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF0, 0x79, 0xE1, 0xF3, 0xC3,
  0xE7, 0xC7, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFE, 0xFB, 0x9F, 0x23, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x00, 0x3F, 0xC1, 0xFF,
  0xC7, 0xFF, 0xC7, 0xDF, 0xCE, 0x0F, 0x88, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x7F, 0xC3, 0xFF, 0xE3,
  0xFF, 0xC7, 0x9F, 0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE8, 0x07, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0x7C, 0x1E, 0xF8, 0x39, 0xF0,
  0xF3, 0xE1, 0xC7, 0xC7, 0x8F, 0x8E, 0x1F, 0x3C, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF2, 0x07, 0xFE, 0x3F, 0xFD, 0xFF, 0xE7, 0x7F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x03, 0xFF, 0xFF,
  0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0x00, 0x30, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFC, 0x87, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF3, 0xC3,
  0xEF, 0xC7, 0xBF, 0xCF, 0xFF, 0xDF, 0x8F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFB, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x0F,
  0x9E, 0x0F, 0x3C, 0x1E, 0x7C, 0x7C, 0xFD, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3E, 0x7E, 0xF8, 0x7D, 0xF0, 0x7F, 0xC0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0,
  0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0x0F, 0xBE,
  0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xDE, 0x0C, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x39,
  0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D,
  0xF7, 0xDE, 0x79, 0xCF, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0x00,
  0x78, 0x00, 0x80, 0x00, 0x06, 0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0xDF,
  0x90, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE3, 0xF8, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x3F, 0x8E, 0x78, 0x7F, 0xCE,
  0x78, 0xFF, 0xCF, 0x71, 0xE3, 0xCF, 0x71, 0xC3, 0xC7, 0x71, 0xC3, 0x87,
  0xF3, 0xC3, 0x87, 0xF3, 0xC3, 0x8F, 0xF3, 0xC3, 0x8F, 0xF1, 0xC7, 0x8E,
  0x71, 0xE7, 0x8E, 0x71, 0xFF, 0xFE, 0x70, 0xFC, 0xFC, 0x78, 0x78, 0xF8,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0xC1, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xC0,
  0x07, 0xBE, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x1F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF9, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF8,
  0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xC0, 0x0F,
  0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xCF, 0xC0, 0x9F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x47, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x0F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x20, 0x03, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFD, 0xF3, 0xF0, 0x11, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF7,
  0xE0, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xFF,
  0xFF, 0xF7, 0xF3, 0xF0, 0xF0, 0x3F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xFC,
  0xF0, 0xF8, 0xF1, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xE0, 0xF7, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFB, 0xE0, 0xF1, 0xF0,
  0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xEF, 0xF7, 0x07, 0xBF, 0xDE, 0x1E, 0xFF, 0x78,
  0x7B, 0xFD, 0xE3, 0xCF, 0xF3, 0xCF, 0x3F, 0xCF, 0x3C, 0xFF, 0x3C, 0xE3,
  0xFC, 0xF7, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC,
  0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x83, 0xFC, 0x1E,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0x87, 0xFD, 0xF1, 0xFF,
  0x3C, 0x7F, 0xCF, 0x9F, 0xF1, 0xE7, 0xFC, 0x7D, 0xFF, 0x0F, 0x7F, 0xC3,
  0xFF, 0xF0, 0xFB, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x07, 0xE7, 0xE1, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x3E, 0x07, 0xE7, 0xE1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F,
  0xCF, 0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0x00, 0x7F,
  0xC3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xF0, 0x4F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0xE0, 0xFB, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xE7, 0x81, 0xF8, 0x3E, 0x78, 0x1F, 0x83, 0xE7, 0xC3, 0xF8, 0x3E, 0x7C,
  0x3F, 0x83, 0xC7, 0xC3, 0xFC, 0x3C, 0x3C, 0x3B, 0xC7, 0xC3, 0xC3, 0xBC,
  0x7C, 0x3E, 0x7B, 0xC7, 0xC3, 0xE7, 0x9C, 0x78, 0x3E, 0x79, 0xE7, 0x81,
  0xE7, 0x9E, 0xF8, 0x1E, 0xF1, 0xEF, 0x81, 0xEF, 0x1E, 0xF8, 0x1F, 0xF0,
  0xEF, 0x00, 0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x3E, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x03,
  0xE7, 0xC0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x81, 0xF3, 0xE0,
  0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFF, 0x10, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x1F, 0xFD,
  0xFF, 0xF7, 0xF7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F,
  0x7F, 0xFD, 0xFE, 0xF3, 0xF1, 0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0xFB, 0xF9, 0xFF,
  0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xBF,
  0xFF, 0x7F, 0xFE, 0xF7, 0xF9, 0xE7, 0xE0, 0x07, 0xE0, 0xFF, 0xCF, 0xFE,
  0x7F, 0xE7, 0xE1, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x2F, 0xFF, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x87, 0x8F, 0x1F, 0xDE, 0x7F, 0xBD, 0xFF, 0xFB, 0xE3,
  0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F,
  0xDE, 0x3F, 0x3C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x01, 0x3F, 0x9E, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x1E, 0x3F, 0xBC, 0xFF, 0x7B,
  0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFF,
  0x3F, 0xFE, 0x7F, 0xBC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xD8,
  0x1F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0x80, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF0,
  0xFB, 0xF9, 0xEF, 0xFB, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0x77, 0xFF,
  0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC,
  0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF7, 0xF9, 0xFC, 0xF7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F,
  0x3F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF1, 0xE1, 0xEF, 0xF3, 0xDF,
  0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xE1, 0xE7,
  0xF3, 0xDF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x1F, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xEF, 0xC7, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x0F, 0x1E, 0x3F, 0xBC, 0xFF, 0x7B, 0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xDE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F, 0xBC, 0x7E, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0xF1, 0xFE, 0x7B, 0xDF, 0x7F, 0xEF, 0xFD, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xFF, 0x7F, 0xEF, 0xFE,
  0xF8, 0x2F, 0x80, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0x3F, 0xCF, 0xF1, 0xFC, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xFD, 0xFE, 0xF3,
  0xF1, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E,
  0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0x9E, 0x1F,
  0x83, 0xCF, 0x0F, 0xE3, 0xE7, 0xC7, 0x71, 0xF3, 0xE3, 0xB8, 0xF0, 0xF1,
  0xDC, 0x78, 0x79, 0xEE, 0x3C, 0x3E, 0xF7, 0xBE, 0x1F, 0x71, 0xDE, 0x07,
  0xB8, 0xEF, 0x03, 0xDC, 0x77, 0x81, 0xEE, 0x3B, 0xC0, 0xF7, 0x1D, 0xE0,
  0x3F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C,
  0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x83, 0xF1, 0xFC,
  0x3E, 0x07, 0xF0, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF8, 0x1F, 0xC0, 0xF8, 0x7F,
  0x1F, 0xC3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0x1C, 0x02, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xD0, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 15, 2, -24 },
  { 30, 17, 24, 19, 1, -24 },
  { 81, 14, 28, 17, 1, -26 },
  { 130, 26, 25, 28, 1, -25 },
  { 212, 20, 25, 21, 1, -25 },
  { 275, 5, 9, 8, 2, -24 },
  { 281, 8, 29, 11, 2, -24 },
  { 310, 8, 29, 11, 1, -24 },
  { 339, 14, 15, 16, 1, -26 },
  { 366, 15, 16, 17, 1, -20 },
  { 396, 6, 8, 9, 1, -4 },
  { 402, 9, 4, 11, 1, -11 },
  { 407, 5, 5, 9, 2, -5 },
  { 411, 14, 25, 14, 0, -25 },
  { 455, 15, 25, 17, 1, -25 },
  { 502, 11, 24, 17, 2, -24 },
  { 535, 15, 25, 17, 1, -25 },
  { 582, 15, 25, 17, 1, -25 },
  { 629, 15, 24, 17, 1, -24 },
  { 674, 13, 24, 17, 2, -24 },
  { 713, 15, 25, 17, 1, -25 },
  { 760, 15, 24, 17, 1, -24 },
  { 805, 15, 25, 17, 1, -25 },
  { 852, 15, 25, 17, 1, -25 },
  { 899, 5, 19, 9, 2, -19 },
  { 911, 6, 23, 9, 1, -19 },
  { 929, 15, 17, 17, 1, -21 },
  { 961, 15, 10, 17, 1, -17 },
  { 980, 15, 17, 17, 1, -21 },
  { 1012, 13, 25, 14, 0, -25 },
  { 1053, 24, 28, 26, 1, -25 },
  { 1137, 20, 24, 20, 0, -24 },
  { 1197, 16, 24, 19, 2, -24 },
  { 1245, 15, 25, 18, 2, -25 },
  { 1292, 17, 24, 21, 2, -24 },
  { 1343, 11, 24, 16, 3, -24 },
  { 1376, 11, 24, 16, 3, -24 },
  { 1409, 17, 25, 21, 2, -25 },
  { 1463, 16, 24, 22, 3, -24 },
  { 1511, 10, 24, 11, 1, -24 },
  { 1541, 9, 31, 10, -2, -24 },
  { 1576, 16, 24, 19, 3, -24 },
  { 1624, 13, 24, 15, 2, -24 },
  { 1663, 22, 24, 28, 3, -24 },
  { 1729, 18, 24, 23, 3, -24 },
  { 1783, 19, 25, 22, 2, -25 },
  { 1843, 15, 24, 18, 2, -24 },
  { 1888, 19, 31, 22, 2, -25 },
  { 1962, 17, 24, 19, 2, -24 },
  { 2013, 14, 25, 16, 1, -25 },
  { 2057, 15, 24, 16, 1, -24 },
  { 2102, 17, 24, 21, 2, -24 },
  { 2153, 19, 24, 19, 0, -24 },
  { 2210, 28, 24, 28, 0, -24 },
  { 2294, 18, 24, 18, 0, -24 },
  { 2348, 18, 24, 18, 0, -24 },
  { 2402, 14, 24, 16, 1, -24 },
  { 2444, 8, 29, 11, 2, -24 },
  { 2473, 14, 25, 14, 0, -25 },
  { 2517, 8, 29, 11, 1, -24 },
  { 2546, 17, 15, 18, 1, -24 },
  { 2578, 14, 2, 14, 0, 3 },
  { 2582, 9, 5, 11, 1, -26 },
  { 2588, 14, 19, 17, 1, -19 },
  { 2622, 15, 26, 18, 2, -26 },
  { 2671, 13, 19, 15, 1, -19 },
  { 2702, 15, 26, 18, 1, -26 },
  { 2751, 15, 19, 17, 1, -19 },
  { 2787, 12, 26, 11, 0, -26 },
  { 2826, 15, 27, 18, 1, -19 },
  { 2877, 15, 26, 19, 2, -26 },
  { 2926, 5, 26, 9, 2, -26 },
  { 2943, 8, 34, 9, -1, -26 },
  { 2977, 16, 26, 18, 2, -26 },
  { 3029, 5, 26, 9, 2, -26 },
  { 3046, 24, 19, 28, 2, -19 },
  { 3103, 15, 19, 19, 2, -19 },
  { 3139, 16, 19, 18, 1, -19 },
  { 3177, 15, 27, 18, 2, -19 },
  { 3228, 15, 27, 18, 1, -19 },
  { 3279, 11, 19, 13, 2, -19 },
  { 3306, 12, 19, 14, 1, -19 },
  { 3335, 10, 23, 12, 1, -23 },
  { 3364, 14, 19, 19, 2, -19 },
  { 3398, 16, 19, 16, 0, -19 },
  { 3436, 25, 19, 25, 0, -19 },
  { 3496, 16, 19, 16, 0, -19 },
  { 3534, 16, 27, 16, 0, -19 },
  { 3588, 12, 19, 14, 1, -19 },
  { 3617, 11, 29, 12, 0, -24 },
  { 3657, 4, 34, 16, 6, -26 },
  { 3674, 11, 29, 12, 1, -24 },
  { 3714, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Bold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_BOLD34PT7B_H_
