#ifndef _NOTOSANS_CONDENSED_BOLD62PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFE, 0x0C, 0x00, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xFD,
  0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xCF, 0xF9, 0xC1, 0xE7, 0xF8, 0xE0, 0x13, 0xFC, 0x70,
  0x01, 0xFE, 0x38, 0x00, 0xFF, 0x1C, 0x00, 0x7F, 0xCE, 0x00, 0x3F, 0xF7,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xEF, 0xFC,
  0x00, 0x73, 0xFE, 0x00, 0x38, 0xFF, 0x00, 0x1C, 0x7F, 0x80, 0x0E, 0x3F,
  0xE0, 0x07, 0x1F, 0xFC, 0x03, 0x8F, 0xFF, 0x81, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x87,
  0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0,
  0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x83,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0xF0, 0x7E, 0x1F, 0xC7, 0xE1, 0xFF, 0xE1, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0xF8, 0x7E, 0x3F, 0x87, 0xF0,
  0xFF, 0xC3, 0xF8, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xE1, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xEF, 0xF8, 0x7F, 0xC7, 0xFC, 0xFF, 0xC7,
  0xF8, 0xFF, 0x87, 0xFE, 0xFF, 0x8F, 0xF8, 0x3F, 0xEF, 0xF8, 0xFF, 0x81,
  0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0x87,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x08, 0x07, 0xE0, 0x11, 0xE0, 0xFC, 0x1E, 0x3F, 0x9F, 0x9F, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x03, 0xFC, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0x03,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x08, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F,
  0x83, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xDF,
  0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0x7F, 0x8F, 0xF3, 0xF0, 0xFF, 0x1E, 0x1F,
  0xF0, 0xC1, 0xFF, 0x08, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xC0, 0x07,
  0xF8, 0x20, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xFE, 0x1E, 0x01, 0xFF, 0x86, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xF8, 0xFF, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x38, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xD8, 0x00, 0x7F, 0xEF, 0x80, 0x7F, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x18, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xE3, 0xFF, 0x03,
  0xFC, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0x0F, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x9F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB,
  0xF8, 0x7F, 0xFE, 0xFF, 0x07, 0xFF, 0x9F, 0xE0, 0x7F, 0xE3, 0xFC, 0x00,
  0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x87, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0x7F, 0xCF, 0xE0, 0xC0, 0x1F, 0x87, 0xF8, 0xFF, 0x9F, 0xF7, 0xFE,
  0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xCF, 0xFE, 0x3E, 0x03,
  0xFF, 0x10, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xFF,
  0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xFC, 0x3F, 0x0F, 0xC0, 0x7F, 0xFF, 0x87,
  0xE3, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xCF,
  0xC1, 0xFE, 0x0F, 0xC1, 0xFB, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x7F, 0x07,
  0xE0, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xE0, 0xFC, 0x07, 0xF0,
  0x7F, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xDF, 0x83, 0xF0, 0x1F, 0xC1, 0xFB,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xEF, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xBF, 0x07, 0xF0,
  0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xF0, 0xFC, 0xFC, 0x0F, 0xE7, 0xFF,
  0x3F, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8,
  0x3F, 0x03, 0xFF, 0xCF, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xC1, 0xFF, 0x80, 0x04,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x61, 0xFF,
  0xE0, 0x3E, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0xF8, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x78,
  0x3F, 0xF8, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xC0, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0x0F, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0x3F, 0xE0,
  0x03, 0xFD, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0,
  0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xEF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xDF, 0xC0,
  0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xFB,
  0xFF, 0xFB, 0xFC, 0x01, 0xFD, 0xFF, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0xFE,
  0x7F, 0x00, 0x7F, 0x7F, 0xFF, 0xBF, 0x80, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0,
  0x3F, 0x9F, 0xFF, 0xE7, 0xF0, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x1F, 0xC7,
  0xFF, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x07, 0xF1, 0xFF, 0xFE,
  0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0x8F, 0xF1,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0x83, 0xFF, 0xFC,
  0x1F, 0xDF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFB, 0xFE, 0x01,
  0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0x1F, 0xF0,
  0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0x81, 0xFE, 0x3F, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xF8,
  0x07, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC,
  0x1F, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x3F, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xE0, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE0, 0x7E, 0x7F, 0xC0, 0x0C,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xDF,
  0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0x9F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xF9, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x3F, 0x9F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0x8F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x0F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x7F,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xE0,
  0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x7F, 0x7F, 0xC0, 0x01, 0xFE, 0xFE, 0x03, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xE0, 0x3F, 0x7F, 0x80, 0x00, 0xFE, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xFE, 0x06, 0x00, 0xFF, 0x81, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0x87, 0xF0, 0xFF, 0xC1, 0xFC, 0x03, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC7, 0xFF, 0x07, 0xF9, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0xFD,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x1F,
  0xF7, 0xFF, 0x07, 0xFE, 0xFF, 0xFB, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xE1, 0xFC, 0x7F, 0xF8,
  0x3F, 0x87, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xF0, 0x18, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x09, 0xFF, 0x80, 0x73, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x10, 0x1F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0x9F, 0xF0, 0xFF, 0xFD, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0x3F,
  0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF8, 0xFF, 0x01, 0xFF, 0x07, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF8, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x10, 0xFF, 0x80, 0x06, 0x1F, 0xFC,
  0x07, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x02, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x03, 0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xDF, 0xF0, 0x7F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x20, 0x00, 0x3F, 0xE3, 0x80, 0x07, 0xFE, 0x3F, 0x83, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x0F, 0xF3,
  0xFF, 0xC3, 0xFD, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0x1F,
  0xE7, 0xFB, 0xFF, 0xFF, 0xDF, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x01, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xA3, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83,
  0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0,
  0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xF1, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8,
  0x07, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03,
  0xFE, 0x7F, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xF8, 0xFF, 0xF0, 0x7F, 0xFC,
  0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFE, 0x0F,
  0xE3, 0xFF, 0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07,
  0xFE, 0x1F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x03,
  0xF8, 0x7F, 0xF0, 0x7F, 0x1F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xDF, 0xFC, 0xFF, 0xE0, 0xFF, 0xDF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x01, 0xFF,
  0x7F, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFB, 0xFF, 0xF8, 0xFF, 0x7F, 0xFE, 0x1F, 0xE7, 0xFF, 0x83,
  0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x03, 0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xDF, 0xF0, 0x7F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0x9F, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFD, 0xFC, 0xFF, 0xBF, 0xBF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0x0B, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xE0, 0x7C, 0xFF,
  0x00, 0x63, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x81, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0x1F,
  0xC1, 0xFF, 0x07, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xDF, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xE7, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0xFD, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xEF, 0xC0, 0xFF, 0x07,
  0xF8, 0x3F, 0x7F, 0x0F, 0xF8, 0x3F, 0xC1, 0xF9, 0xF8, 0x7F, 0x81, 0xFF,
  0x1F, 0xCF, 0xC3, 0xFC, 0x07, 0xF8, 0xFC, 0x7E, 0x1F, 0xE0, 0x3F, 0xC7,
  0xE3, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0x0F, 0xCF, 0xF0, 0x0F, 0xF1, 0xF8,
  0x7E, 0x7F, 0x80, 0x3F, 0x8F, 0xC3, 0xF3, 0xFC, 0x01, 0xFE, 0xFC, 0x1F,
  0x9F, 0xE0, 0x0F, 0xF7, 0xE0, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x07, 0xEF,
  0xF0, 0x03, 0xFD, 0xF8, 0x1F, 0x7F, 0x80, 0x0F, 0xEF, 0xC0, 0xFB, 0xFC,
  0x00, 0x7F, 0x7C, 0x07, 0xDF, 0xC0, 0x03, 0xFB, 0xE0, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0x90, 0x00, 0x3F,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Bold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 45, 16, 3, -44 },
  { 58, 22, 16, 28, 3, -44 },
  { 102, 32, 44, 34, 1, -44 },
  { 278, 25, 51, 31, 3, -47 },
  { 438, 46, 46, 50, 2, -45 },
  { 703, 36, 46, 38, 2, -45 },
  { 910, 9, 16, 15, 3, -44 },
  { 928, 16, 54, 20, 3, -44 },
  { 1036, 16, 54, 20, 1, -44 },
  { 1144, 27, 26, 29, 1, -47 },
  { 1232, 27, 30, 31, 2, -37 },
  { 1334, 11, 15, 16, 2, -7 },
  { 1355, 15, 7, 19, 2, -20 },
  { 1369, 10, 10, 16, 3, -9 },
  { 1382, 24, 45, 25, 1, -45 },
  { 1517, 26, 46, 31, 2, -45 },
  { 1667, 20, 44, 31, 3, -44 },
  { 1777, 26, 45, 31, 2, -45 },
  { 1924, 26, 46, 31, 2, -45 },
  { 2074, 29, 44, 31, 1, -44 },
  { 2234, 25, 45, 31, 3, -44 },
  { 2375, 27, 46, 31, 2, -45 },
  { 2531, 28, 44, 31, 1, -44 },
  { 2685, 27, 46, 31, 2, -45 },
  { 2841, 27, 46, 31, 2, -45 },
  { 2997, 10, 35, 16, 3, -34 },
  { 3041, 11, 42, 17, 2, -34 },
  { 3099, 27, 31, 31, 2, -38 },
  { 3204, 27, 18, 31, 2, -31 },
  { 3265, 27, 31, 31, 2, -38 },
  { 3370, 24, 46, 25, 0, -45 },
  { 3508, 43, 50, 48, 3, -45 },
  { 3777, 36, 44, 36, 0, -44 },
  { 3975, 28, 44, 35, 4, -44 },
  { 4129, 28, 46, 33, 3, -45 },
  { 4290, 31, 44, 38, 4, -44 },
  { 4461, 21, 44, 29, 5, -44 },
  { 4577, 21, 44, 29, 5, -44 },
  { 4693, 31, 46, 38, 3, -45 },
  { 4872, 30, 44, 40, 5, -44 },
  { 5037, 17, 44, 21, 2, -44 },
  { 5131, 17, 57, 18, -4, -44 },
  { 5253, 30, 44, 35, 5, -44 },
  { 5418, 23, 44, 28, 4, -44 },
  { 5545, 41, 44, 51, 5, -44 },
  { 5771, 33, 44, 42, 5, -44 },
  { 5953, 35, 46, 40, 3, -45 },
  { 6155, 27, 44, 33, 4, -44 },
  { 6304, 35, 56, 40, 3, -45 },
  { 6549, 30, 44, 34, 4, -44 },
  { 6714, 24, 46, 29, 2, -45 },
  { 6852, 27, 44, 29, 1, -44 },
  { 7001, 30, 45, 39, 4, -44 },
  { 7170, 34, 44, 34, 0, -44 },
  { 7357, 52, 44, 50, -1, -44 },
  { 7643, 33, 44, 33, 0, -44 },
  { 7825, 32, 44, 32, 0, -44 },
  { 8001, 27, 44, 29, 1, -44 },
  { 8150, 14, 54, 20, 4, -44 },
  { 8245, 25, 45, 25, 0, -45 },
  { 8386, 14, 54, 20, 2, -44 },
  { 8481, 31, 27, 34, 1, -44 },
  { 8586, 25, 5, 25, 0, 5 },
  { 8602, 16, 9, 20, 2, -47 },
  { 8620, 26, 36, 31, 2, -35 },
  { 8737, 27, 48, 33, 4, -47 },
  { 8899, 23, 36, 27, 2, -35 },
  { 9003, 28, 48, 33, 2, -47 },
  { 9171, 27, 35, 31, 2, -34 },
  { 9290, 21, 47, 20, 1, -47 },
  { 9414, 28, 50, 33, 2, -35 },
  { 9589, 26, 47, 34, 4, -47 },
  { 9742, 10, 47, 16, 3, -47 },
  { 9801, 15, 62, 16, -2, -47 },
  { 9918, 29, 47, 32, 4, -47 },
  { 10089, 8, 47, 16, 4, -47 },
  { 10136, 43, 35, 51, 4, -35 },
  { 10325, 26, 35, 34, 4, -35 },
  { 10439, 28, 36, 33, 2, -35 },
  { 10565, 27, 50, 33, 4, -35 },
  { 10734, 28, 50, 33, 2, -35 },
  { 10909, 19, 35, 23, 4, -35 },
  { 10993, 22, 36, 26, 2, -35 },
  { 11092, 20, 42, 22, 1, -41 },
  { 11197, 26, 35, 34, 4, -34 },
  { 11311, 30, 34, 30, 0, -34 },
  { 11439, 45, 34, 45, 0, -34 },
  { 11631, 29, 34, 29, 0, -34 },
  { 11755, 30, 49, 30, 0, -34 },
  { 11939, 22, 34, 25, 1, -34 },
  { 12033, 19, 54, 22, 1, -44 },
  { 12162, 7, 61, 29, 11, -47 },
  { 12216, 20, 54, 22, 2, -44 },
  { 12351, 27, 10, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_Bold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_BOLD62PT7B_H_
