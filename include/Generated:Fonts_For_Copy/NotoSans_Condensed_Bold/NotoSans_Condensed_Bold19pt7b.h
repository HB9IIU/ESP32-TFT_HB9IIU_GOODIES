#ifndef _NOTOSANS_CONDENSED_BOLD19PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xEF, 0xDF, 0xBE, 0x6C, 0xC0,
  0x0D, 0x82, 0x61, 0x98, 0x64, 0x7F, 0xDF, 0xF1, 0xB0, 0x4C, 0xFF, 0xFF,
  0xF3, 0x60, 0xD8, 0x36, 0x0D, 0x80, 0x10, 0x3F, 0xFE, 0xF2, 0xD0, 0xF0,
  0x78, 0x3E, 0x1E, 0x17, 0x97, 0xFE, 0xFC, 0x10, 0x10, 0x70, 0x63, 0xE3,
  0x0D, 0x8C, 0x36, 0x60, 0xD9, 0x83, 0x6C, 0x0D, 0xB7, 0xBE, 0xFE, 0x76,
  0xCC, 0x1B, 0x30, 0xCC, 0xC3, 0x33, 0x18, 0x78, 0x61, 0xE0, 0x18, 0x0F,
  0xC1, 0xB8, 0x33, 0x06, 0xE0, 0xF8, 0x0E, 0x03, 0xCE, 0xFD, 0xD9, 0xF3,
  0x1E, 0x73, 0xCF, 0xF8, 0xFB, 0xC0, 0xFF, 0xEC, 0x19, 0x9C, 0xCE, 0x73,
  0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86, 0x38, 0xE3, 0x0C, 0x63, 0x8C, 0x63,
  0x18, 0xC6, 0x33, 0x98, 0xCE, 0xE0, 0x1C, 0x04, 0x1F, 0xDF, 0xF1, 0xC1,
  0xB1, 0xDC, 0x28, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x60, 0xFF, 0xFF, 0x80, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x38, 0x7C, 0xFE, 0xE6, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xEE, 0x7E, 0x3C, 0x0C, 0x73, 0xDF,
  0xFD, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x38, 0xFE, 0xFE, 0x86,
  0x06, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x38, 0xFE,
  0xEE, 0x06, 0x06, 0x0E, 0x7C, 0x7C, 0x0E, 0x07, 0x07, 0x8E, 0xFE, 0xFC,
  0x07, 0x03, 0x83, 0xC1, 0xE1, 0xF1, 0xB8, 0xDC, 0xCE, 0x67, 0x7F, 0xFF,
  0xE0, 0xE0, 0x70, 0x38, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xF8, 0xFE, 0xFE,
  0x07, 0x07, 0x07, 0x8E, 0xFE, 0xFC, 0x1E, 0x3E, 0x7A, 0xE0, 0xC0, 0xDC,
  0xFE, 0xEF, 0xC7, 0xC7, 0xC7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0,
  0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0,
  0x38, 0x7E, 0xEE, 0xC6, 0xE6, 0xEE, 0x7C, 0x7C, 0xEE, 0xC7, 0xC7, 0xC7,
  0xFE, 0x7C, 0x38, 0x7C, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xFF, 0x7F, 0x06,
  0x06, 0x0E, 0xFC, 0xF8, 0x5F, 0xA0, 0x00, 0xFF, 0x80, 0x5F, 0xA0, 0x00,
  0x1F, 0xEC, 0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x1F, 0x07, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F,
  0x3E, 0xF8, 0xC0, 0x80, 0x39, 0xFD, 0xB8, 0x30, 0x61, 0xC7, 0x1C, 0x30,
  0x60, 0x01, 0x83, 0x87, 0x00, 0x07, 0x00, 0xFF, 0x0C, 0x1C, 0xC0, 0x66,
  0x79, 0xE6, 0xCF, 0x66, 0x7B, 0x33, 0xD9, 0x9E, 0xCC, 0xF3, 0xFD, 0x8C,
  0xC6, 0x00, 0x38, 0x20, 0x7F, 0x00, 0x40, 0x0E, 0x03, 0xC0, 0x7C, 0x0D,
  0x81, 0xB0, 0x77, 0x0E, 0xE1, 0x8C, 0x3F, 0x8F, 0xF9, 0xFF, 0x38, 0xEE,
  0x0F, 0xC1, 0xC0, 0xF8, 0x7F, 0xBF, 0xDC, 0x7E, 0x3F, 0x3B, 0xF9, 0xFE,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xF7, 0xF0, 0x0E, 0x1F, 0xDF, 0xCE, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x27, 0xF1, 0xF8, 0xF8,
  0x3F, 0xCF, 0xFB, 0x8E, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E,
  0x3B, 0x9E, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF,
  0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F,
  0xFF, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x0F, 0x1F, 0xDF, 0xEE, 0x0E,
  0x07, 0x03, 0x9F, 0xCF, 0xE7, 0xF0, 0xF8, 0x6E, 0x37, 0xF8, 0xFC, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xEF, 0xFC, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xF7,
  0xF7, 0x00, 0xE1, 0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x3B, 0x8F, 0xC3, 0xF0,
  0xFE, 0x39, 0x8E, 0x73, 0x8C, 0xE3, 0xB8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xF0, 0x3F, 0x83,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x6F, 0xB3, 0x7D, 0x9B, 0xED, 0x9F,
  0x7C, 0xF9, 0xE7, 0xCE, 0x3E, 0x71, 0xF3, 0x8C, 0xF0, 0xFE, 0x1F, 0xE3,
  0xFC, 0x7F, 0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xC0, 0x1E, 0x07, 0xF1, 0xFE, 0x70, 0xEE, 0x1D, 0xC1,
  0xB8, 0x37, 0x07, 0xE0, 0xDC, 0x1B, 0x87, 0x39, 0xE7, 0xF8, 0x7E, 0x00,
  0xF8, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x1E, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x1D, 0xC1, 0xB8, 0x3F,
  0x07, 0xE0, 0xDC, 0x1B, 0x87, 0x39, 0xE7, 0xF8, 0x7E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0xF8, 0x3F, 0x8F, 0xF3, 0x8C, 0xE3, 0xB8, 0xCE, 0x73, 0xF8,
  0xFE, 0x3B, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xF0, 0x38, 0xFF, 0xFE, 0x0C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x7F, 0xDF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x8F, 0xC0, 0xE0, 0xF8, 0x36, 0x1D, 0x87,
  0x71, 0x9C, 0x63, 0x38, 0xCC, 0x3B, 0x0E, 0xC1, 0xF0, 0x78, 0x1E, 0x03,
  0x80, 0xC1, 0x87, 0xE3, 0x86, 0xE3, 0x86, 0xE3, 0xCE, 0x63, 0xCE, 0x67,
  0xCE, 0x76, 0xCC, 0x76, 0xCC, 0x36, 0xFC, 0x36, 0x7C, 0x3E, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x1C, 0x38, 0xE1, 0xDC, 0xE7, 0x38, 0xCC, 0x3F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xC3, 0xB1, 0xCE, 0x73, 0xB8, 0x70, 0xE1,
  0xF8, 0x67, 0x39, 0xCE, 0x33, 0x0F, 0xC1, 0xE0, 0x78, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78,
  0x3B, 0x0C, 0xC3, 0x39, 0x86, 0xE1, 0xC0, 0xFF, 0xE6, 0x30, 0x19, 0xFD,
  0xB8, 0x30, 0x6F, 0xF9, 0xE3, 0xC7, 0xFD, 0xD8, 0xE0, 0x70, 0x38, 0x1C,
  0x8F, 0xE7, 0xFB, 0x8D, 0xC6, 0xE3, 0xF1, 0xB8, 0xDC, 0xEF, 0xF6, 0xF0,
  0x18, 0xFF, 0xF7, 0x0C, 0x18, 0x30, 0x70, 0xE2, 0xFD, 0xF0, 0x07, 0x07,
  0x07, 0x33, 0x7B, 0xFF, 0xE7, 0xC7, 0xC3, 0xC3, 0xE7, 0xE7, 0xFF, 0x7B,
  0x18, 0x7E, 0xEE, 0xE7, 0xC7, 0xFF, 0xFF, 0xC0, 0xE1, 0x7E, 0x3E, 0x08,
  0x7C, 0xF1, 0x87, 0x1F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x00, 0x30, 0x7B, 0xFF, 0xE7, 0xC7, 0xC3, 0xC3, 0xE7, 0xE7, 0xFF, 0x7B,
  0x07, 0x07, 0xFF, 0xFE, 0x30, 0xE0, 0xE0, 0xE0, 0xEC, 0xFF, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x39, 0xC0, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF,
  0x90, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x77, 0x33, 0xB9, 0xF8, 0xFC, 0x7E,
  0x3B, 0x9C, 0xEE, 0x77, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x26, 0xF7, 0xFF, 0xFF, 0xCE, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3,
  0xE7, 0x1F, 0x38, 0xF9, 0xC6, 0x04, 0xDF, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0x18, 0x7E, 0xFF, 0xE7, 0xC3, 0xC3, 0xC3, 0xE3,
  0xE7, 0x7E, 0x3C, 0x0C, 0x6F, 0x3F, 0xDC, 0x6E, 0x37, 0x1F, 0x8D, 0xC6,
  0xE7, 0x7F, 0xBF, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x7B, 0xFF,
  0xE7, 0xC7, 0xC3, 0xC3, 0xE7, 0xE7, 0xFF, 0x7B, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x7F, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x33, 0xFE,
  0xF0, 0xE3, 0xE3, 0xC7, 0x8F, 0xFF, 0x80, 0x30, 0xC3, 0x3F, 0xFD, 0xC7,
  0x1C, 0x71, 0xC7, 0x0F, 0x3C, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7,
  0xE7, 0xFF, 0x7B, 0xE3, 0xB1, 0xD8, 0xCE, 0xE3, 0x71, 0xB0, 0xD8, 0x7C,
  0x1C, 0x0E, 0x00, 0xE7, 0x9D, 0x9E, 0x66, 0x79, 0x9D, 0xEE, 0x74, 0xB8,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x80, 0xE3, 0xBB, 0x8D,
  0x87, 0xC1, 0xC1, 0xF0, 0xF8, 0xEE, 0x77, 0x71, 0xC0, 0xE3, 0xB1, 0xDC,
  0xCE, 0xE3, 0x71, 0xB0, 0xF8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x07, 0x83,
  0x81, 0x80, 0x7E, 0xFC, 0x30, 0xE1, 0x87, 0x1C, 0x38, 0xFF, 0xFC, 0x04,
  0x73, 0x8E, 0x38, 0xE3, 0x8E, 0xF3, 0xC3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x83, 0x8E, 0x1C, 0x71,
  0xC7, 0x1C, 0x3C, 0xF7, 0x1C, 0x71, 0xC7, 0x38, 0xE0, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 8, 15, 9, 1, -14 },
  { 45, 14, 14, 15, 1, -14 },
  { 70, 11, 14, 12, 1, -14 },
  { 90, 3, 5, 5, 1, -14 },
  { 92, 5, 17, 6, 1, -14 },
  { 103, 5, 17, 6, 0, -14 },
  { 114, 9, 8, 9, 0, -14 },
  { 123, 8, 9, 9, 1, -11 },
  { 132, 3, 4, 5, 1, -2 },
  { 134, 4, 2, 6, 1, -6 },
  { 135, 3, 3, 5, 1, -3 },
  { 137, 8, 14, 8, 0, -14 },
  { 151, 8, 14, 9, 1, -14 },
  { 165, 6, 14, 9, 1, -14 },
  { 176, 8, 14, 9, 1, -14 },
  { 190, 8, 14, 9, 1, -14 },
  { 204, 9, 14, 9, 0, -14 },
  { 220, 8, 14, 9, 1, -14 },
  { 234, 8, 14, 9, 1, -14 },
  { 248, 9, 14, 9, 0, -14 },
  { 264, 8, 14, 9, 1, -14 },
  { 278, 8, 14, 9, 1, -14 },
  { 292, 3, 11, 5, 1, -11 },
  { 297, 3, 13, 5, 1, -11 },
  { 302, 8, 10, 9, 1, -12 },
  { 312, 8, 6, 9, 1, -10 },
  { 318, 8, 10, 9, 1, -12 },
  { 328, 7, 14, 8, 0, -14 },
  { 341, 13, 16, 15, 1, -14 },
  { 367, 11, 14, 11, 0, -14 },
  { 387, 9, 14, 11, 1, -14 },
  { 403, 9, 14, 10, 1, -14 },
  { 419, 10, 14, 12, 1, -14 },
  { 437, 7, 14, 9, 1, -14 },
  { 450, 7, 14, 9, 1, -14 },
  { 463, 9, 14, 12, 1, -14 },
  { 479, 10, 14, 12, 1, -14 },
  { 497, 5, 14, 6, 1, -14 },
  { 506, 5, 18, 6, -1, -14 },
  { 518, 10, 14, 11, 1, -14 },
  { 536, 7, 14, 9, 1, -14 },
  { 549, 13, 14, 16, 1, -14 },
  { 572, 11, 14, 13, 1, -14 },
  { 592, 11, 14, 12, 1, -14 },
  { 612, 8, 14, 10, 1, -14 },
  { 626, 11, 17, 12, 1, -14 },
  { 650, 10, 14, 11, 1, -14 },
  { 668, 7, 14, 9, 1, -14 },
  { 681, 9, 14, 9, 0, -14 },
  { 697, 10, 14, 12, 1, -14 },
  { 715, 10, 14, 10, 0, -14 },
  { 733, 16, 14, 15, 0, -14 },
  { 761, 10, 14, 10, 0, -14 },
  { 779, 10, 14, 10, 0, -14 },
  { 797, 8, 14, 9, 0, -14 },
  { 811, 5, 17, 6, 1, -14 },
  { 822, 8, 14, 8, 0, -14 },
  { 836, 5, 17, 6, 0, -14 },
  { 847, 10, 9, 10, 0, -14 },
  { 859, 8, 1, 8, 0, 2 },
  { 860, 4, 3, 6, 1, -15 },
  { 862, 7, 11, 10, 1, -11 },
  { 872, 9, 14, 10, 1, -14 },
  { 888, 7, 11, 8, 1, -11 },
  { 898, 8, 14, 10, 1, -14 },
  { 912, 8, 11, 9, 1, -11 },
  { 923, 7, 15, 6, 0, -15 },
  { 937, 8, 16, 10, 1, -11 },
  { 953, 8, 14, 10, 1, -14 },
  { 967, 3, 14, 5, 1, -14 },
  { 973, 5, 19, 5, -1, -14 },
  { 985, 9, 14, 10, 1, -14 },
  { 1001, 3, 14, 5, 1, -14 },
  { 1007, 13, 11, 15, 1, -11 },
  { 1025, 8, 11, 10, 1, -11 },
  { 1036, 8, 11, 10, 1, -11 },
  { 1047, 9, 16, 10, 1, -11 },
  { 1065, 8, 16, 10, 1, -11 },
  { 1081, 6, 11, 7, 1, -11 },
  { 1090, 6, 11, 8, 1, -11 },
  { 1099, 6, 13, 7, 0, -13 },
  { 1109, 8, 10, 10, 1, -10 },
  { 1119, 9, 10, 9, 0, -10 },
  { 1131, 14, 10, 14, 0, -10 },
  { 1149, 9, 10, 9, 0, -10 },
  { 1161, 9, 15, 9, 0, -10 },
  { 1178, 7, 10, 8, 0, -10 },
  { 1187, 6, 17, 7, 0, -14 },
  { 1200, 3, 19, 9, 3, -15 },
  { 1208, 6, 17, 7, 1, -14 },
  { 1221, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Bold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_BOLD19PT7B_H_
