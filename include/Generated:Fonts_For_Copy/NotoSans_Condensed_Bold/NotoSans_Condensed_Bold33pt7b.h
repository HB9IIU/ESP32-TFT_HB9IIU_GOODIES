#ifndef _NOTOSANS_CONDENSED_BOLD33PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0x00,
  0x00, 0xEF, 0xFF, 0xFE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x07, 0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x07, 0xFE,
  0x3F, 0xFD, 0xFF, 0xE7, 0xF3, 0xBE, 0xC0, 0xFB, 0x01, 0xEC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0x7C, 0x0C,
  0xF8, 0x33, 0xFC, 0xDF, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x1E, 0x00, 0xE0, 0x1F, 0x80, 0xF0, 0x1F,
  0xE0, 0x70, 0x0E, 0x70, 0x78, 0x0F, 0x3C, 0x38, 0x07, 0x9E, 0x1C, 0x03,
  0xCF, 0x1E, 0x01, 0xE7, 0x8E, 0x00, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x00,
  0x3C, 0xF7, 0x9F, 0x8E, 0x73, 0x9F, 0xC7, 0xFB, 0xCF, 0xF1, 0xF9, 0xEF,
  0x38, 0x78, 0xE7, 0x9E, 0x00, 0xF3, 0x8F, 0x00, 0x71, 0xC7, 0x80, 0x78,
  0xE3, 0xC0, 0x38, 0x71, 0xE0, 0x3C, 0x3C, 0xF0, 0x1C, 0x1E, 0x70, 0x0E,
  0x07, 0xF8, 0x0F, 0x03, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x13, 0xFC, 0x3C, 0xFF, 0xCF, 0xBF, 0x7D, 0xF7, 0xCF, 0xBC, 0xF8, 0xFF,
  0x9F, 0x0F, 0xF3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0xE0, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x21, 0xC2, 0xF7, 0x3B, 0xFF, 0xEF, 0xFF,
  0xC7, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xDF, 0x1F, 0x3E, 0x38, 0xE0, 0x21,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x7F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x03, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF,
  0xBF, 0xCF, 0x63, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0xC0,
  0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x78, 0xF8, 0x81, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70,
  0xF8, 0x81, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC1, 0xFE, 0x07,
  0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0x78, 0x07, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x78, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF3,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F,
  0xF0, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xCF, 0xCF, 0x7F, 0xBF, 0xFE, 0xFE, 0xFF,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0x1F,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE1, 0xF7,
  0x87, 0xDE, 0x1E, 0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC7, 0xCF, 0xBE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0xFD, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x87, 0xFE, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0x8F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x67, 0xF1, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF,
  0x80, 0x79, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x0F, 0x83, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE7, 0x0F, 0xA0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xF0,
  0x07, 0x83, 0x80, 0x07, 0x8F, 0x07, 0x07, 0x1C, 0x3F, 0xCF, 0x78, 0xFF,
  0x8E, 0xE3, 0xC7, 0x1D, 0xC7, 0x0E, 0x3B, 0x9E, 0x1C, 0x7F, 0x3C, 0x78,
  0xFE, 0x78, 0xF1, 0xFC, 0xF1, 0xE3, 0xF9, 0xE3, 0xC7, 0xF3, 0xC7, 0x9C,
  0xE3, 0xFF, 0xF9, 0xC7, 0xF7, 0xE3, 0xC7, 0xC7, 0x87, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x08, 0x0F, 0xC1, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3C, 0x1E, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF,
  0x0F, 0xFF, 0x9F, 0xFF, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x03,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xE1, 0xCF, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x27, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x9F, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F,
  0x9F, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBC, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFE, 0x3F, 0x06, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC7, 0xFF, 0xEF, 0xF7, 0xF3, 0xE0, 0xF0, 0x3F, 0xF0, 0x3E, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xDC, 0x1D, 0xFF, 0x78,
  0xF7, 0xFD, 0xE3, 0xDF, 0xF7, 0x8F, 0x7F, 0xCE, 0x39, 0xFF, 0x3D, 0xE7,
  0xFC, 0xF7, 0x9F, 0xF3, 0xDC, 0x7F, 0xC7, 0xF1, 0xFF, 0x1F, 0xC7, 0xFC,
  0x7F, 0x1F, 0xF1, 0xF8, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3C,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xDE, 0x0F, 0xFF, 0x87, 0xFB, 0xC3, 0xFD, 0xF1,
  0xFE, 0x78, 0xFF, 0x3E, 0x7F, 0x8F, 0x3F, 0xC7, 0xDF, 0xE1, 0xEF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0xC0, 0xF9, 0xF8,
  0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0xF9, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF8,
  0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF9, 0xFC, 0xF8, 0x7C,
  0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F,
  0x07, 0xC0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0xC7, 0x7C, 0x0B, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xF0, 0x03, 0xFE,
  0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xE0, 0x7C,
  0x0F, 0xFC, 0x0F, 0x81, 0xE7, 0x83, 0xF0, 0x3C, 0xF0, 0x7F, 0x0F, 0x9E,
  0x0F, 0xE1, 0xF3, 0xE1, 0xFC, 0x3E, 0x7C, 0x3B, 0x87, 0x87, 0x8F, 0x70,
  0xF0, 0xF1, 0xEF, 0x3E, 0x1E, 0x3D, 0xE7, 0xC3, 0xE7, 0xBC, 0xF8, 0x3D,
  0xE7, 0x9E, 0x07, 0xBC, 0x73, 0xC0, 0xF7, 0x8F, 0x78, 0x1E, 0xF1, 0xFF,
  0x03, 0xDC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC3, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xBE, 0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE3,
  0xC1, 0xE1, 0xF1, 0xF0, 0x78, 0xF8, 0x3E, 0x78, 0x1F, 0x7C, 0x07, 0xBC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x1E,
  0x70, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3C, 0x1E, 0x0F,
  0x07, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8E, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xDF, 0xFF, 0x7F, 0xBC, 0xFC, 0xF0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xF8,
  0xF7, 0xF9, 0xFF, 0xF3, 0xFB, 0xF7, 0xC3, 0xEF, 0x83, 0xDF, 0x07, 0xBE,
  0x0F, 0x7C, 0x1F, 0xF8, 0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xEF, 0x87,
  0xDF, 0xDF, 0xBF, 0xFE, 0x7B, 0xFC, 0xF3, 0xF0, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFC, 0xFC, 0xE7, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x09, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x8F, 0xDF, 0x3F, 0xFE, 0x7F, 0xFD, 0xFB, 0xFB, 0xE1,
  0xF7, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFB, 0xC1, 0xF7, 0xC3, 0xEF, 0xDF, 0xCF, 0xFF, 0x9F, 0xEF, 0x1F,
  0x9E, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x17, 0xE1, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1F,
  0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xF7, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF,
  0x87, 0xDF, 0xBF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xCC, 0x0F, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0xFC, 0xF7, 0xFB, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0xF7, 0xFF, 0xF6, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F,
  0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0xBE, 0x1F, 0xF8, 0x3D,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F,
  0x9F, 0x0F, 0x3E, 0x1F, 0x7C, 0x1F, 0xF8, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF3, 0xF1, 0xF9, 0xEF, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF0, 0xF8, 0x7C, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0,
  0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83,
  0xEF, 0x87, 0x9F, 0x9F, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0xF3, 0xF1,
  0xEF, 0xF3, 0xFF, 0xE7, 0xE7, 0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x7C,
  0x1E, 0xF8, 0x3F, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xEF, 0x87, 0xDF, 0x0F,
  0xBF, 0xFF, 0x7F, 0xFC, 0xF7, 0xF9, 0xE7, 0xE3, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xF7, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF,
  0x87, 0xDF, 0xBF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0xF3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFE, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x3F,
  0xC7, 0xFE, 0x7F, 0xEF, 0x8C, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0xF7, 0xEF, 0xFE, 0xFF,
  0xC7, 0xF8, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x7D, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF,
  0xFF, 0x7F, 0xBC, 0xFC, 0xF0, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1F, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x7C, 0x7F, 0x1E, 0x3C, 0xFF, 0x3E, 0x3C,
  0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0x3C, 0x3E, 0xE7, 0x7C, 0x1E,
  0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3E, 0xF8, 0x78, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xEF, 0x87,
  0xDF, 0x0F, 0x9F, 0x3E, 0x3E, 0x7C, 0x3F, 0xF0, 0x7C, 0xF8, 0x1F, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x20, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFC, 0x3F, 0x07, 0xF0,
  0xFF, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xA0,
  0x1F, 0x83, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0xC1, 0xF8, 0x7F, 0x1F, 0xE3, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC3, 0xF8,
  0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 16, 24, 18, 1, -24 },
  { 77, 14, 27, 16, 1, -25 },
  { 125, 25, 24, 27, 1, -24 },
  { 200, 19, 24, 20, 1, -24 },
  { 257, 4, 9, 8, 2, -24 },
  { 262, 9, 29, 11, 1, -24 },
  { 295, 8, 29, 11, 1, -24 },
  { 324, 14, 14, 16, 1, -25 },
  { 349, 14, 16, 16, 1, -20 },
  { 377, 6, 8, 9, 1, -4 },
  { 383, 8, 4, 10, 1, -11 },
  { 387, 5, 5, 9, 2, -5 },
  { 391, 13, 24, 13, 0, -24 },
  { 430, 14, 24, 16, 1, -24 },
  { 472, 10, 24, 16, 2, -24 },
  { 502, 14, 24, 16, 1, -24 },
  { 544, 14, 24, 16, 1, -24 },
  { 586, 16, 24, 16, 0, -24 },
  { 634, 13, 24, 16, 2, -24 },
  { 673, 14, 24, 16, 1, -24 },
  { 715, 14, 24, 16, 1, -24 },
  { 757, 14, 24, 16, 1, -24 },
  { 799, 14, 24, 16, 1, -24 },
  { 841, 5, 18, 9, 2, -18 },
  { 853, 6, 22, 9, 1, -18 },
  { 870, 14, 16, 16, 1, -20 },
  { 898, 14, 10, 16, 1, -17 },
  { 916, 14, 16, 16, 1, -20 },
  { 944, 13, 24, 13, 0, -24 },
  { 983, 23, 27, 26, 1, -24 },
  { 1061, 19, 24, 19, 0, -24 },
  { 1118, 15, 24, 19, 2, -24 },
  { 1163, 15, 24, 18, 2, -24 },
  { 1208, 17, 24, 20, 2, -24 },
  { 1259, 11, 24, 16, 3, -24 },
  { 1292, 11, 24, 15, 3, -24 },
  { 1325, 16, 24, 20, 2, -24 },
  { 1373, 16, 24, 21, 3, -24 },
  { 1421, 9, 24, 11, 1, -24 },
  { 1448, 9, 31, 10, -2, -24 },
  { 1483, 16, 24, 18, 3, -24 },
  { 1531, 12, 24, 15, 2, -24 },
  { 1567, 22, 24, 27, 3, -24 },
  { 1633, 17, 24, 23, 3, -24 },
  { 1684, 18, 24, 22, 2, -24 },
  { 1738, 14, 24, 17, 2, -24 },
  { 1780, 18, 30, 22, 2, -24 },
  { 1848, 16, 24, 18, 2, -24 },
  { 1896, 13, 24, 15, 1, -24 },
  { 1935, 14, 24, 16, 1, -24 },
  { 1977, 16, 24, 21, 2, -24 },
  { 2025, 18, 24, 18, 0, -24 },
  { 2079, 27, 24, 27, 0, -24 },
  { 2160, 17, 24, 18, 0, -24 },
  { 2211, 17, 24, 17, 0, -24 },
  { 2262, 14, 24, 15, 1, -24 },
  { 2304, 8, 29, 10, 2, -24 },
  { 2333, 13, 24, 13, 0, -24 },
  { 2372, 7, 29, 10, 1, -24 },
  { 2398, 16, 15, 18, 1, -24 },
  { 2428, 14, 2, 14, 0, 3 },
  { 2432, 8, 5, 11, 1, -25 },
  { 2437, 14, 18, 17, 1, -18 },
  { 2469, 15, 25, 18, 2, -25 },
  { 2516, 13, 18, 14, 1, -18 },
  { 2546, 15, 25, 18, 1, -25 },
  { 2593, 14, 18, 16, 1, -18 },
  { 2625, 12, 25, 11, 0, -25 },
  { 2663, 15, 26, 18, 1, -18 },
  { 2712, 14, 25, 18, 2, -25 },
  { 2756, 5, 25, 9, 2, -25 },
  { 2772, 8, 33, 9, -1, -25 },
  { 2805, 15, 25, 17, 2, -25 },
  { 2852, 5, 25, 9, 2, -25 },
  { 2868, 23, 18, 27, 2, -18 },
  { 2920, 14, 18, 18, 2, -18 },
  { 2952, 15, 18, 17, 1, -18 },
  { 2986, 15, 26, 18, 2, -18 },
  { 3035, 15, 26, 18, 1, -18 },
  { 3084, 10, 18, 12, 2, -18 },
  { 3107, 12, 18, 14, 1, -18 },
  { 3134, 11, 22, 12, 0, -22 },
  { 3165, 14, 18, 18, 2, -18 },
  { 3197, 16, 18, 16, 0, -18 },
  { 3233, 24, 18, 24, 0, -18 },
  { 3287, 15, 18, 15, 0, -18 },
  { 3321, 16, 26, 16, 0, -18 },
  { 3373, 11, 18, 13, 1, -18 },
  { 3398, 11, 29, 12, 0, -24 },
  { 3438, 4, 33, 16, 6, -25 },
  { 3455, 11, 29, 12, 1, -24 },
  { 3495, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Bold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_BOLD33PT7B_H_
