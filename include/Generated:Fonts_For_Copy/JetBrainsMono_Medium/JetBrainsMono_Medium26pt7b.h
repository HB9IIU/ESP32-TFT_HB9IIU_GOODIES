#ifndef _JETBRAINSMONO_MEDIUM26PT7B_H_
#define _JETBRAINSMONO_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x60, 0x00, 0xFF, 0xF0, 0xE7,
  0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x0E, 0x38, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60, 0x61,
  0x81, 0x86, 0x0E, 0x38, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x0C, 0x30, 0x71,
  0xC1, 0x86, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1F,
  0x87, 0xFC, 0x77, 0xEE, 0x66, 0xE6, 0x7E, 0x60, 0xE6, 0x07, 0xE0, 0x7F,
  0x03, 0xFC, 0x07, 0xE0, 0x6E, 0x06, 0x70, 0x67, 0xE6, 0x7E, 0x67, 0xF7,
  0xE7, 0xFE, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x06,
  0xFC, 0x1B, 0x9C, 0x37, 0x18, 0xCE, 0x33, 0x1C, 0x6E, 0x19, 0xD8, 0x3F,
  0x60, 0x19, 0xC0, 0x03, 0x00, 0x0C, 0x40, 0x33, 0xE0, 0x6E, 0xE1, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x30, 0xC6, 0xC1, 0xFF, 0x81, 0xF0, 0x1F, 0x80,
  0xFF, 0x03, 0x8E, 0x1C, 0x38, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x3C, 0x01, 0xF8, 0x1E, 0x73, 0xB9, 0xCE, 0xE3, 0xF3, 0x87, 0xCE, 0x0E,
  0x38, 0x38, 0x73, 0xF1, 0xFE, 0xE3, 0xF1, 0xC0, 0xFF, 0xFF, 0xFB, 0x03,
  0x0F, 0x1F, 0x3C, 0x78, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x3C, 0x1F, 0x0F, 0x03,
  0x80, 0xE0, 0xF8, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x1E, 0x3C, 0xF8, 0xF0,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0xE3, 0x3B, 0xED, 0xF7,
  0xFF, 0x80, 0xC0, 0x07, 0x80, 0x37, 0x01, 0xCE, 0x0E, 0x38, 0x38, 0x70,
  0x41, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0xE3,
  0x9E, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x1F,
  0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEE,
  0x7E, 0xE7, 0xEE, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x71,
  0xE7, 0xFC, 0x1F, 0x80, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x08,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFC,
  0xF1, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xE0,
  0x6E, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0xEE, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xE7,
  0xFE, 0x7F, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF,
  0x0E, 0xE0, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x0E, 0x71, 0xE7,
  0xFC, 0x3F, 0x80, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x78, 0x7F, 0xCF, 0xFE, 0xE0, 0xFE, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xF1, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x00, 0x1F, 0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0x6E, 0x0E, 0x70, 0xE7,
  0x9C, 0x3F, 0x81, 0xF8, 0x3B, 0xC7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E,
  0x07, 0xF1, 0xE7, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xFC, 0xF1, 0xEE, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFF, 0xBE, 0x7F, 0xE1, 0xDC,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x4F,
  0xFF, 0x60, 0x00, 0x00, 0x0E, 0xFF, 0xF0, 0x10, 0xF7, 0xCF, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x38, 0xE7, 0x9C, 0x71, 0x8E, 0x00, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x07, 0xC0, 0xF0, 0x0C, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x0C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x0C, 0x00, 0xFE, 0x3F, 0xCF, 0xF8, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x0F, 0x8F, 0xC3, 0xE0, 0xE0, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x1F, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xC7, 0x83, 0x98, 0x06,
  0xE0, 0x1F, 0x80, 0x7C, 0x1D, 0xF0, 0xFB, 0xC7, 0x1F, 0x1C, 0x7C, 0x61,
  0xF1, 0x87, 0xC6, 0x1F, 0x18, 0x7C, 0x71, 0xF1, 0xCF, 0xC3, 0xEF, 0x82,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xDC, 0x06, 0xE0, 0x73, 0x03, 0x9C,
  0x18, 0xE0, 0xC7, 0x0E, 0x18, 0x70, 0xE3, 0xFF, 0x1F, 0xF9, 0xC0, 0xCE,
  0x07, 0x70, 0x3F, 0x01, 0xF8, 0x06, 0xFF, 0x8F, 0xFC, 0xE3, 0xEE, 0x0E,
  0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xFF, 0xCF, 0xFC, 0xE1, 0xEE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE3, 0xEF, 0xFE, 0xFF, 0x80, 0x1F,
  0x87, 0xFC, 0x79, 0xEE, 0x0E, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x0E, 0x71,
  0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0x6E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6E, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x79, 0xEE,
  0x0E, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x70, 0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x77, 0x03, 0xB8,
  0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x70, 0xFF, 0x07, 0xF8,
  0x39, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xE7,
  0x03, 0xB8, 0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1B,
  0xD9, 0xBD, 0x9B, 0xDB, 0x3D, 0xB7, 0xCF, 0x7C, 0xF7, 0xCE, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0xF0,
  0x7F, 0x07, 0xF8, 0x7D, 0x87, 0xF8, 0x7F, 0xC7, 0xEC, 0x7E, 0xC7, 0xEE,
  0x7E, 0x67, 0xE6, 0x7E, 0x77, 0xE3, 0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xF0, 0x1F, 0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0x6E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x6E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0x8F, 0xFE,
  0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xFF, 0xFE,
  0xFF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE1, 0xEF, 0xFE, 0xFF, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1,
  0xCE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0x70, 0x1F, 0x87, 0xFC, 0x71, 0xEE,
  0x06, 0xE0, 0x7E, 0x00, 0xE0, 0x07, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0xE0, 0x7E, 0x07, 0xF1, 0xE7, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80,
  0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x18, 0x38, 0xE1, 0xC7,
  0x0E, 0x38, 0x60, 0xC7, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x06, 0xE0, 0x37,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0xC7, 0x0F, 0x1C, 0x7C, 0x71,
  0xF1, 0xE7, 0xC7, 0x9F, 0x96, 0x6E, 0x59, 0xB9, 0x66, 0xE4, 0x99, 0xB2,
  0x66, 0xC9, 0x9B, 0x26, 0x6C, 0xF9, 0xB3, 0xE6, 0x8F, 0x1A, 0x3C, 0x78,
  0xF1, 0xE3, 0xC3, 0x87, 0x00, 0xF0, 0x39, 0xC0, 0xE3, 0x87, 0x0E, 0x1C,
  0x1C, 0xE0, 0x77, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xF0, 0x1D, 0xC0, 0x73, 0x83, 0x8E, 0x0E, 0x1C, 0x70, 0x71, 0xC0,
  0xEE, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x1C, 0x38, 0x70,
  0xE3, 0x81, 0xCE, 0x07, 0x30, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xFE, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x39, 0x83, 0x1C, 0x30,
  0xC7, 0x0C, 0x60, 0xEE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC0, 0x04,
  0x07, 0xF9, 0xFF, 0xB8, 0x7E, 0x06, 0x00, 0xC0, 0x1B, 0xFF, 0xFF, 0xFC,
  0x0F, 0x01, 0xE0, 0x7E, 0x1F, 0xFE, 0xDF, 0x98, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE2, 0x0E, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x6E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF1, 0xEF, 0xFE, 0xEF,
  0xC0, 0x04, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x7E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x86, 0x7E, 0xDF, 0xDF, 0x87, 0xE0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xF1, 0xEF,
  0xEC, 0xF9, 0x80, 0x04, 0x03, 0xF8, 0x7F, 0xEF, 0x0E, 0xE0, 0x6E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x07, 0x70, 0xE7, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x0C, 0x00, 0x60, 0x03, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x07, 0xED,
  0xFD, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83,
  0xBC, 0xF7, 0xF6, 0x7C, 0xC0, 0x18, 0x03, 0x00, 0xE7, 0xFC, 0xFF, 0x1F,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x21, 0xDF, 0xBF, 0xFF, 0x87,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xEF, 0xFB, 0xFC, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x1C, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0xB8,
  0x1E, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x08, 0x4F, 0xDE, 0xFF,
  0xFC, 0x67, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0x02, 0x1D, 0xFB, 0xFF, 0xF8,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x18, 0x06, 0x03, 0xF8, 0x7F, 0xEF, 0x0E, 0xE0, 0x6E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x71, 0xE7,
  0xFC, 0x1F, 0x80, 0x02, 0x0E, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x6E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF1, 0xEF, 0xFE,
  0xEF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x08, 0x07, 0xED,
  0xFD, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x77, 0x1E, 0xFE, 0xCF, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x1B, 0xF3, 0x7F, 0x70, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x06, 0x03,
  0xFC, 0x7F, 0xEE, 0x0E, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0x00, 0x7E, 0x07, 0xF0, 0xE7, 0xFE, 0x3F, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB8, 0xF7, 0xFC, 0x3F, 0x00, 0xE0,
  0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE3, 0x87, 0x1C, 0x30, 0xE3, 0x83, 0x9C,
  0x1C, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0xC7, 0x1F,
  0x1C, 0x7C, 0x71, 0xB9, 0xE6, 0xE5, 0x99, 0x96, 0x66, 0x59, 0x9B, 0x2E,
  0x6C, 0xB1, 0xB3, 0xC7, 0x8F, 0x0E, 0x3C, 0x38, 0xF0, 0xE1, 0xC0, 0xF0,
  0x79, 0xC3, 0x8E, 0x38, 0x39, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0x70, 0xE7, 0x07, 0x78, 0x1C, 0xF0, 0x3B,
  0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83, 0x9C, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x7F, 0x8F, 0xC1, 0xFC, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xF8, 0x1F, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x1F,
  0x03, 0xF0, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0xF0, 0x7E, 0x1F, 0xC3, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xC0, 0x38, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3F, 0xC3,
  0xCE, 0x3C, 0x7F, 0xC3, 0xE0, 0x0C,
};

const GFXglyph JetBrainsMono_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 8, 16, 4, -19 },
  { 19, 14, 19, 16, 1, -19 },
  { 53, 12, 27, 16, 2, -23 },
  { 94, 15, 19, 16, 0, -19 },
  { 130, 14, 19, 16, 1, -19 },
  { 164, 3, 8, 16, 6, -19 },
  { 167, 8, 25, 16, 5, -22 },
  { 192, 8, 25, 16, 3, -22 },
  { 217, 14, 14, 16, 1, -16 },
  { 242, 12, 13, 16, 2, -15 },
  { 262, 6, 8, 16, 4, -4 },
  { 268, 8, 3, 16, 4, -10 },
  { 271, 4, 4, 16, 6, -4 },
  { 273, 12, 25, 16, 2, -22 },
  { 311, 12, 19, 16, 2, -19 },
  { 340, 12, 19, 16, 2, -19 },
  { 369, 12, 19, 16, 2, -19 },
  { 398, 12, 19, 16, 2, -19 },
  { 427, 11, 19, 16, 2, -19 },
  { 454, 12, 19, 16, 2, -19 },
  { 483, 12, 19, 16, 2, -19 },
  { 512, 12, 19, 16, 2, -19 },
  { 541, 12, 19, 16, 2, -19 },
  { 570, 12, 19, 16, 2, -19 },
  { 599, 4, 15, 16, 6, -15 },
  { 607, 6, 19, 16, 4, -15 },
  { 622, 12, 14, 16, 2, -16 },
  { 643, 11, 9, 16, 2, -13 },
  { 656, 12, 14, 16, 2, -16 },
  { 677, 10, 19, 16, 3, -19 },
  { 701, 14, 24, 16, 1, -19 },
  { 743, 13, 19, 16, 1, -19 },
  { 774, 12, 19, 16, 2, -19 },
  { 803, 12, 19, 16, 2, -19 },
  { 832, 12, 19, 16, 2, -19 },
  { 861, 12, 19, 16, 2, -19 },
  { 890, 12, 19, 16, 2, -19 },
  { 919, 12, 19, 16, 2, -19 },
  { 948, 11, 19, 16, 2, -19 },
  { 975, 10, 19, 16, 3, -19 },
  { 999, 12, 19, 16, 1, -19 },
  { 1028, 13, 19, 16, 2, -19 },
  { 1059, 11, 19, 16, 3, -19 },
  { 1086, 12, 19, 16, 2, -19 },
  { 1115, 12, 19, 16, 2, -19 },
  { 1144, 12, 19, 16, 2, -19 },
  { 1173, 12, 19, 16, 2, -19 },
  { 1202, 12, 24, 16, 2, -19 },
  { 1238, 12, 19, 16, 2, -19 },
  { 1267, 12, 19, 16, 2, -19 },
  { 1296, 13, 19, 16, 1, -19 },
  { 1327, 12, 19, 16, 2, -19 },
  { 1356, 13, 19, 16, 1, -19 },
  { 1387, 14, 19, 16, 1, -19 },
  { 1421, 14, 19, 16, 1, -19 },
  { 1455, 14, 19, 16, 1, -19 },
  { 1489, 11, 19, 16, 2, -19 },
  { 1516, 7, 25, 16, 5, -22 },
  { 1538, 12, 25, 16, 2, -22 },
  { 1576, 7, 25, 16, 4, -22 },
  { 1598, 12, 10, 16, 2, -19 },
  { 1613, 12, 2, 16, 2, 1 },
  { 1616, 6, 3, 16, 4, -20 },
  { 1619, 11, 15, 16, 2, -15 },
  { 1640, 12, 19, 16, 2, -19 },
  { 1669, 12, 15, 16, 2, -15 },
  { 1692, 11, 19, 16, 2, -19 },
  { 1719, 12, 15, 16, 2, -15 },
  { 1742, 13, 19, 16, 1, -19 },
  { 1773, 11, 20, 16, 2, -15 },
  { 1801, 11, 19, 16, 2, -19 },
  { 1828, 12, 20, 16, 2, -20 },
  { 1858, 10, 25, 16, 2, -20 },
  { 1890, 13, 19, 16, 2, -19 },
  { 1921, 13, 19, 16, 1, -19 },
  { 1952, 12, 15, 16, 2, -15 },
  { 1975, 11, 15, 16, 2, -15 },
  { 1996, 12, 15, 16, 2, -15 },
  { 2019, 12, 20, 16, 2, -15 },
  { 2049, 11, 20, 16, 2, -15 },
  { 2077, 11, 15, 16, 3, -15 },
  { 2098, 12, 15, 16, 2, -15 },
  { 2121, 13, 18, 16, 1, -18 },
  { 2151, 11, 14, 16, 2, -14 },
  { 2171, 13, 14, 16, 1, -14 },
  { 2194, 14, 14, 16, 1, -14 },
  { 2219, 13, 14, 16, 1, -14 },
  { 2242, 13, 19, 16, 1, -14 },
  { 2273, 11, 14, 16, 2, -14 },
  { 2293, 11, 25, 16, 2, -22 },
  { 2328, 3, 25, 16, 6, -22 },
  { 2338, 11, 25, 16, 2, -22 },
  { 2373, 12, 6, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Medium26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_MEDIUM26PT7B_H_
