#ifndef _JETBRAINSMONO_MEDIUM9PT7B_H_
#define _JETBRAINSMONO_MEDIUM9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xDC, 0xE7,
  0xDE, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x22, 0x90, 0xCA, 0xC9, 0xA0,
  0xE0, 0x5A, 0xAA, 0x40, 0x98, 0x92, 0x4A, 0x80, 0x27, 0xCC, 0xA0, 0x44,
  0xF4, 0x70, 0xE0, 0xC0, 0x32, 0x24, 0x44, 0x88, 0x69, 0x9D, 0x99, 0xE0,
  0x6A, 0xA2, 0x22, 0xF0, 0x6B, 0x12, 0x6C, 0xF0, 0xE2, 0x46, 0x19, 0xE0,
  0x26, 0x49, 0x9F, 0x10, 0xE8, 0x8E, 0x19, 0xE0, 0x24, 0xCE, 0x99, 0xE0,
  0xF9, 0x22, 0x24, 0x40, 0x6B, 0x96, 0x99, 0xE0, 0x69, 0x9B, 0x62, 0x40,
  0x88, 0x60, 0x05, 0x80, 0x3C, 0xC3, 0xF0, 0x0F, 0xC3, 0x3C, 0xC4, 0xB4,
  0x10, 0x32, 0x67, 0x5A, 0xD6, 0x48, 0x30, 0x21, 0x94, 0xA7, 0x26, 0x20,
  0xCB, 0x9E, 0x99, 0xE0, 0x69, 0x88, 0x89, 0xE0, 0xCB, 0x99, 0x99, 0xE0,
  0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x69, 0x88, 0xB9, 0xE0,
  0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x38, 0x42, 0x10, 0xC9,
  0xC0, 0x9A, 0xAC, 0xAA, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x9B, 0xBD, 0x99,
  0x90, 0x99, 0xDD, 0xDB, 0xB0, 0x6B, 0x99, 0x99, 0xE0, 0xE9, 0x9F, 0x88,
  0x80, 0x6B, 0x99, 0x99, 0xE2, 0x10, 0xCB, 0x9F, 0xAA, 0x90, 0x69, 0x8E,
  0x19, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xE0, 0x8A,
  0x52, 0xA5, 0x18, 0x80, 0xAD, 0x6B, 0x75, 0xAD, 0x60, 0xCA, 0x8C, 0x43,
  0x2B, 0x20, 0x8A, 0x54, 0x62, 0x10, 0x80, 0xF3, 0x24, 0x48, 0xF0, 0xEA,
  0xAB, 0x88, 0x44, 0x42, 0x21, 0xE4, 0x92, 0x4F, 0x46, 0xA9, 0xF0, 0xC0,
  0xE1, 0xF9, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0xE9, 0x89, 0xE0, 0x11, 0xDB,
  0x99, 0xF0, 0xE9, 0xF9, 0xE0, 0x34, 0x4F, 0x44, 0x40, 0xF9, 0x9B, 0x51,
  0xE0, 0x88, 0xE9, 0x99, 0x90, 0x60, 0xC4, 0x44, 0xF0, 0x23, 0x92, 0x49,
  0xC0, 0x88, 0x9A, 0xEA, 0x90, 0xE1, 0x08, 0x42, 0x10, 0xE0, 0xFD, 0xDD,
  0xD0, 0xE9, 0x99, 0x90, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xDB,
  0x99, 0xF1, 0x10, 0xE9, 0x88, 0x80, 0xF8, 0xE1, 0xE0, 0x27, 0xC8, 0x42,
  0x1C, 0x99, 0x99, 0xE0, 0xCA, 0x54, 0x63, 0x00, 0xAD, 0x56, 0xB5, 0x00,
  0xCB, 0x88, 0xAC, 0x80, 0xCA, 0x94, 0x62, 0x10, 0x80, 0xF2, 0x48, 0xF0,
  0x72, 0x2C, 0x62, 0x43, 0xFF, 0xC4, 0x47, 0x44, 0x4C, 0xDB,
};

const GFXglyph JetBrainsMono_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 3, 5, 2, -7 },
  { 25, 2, 9, 5, 2, -8 },
  { 28, 3, 9, 5, 1, -8 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 4, 4, 5, 1, -5 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 1, 2, 5, 2, -2 },
  { 40, 4, 8, 5, 1, -7 },
  { 44, 4, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 1, -7 },
  { 56, 4, 7, 5, 1, -7 },
  { 60, 4, 7, 5, 1, -7 },
  { 64, 4, 7, 5, 1, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 4, 7, 5, 1, -7 },
  { 84, 1, 5, 5, 2, -5 },
  { 85, 3, 6, 5, 1, -5 },
  { 88, 4, 4, 5, 1, -5 },
  { 90, 4, 4, 5, 1, -5 },
  { 92, 4, 4, 5, 1, -5 },
  { 94, 3, 7, 5, 1, -7 },
  { 97, 5, 9, 5, 0, -7 },
  { 103, 5, 7, 5, 0, -7 },
  { 108, 4, 7, 5, 1, -7 },
  { 112, 4, 7, 5, 1, -7 },
  { 116, 4, 7, 5, 1, -7 },
  { 120, 4, 7, 5, 1, -7 },
  { 124, 4, 7, 5, 1, -7 },
  { 128, 4, 7, 5, 1, -7 },
  { 132, 4, 7, 5, 1, -7 },
  { 136, 4, 7, 5, 1, -7 },
  { 140, 5, 7, 5, 0, -7 },
  { 145, 4, 7, 5, 1, -7 },
  { 149, 4, 7, 5, 1, -7 },
  { 153, 4, 7, 5, 1, -7 },
  { 157, 4, 7, 5, 1, -7 },
  { 161, 4, 7, 5, 1, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 4, 9, 5, 1, -7 },
  { 174, 4, 7, 5, 1, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 5, 7, 5, 0, -7 },
  { 187, 4, 7, 5, 1, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 4, 7, 5, 1, -7 },
  { 215, 2, 8, 5, 2, -7 },
  { 217, 4, 8, 5, 1, -7 },
  { 221, 3, 8, 5, 1, -7 },
  { 224, 4, 4, 5, 1, -7 },
  { 226, 4, 1, 5, 1, 0 },
  { 227, 2, 1, 5, 2, -7 },
  { 228, 4, 5, 5, 1, -5 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 4, 5, 5, 1, -5 },
  { 238, 4, 7, 5, 1, -7 },
  { 242, 4, 5, 5, 1, -5 },
  { 245, 4, 7, 5, 1, -7 },
  { 249, 4, 7, 5, 1, -5 },
  { 253, 4, 7, 5, 1, -7 },
  { 257, 4, 7, 5, 1, -7 },
  { 261, 3, 9, 5, 1, -7 },
  { 265, 4, 7, 5, 1, -7 },
  { 269, 5, 7, 5, 0, -7 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 5, 1, -5 },
  { 280, 4, 5, 5, 1, -5 },
  { 283, 4, 7, 5, 1, -5 },
  { 287, 4, 7, 5, 1, -5 },
  { 291, 4, 5, 5, 1, -5 },
  { 294, 4, 5, 5, 1, -5 },
  { 297, 5, 6, 5, 0, -6 },
  { 301, 4, 5, 5, 1, -5 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 5, 5, 5, 0, -5 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 5, 7, 5, 0, -5 },
  { 321, 4, 5, 5, 1, -5 },
  { 324, 4, 8, 5, 1, -7 },
  { 328, 1, 8, 5, 2, -7 },
  { 329, 4, 8, 5, 1, -7 },
  { 333, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Medium9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_MEDIUM9PT7B_H_
