#ifndef _JETBRAINSMONO_MEDIUM13PT7B_H_
#define _JETBRAINSMONO_MEDIUM13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA2, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x44, 0xBF,
  0xA4, 0x48, 0x20, 0xCF, 0xAB, 0xE3, 0x83, 0x8B, 0xA7, 0xB7, 0x88, 0x20,
  0x61, 0xD2, 0x94, 0x94, 0x68, 0x10, 0x3E, 0x29, 0x49, 0x8E, 0x33, 0xEC,
  0xB0, 0x42, 0x9B, 0xE6, 0x9B, 0xD0, 0xFC, 0x13, 0x64, 0xCC, 0xCC, 0xC4,
  0x63, 0x10, 0xC3, 0x0C, 0x21, 0x0C, 0x63, 0x10, 0x8D, 0xC8, 0x00, 0x18,
  0x33, 0xD9, 0xE1, 0x85, 0x99, 0x00, 0x30, 0xCF, 0xCC, 0x30, 0xC0, 0x6B,
  0x60, 0xF0, 0xF0, 0x0C, 0x20, 0x86, 0x10, 0xC3, 0x08, 0x61, 0x04, 0x30,
  0x33, 0xE8, 0xE3, 0xAE, 0xF8, 0xE3, 0xCD, 0xE0, 0x73, 0x49, 0x04, 0x10,
  0x41, 0x04, 0xFC, 0x33, 0xE8, 0xC3, 0x08, 0x63, 0x18, 0xC3, 0xF0, 0xF8,
  0x63, 0x0E, 0x0C, 0x38, 0xF3, 0x78, 0x18, 0xC2, 0x10, 0xCE, 0x3F, 0xC3,
  0x0C, 0xFB, 0x0C, 0x3E, 0xCC, 0x30, 0xF3, 0x78, 0x38, 0x86, 0x3E, 0xCE,
  0x18, 0x73, 0x78, 0xFE, 0x30, 0x86, 0x18, 0x43, 0x08, 0x60, 0x33, 0xEC,
  0xF3, 0x79, 0xEC, 0xE3, 0xCD, 0xE0, 0x33, 0xE8, 0xE1, 0x8F, 0xF0, 0x84,
  0x31, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xD2, 0xC0, 0x04, 0x77, 0x30, 0xE0,
  0xE0, 0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83, 0x1D, 0xCC, 0x00,
  0xF1, 0x13, 0x64, 0x04, 0xC0, 0x18, 0xCD, 0x0A, 0x1D, 0xFA, 0x74, 0xE9,
  0xDE, 0x81, 0x01, 0xC0, 0x31, 0xC7, 0x92, 0x4B, 0xEF, 0xE3, 0x84, 0xFA,
  0x38, 0xFE, 0xFA, 0x38, 0x63, 0xF8, 0x31, 0xEC, 0xE0, 0x82, 0x08, 0x23,
  0xCD, 0xE0, 0xFA, 0x38, 0xE3, 0x8E, 0x38, 0xE2, 0xF8, 0xFF, 0x0C, 0x3E,
  0xFB, 0x0C, 0x30, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x00,
  0x31, 0xEC, 0xE0, 0x82, 0x78, 0xE3, 0xCD, 0xE0, 0xCF, 0x3C, 0xFF, 0xFF,
  0x3C, 0xF3, 0xCC, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x1E, 0x0C,
  0x18, 0x30, 0x60, 0xF1, 0xA2, 0x7C, 0xCF, 0x2D, 0xBC, 0xF3, 0x6C, 0xB3,
  0xC4, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x3B, 0x6D, 0xB6,
  0x18, 0x61, 0x84, 0xCF, 0xBA, 0xEB, 0xBE, 0x79, 0x67, 0x8C, 0x33, 0xEC,
  0xE3, 0x8E, 0x38, 0xE3, 0xCD, 0xE0, 0xFF, 0x1C, 0x73, 0xFB, 0x0C, 0x30,
  0xC0, 0x33, 0xE8, 0xE3, 0x8E, 0x38, 0xE3, 0xCD, 0xE1, 0x83, 0xFB, 0x3C,
  0x73, 0xFB, 0x4D, 0xB2, 0xCC, 0x33, 0xE8, 0xF0, 0xE0, 0xE0, 0xE1, 0xCD,
  0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xF3, 0x78, 0x86, 0x3C, 0x92, 0x49, 0x67, 0x0C, 0x30, 0xDB,
  0xDA, 0x5A, 0x5A, 0x5A, 0x6A, 0x6A, 0x66, 0x66, 0x66, 0x48, 0xF0, 0xC1,
  0x87, 0x0B, 0x33, 0xC2, 0xC2, 0xC8, 0x91, 0xE1, 0x83, 0x06, 0x0C, 0x18,
  0xFC, 0x21, 0x84, 0x21, 0x84, 0x30, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x70,
  0x83, 0x04, 0x18, 0x60, 0x83, 0x04, 0x10, 0x60, 0x83, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x31, 0xC4, 0xB2, 0x84, 0xFF, 0xF0, 0xC4, 0x7B, 0x30, 0xFF,
  0x8E, 0x3F, 0xC0, 0xC3, 0x0B, 0xB3, 0xCF, 0x3C, 0xF3, 0xB8, 0x7B, 0x38,
  0x20, 0x83, 0x37, 0x80, 0x0C, 0x37, 0xF3, 0x8E, 0x38, 0xF3, 0x7C, 0x7B,
  0x38, 0xFF, 0x83, 0x37, 0x80, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20,
  0x7F, 0x38, 0xE3, 0xCF, 0xF2, 0xC3, 0x78, 0xC3, 0x0B, 0xB3, 0xCF, 0x3C,
  0xF3, 0xCC, 0x30, 0x40, 0x3C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x18, 0x41,
  0xF1, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0xC3, 0x0C, 0xF2, 0xDB, 0xCD, 0xB2,
  0xCC, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xFE, 0x9A, 0x69,
  0xA6, 0x9A, 0x40, 0xBB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x38, 0xE3,
  0x8F, 0x37, 0x80, 0xBB, 0x3C, 0xF3, 0xCF, 0x3B, 0xB0, 0xC0, 0x7F, 0x38,
  0xE3, 0x8F, 0x37, 0xC3, 0x0C, 0xFB, 0x3C, 0x70, 0xC3, 0x0C, 0x00, 0x7B,
  0x3C, 0x1E, 0x0F, 0x37, 0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C,
  0x8E, 0x38, 0xE3, 0x8F, 0x37, 0x80, 0x87, 0x3C, 0x92, 0x79, 0xC3, 0x00,
  0xDA, 0xB5, 0x6A, 0xD6, 0xAC, 0xD9, 0x00, 0xCD, 0x63, 0x0C, 0x79, 0x28,
  0xC0, 0x8F, 0x34, 0x9E, 0x70, 0xC3, 0x08, 0x60, 0xFC, 0x21, 0x0C, 0x63,
  0x0F, 0xC0, 0x0C, 0x61, 0x04, 0x10, 0xCE, 0x04, 0x10, 0x41, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0x82, 0x08, 0x20, 0x83, 0xC8, 0x20, 0x82, 0x38, 0xE6,
  0xD9, 0x80,
};

const GFXglyph JetBrainsMono_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 2, 3, 8, 3, -9 },
  { 43, 4, 13, 8, 2, -11 },
  { 50, 5, 13, 8, 1, -11 },
  { 59, 7, 7, 8, 0, -8 },
  { 66, 6, 6, 8, 1, -7 },
  { 71, 3, 4, 8, 2, -2 },
  { 73, 4, 1, 8, 2, -5 },
  { 74, 2, 2, 8, 3, -2 },
  { 75, 6, 12, 8, 1, -11 },
  { 84, 6, 10, 8, 1, -10 },
  { 92, 6, 9, 8, 1, -9 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 9, 8, 1, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 10, 8, 1, -10 },
  { 150, 6, 10, 8, 1, -10 },
  { 158, 2, 7, 8, 3, -7 },
  { 160, 3, 9, 8, 2, -7 },
  { 164, 6, 7, 8, 1, -8 },
  { 170, 6, 5, 8, 1, -7 },
  { 174, 6, 7, 8, 1, -8 },
  { 180, 4, 9, 8, 2, -9 },
  { 185, 7, 12, 8, 0, -10 },
  { 196, 6, 9, 8, 1, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 6, 10, 8, 1, -10 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 6, 10, 8, 1, -10 },
  { 240, 6, 10, 8, 1, -10 },
  { 248, 6, 9, 8, 1, -9 },
  { 255, 6, 9, 8, 1, -9 },
  { 262, 7, 9, 8, 0, -9 },
  { 270, 6, 9, 8, 1, -9 },
  { 277, 6, 9, 8, 1, -9 },
  { 284, 6, 9, 8, 1, -9 },
  { 291, 6, 9, 8, 1, -9 },
  { 298, 6, 10, 8, 1, -10 },
  { 306, 6, 9, 8, 1, -9 },
  { 313, 6, 12, 8, 1, -10 },
  { 322, 6, 9, 8, 1, -9 },
  { 329, 6, 10, 8, 1, -10 },
  { 337, 6, 10, 8, 1, -10 },
  { 345, 6, 9, 8, 1, -9 },
  { 352, 6, 9, 8, 1, -9 },
  { 359, 8, 9, 8, 0, -9 },
  { 368, 7, 9, 8, 0, -9 },
  { 376, 7, 9, 8, 0, -9 },
  { 384, 6, 9, 8, 1, -9 },
  { 391, 3, 12, 8, 3, -11 },
  { 396, 6, 12, 8, 1, -11 },
  { 405, 3, 12, 8, 2, -11 },
  { 410, 6, 5, 8, 1, -9 },
  { 414, 6, 2, 8, 1, 0 },
  { 416, 3, 2, 8, 2, -10 },
  { 417, 6, 7, 8, 1, -7 },
  { 423, 6, 9, 8, 1, -9 },
  { 430, 6, 7, 8, 1, -7 },
  { 436, 6, 9, 8, 1, -9 },
  { 443, 6, 7, 8, 1, -7 },
  { 449, 6, 9, 8, 1, -9 },
  { 456, 6, 9, 8, 1, -7 },
  { 463, 6, 9, 8, 1, -9 },
  { 470, 6, 10, 8, 1, -10 },
  { 478, 5, 12, 8, 1, -10 },
  { 486, 6, 9, 8, 1, -9 },
  { 493, 7, 9, 8, 0, -9 },
  { 501, 6, 7, 8, 1, -7 },
  { 507, 6, 7, 8, 1, -7 },
  { 513, 6, 7, 8, 1, -7 },
  { 519, 6, 9, 8, 1, -7 },
  { 526, 6, 9, 8, 1, -7 },
  { 533, 6, 7, 8, 1, -7 },
  { 539, 6, 7, 8, 1, -7 },
  { 545, 6, 9, 8, 1, -9 },
  { 552, 6, 7, 8, 1, -7 },
  { 558, 6, 7, 8, 1, -7 },
  { 564, 7, 7, 8, 0, -7 },
  { 571, 6, 7, 8, 1, -7 },
  { 577, 6, 9, 8, 1, -7 },
  { 584, 6, 7, 8, 1, -7 },
  { 590, 6, 12, 8, 1, -11 },
  { 599, 2, 12, 8, 3, -11 },
  { 602, 6, 12, 8, 1, -11 },
  { 611, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Medium13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_MEDIUM13PT7B_H_
