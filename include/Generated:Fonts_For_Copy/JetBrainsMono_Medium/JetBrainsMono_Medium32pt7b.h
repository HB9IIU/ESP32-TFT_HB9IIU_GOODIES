#ifndef _JETBRAINSMONO_MEDIUM32PT7B_H_
#define _JETBRAINSMONO_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFD, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0x1E, 0xE3,
  0xDC, 0x7B, 0x8F, 0x70, 0xC0, 0x03, 0x07, 0x03, 0x83, 0x01, 0xC1, 0x80,
  0xE1, 0xC0, 0x60, 0xE0, 0x30, 0x71, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x07, 0x01, 0x83, 0x81, 0xC1, 0x80, 0xE0, 0xC3, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0C, 0x18, 0x0E, 0x0C, 0x07, 0x06, 0x03,
  0x87, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x3C, 0x03, 0xFE, 0x0F, 0xFE, 0x3E, 0xFE, 0x79, 0x9C, 0xE3,
  0x3D, 0xC6, 0x7B, 0x8C, 0x07, 0x98, 0x0F, 0xB0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0C, 0xF0, 0x19, 0xE0, 0x31, 0xFC,
  0x63, 0xF8, 0xCF, 0x79, 0xBE, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x07, 0xE0, 0x1D, 0xFE,
  0x07, 0x30, 0xC1, 0xCE, 0x1C, 0x31, 0xC3, 0x8E, 0x38, 0x73, 0x87, 0x0E,
  0x60, 0x73, 0x9C, 0x0F, 0xF7, 0x00, 0xFC, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x8C, 0x00, 0x67, 0xE0, 0x1D, 0xFE, 0x07, 0x38, 0xE0, 0xC6,
  0x1C, 0x38, 0xC3, 0x8E, 0x18, 0x71, 0x83, 0x0E, 0x70, 0x73, 0x9C, 0x0F,
  0xF7, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x7C, 0xF8, 0x78,
  0x38, 0x70, 0x38, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0xFF, 0x07, 0xE7, 0x8F, 0xE3, 0x8E, 0xE1, 0xDC, 0xE1,
  0xFC, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xFC, 0xFF, 0xFC, 0x7F,
  0xCE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0xF0, 0xFC, 0x7E,
  0x3E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7F, 0x0F, 0xC0, 0xF0, 0x0C, 0x80, 0x38,
  0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0xC3, 0xE3, 0xF0, 0xF8, 0x38, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x0E, 0x19, 0xE3, 0x3F, 0xFD, 0x7F, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0xD8,
  0x00, 0xEE, 0x00, 0xF7, 0x80, 0x71, 0xE0, 0x78, 0xF0, 0x78, 0x3C, 0x08,
  0x08, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F,
  0x1E, 0x38, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x81, 0xCE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xCE, 0x3F, 0x9C, 0x7F, 0x3C,
  0xFE, 0x71, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B,
  0x80, 0xF7, 0x83, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x7E,
  0x07, 0xF8, 0x3E, 0xE0, 0xF3, 0x83, 0x0E, 0x08, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xDE,
  0x03, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x73, 0xC1,
  0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC1, 0xDE, 0x07, 0x78, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x73, 0xF0, 0xEF, 0xF1, 0xFF, 0xF3, 0xC1, 0xE7, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3D, 0xC0, 0x73,
  0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x77, 0xE1, 0xFF, 0xF3, 0xE3, 0xEF, 0x81, 0xFE, 0x03, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0xC1, 0xE7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x78, 0x3C, 0x78, 0x70, 0x7B, 0xE0, 0x7F, 0x00, 0xFF,
  0x07, 0xDF, 0x1E, 0x0F, 0x38, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xF7, 0x83, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x03, 0x80, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0xFF, 0xC7, 0xFF, 0x87,
  0xEE, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xC0, 0x1C, 0x7C, 0xF9, 0xF3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x9E, 0x3C, 0x79, 0xE3, 0xC7,
  0x0E, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x1F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x3F, 0xE3, 0xFC, 0x3F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x1D, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x33, 0xF0, 0x7F, 0xF8, 0x7F, 0x7C, 0x38, 0x7E,
  0x1C, 0x3F, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC1,
  0xF8, 0x70, 0xFC, 0x38, 0xFE, 0x1F, 0xDF, 0x07, 0xDF, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03,
  0x8F, 0x03, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1C, 0x07, 0x0E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0x73, 0x80,
  0x3B, 0xC0, 0x1E, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC,
  0xE0, 0xFB, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0x87,
  0xFF, 0x3F, 0x7E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x79, 0xFF, 0xE7, 0xFF,
  0x07, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xB8,
  0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0x7E,
  0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x79, 0xFF, 0xE7, 0xFF, 0x07, 0xF0, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7B, 0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xE0,
  0x1F, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38,
  0x70, 0xF0, 0xE1, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0E, 0x3C, 0x1C,
  0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xE7, 0x01,
  0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xDF, 0xE1, 0xBF, 0xC7, 0xFD, 0x8F, 0xFB,
  0x9B, 0xF7, 0x77, 0xE6, 0xEF, 0xCD, 0x9F, 0x9F, 0x3F, 0x1E, 0x7E, 0x38,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFB, 0x8F, 0xEE, 0x3F,
  0x98, 0xFE, 0x73, 0xF9, 0xCF, 0xE3, 0x3F, 0x8E, 0xFE, 0x3B, 0xF8, 0x7F,
  0xE1, 0xDF, 0x87, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07,
  0xC0, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0x7E, 0xF0, 0x7B, 0x80, 0xEE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0E,
  0xF0, 0x79, 0xFF, 0xE7, 0xFF, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7B, 0x83, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83,
  0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x83, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1C, 0x78, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xE7,
  0x03, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x0F, 0x80, 0x03, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xF3, 0xE7, 0x81, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0x83, 0xEF,
  0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xBC, 0x1E, 0x7F, 0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0xF0, 0x07, 0xB8, 0x03,
  0x9E, 0x01, 0xCF, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x38, 0x78,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x87, 0x03, 0xC3, 0x80, 0xE3, 0xC0,
  0x71, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xE1, 0xC3, 0xF8,
  0x70, 0xEE, 0x1E, 0x3B, 0x87, 0x8E, 0xE3, 0x63, 0xB8, 0xD8, 0xEE, 0x36,
  0x39, 0xCD, 0x8E, 0x73, 0x63, 0x9C, 0xD8, 0xC7, 0x32, 0x71, 0xCC, 0xDC,
  0x72, 0x37, 0x1D, 0x8D, 0xC7, 0x63, 0x71, 0xD8, 0xDC, 0x36, 0x37, 0x0D,
  0x8D, 0xC3, 0x63, 0x60, 0xF8, 0x58, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF8, 0x07, 0xBC, 0x07, 0x8F, 0x07, 0x83, 0x83, 0xC1, 0xE3, 0xC0,
  0x71, 0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E, 0xF0, 0x0E,
  0x3C, 0x0F, 0x1E, 0x07, 0x07, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x70, 0x1C, 0x78, 0x0F, 0x38, 0x03, 0xBC, 0x01,
  0xDC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x8E,
  0x07, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x39, 0xC0, 0x77, 0x80, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3C, 0x1C, 0x1F, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x3F, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xFE, 0x7F, 0x7F, 0xDE, 0x7F, 0x3C, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x8F, 0x0E, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1E, 0xFF, 0xFB, 0xBF, 0xCE, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xEE, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x01, 0xEE, 0x03, 0xDE, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xF3, 0xCF, 0xF7,
  0x9F, 0xFF, 0x7C, 0x7E, 0xF0, 0x7D, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0xC1,
  0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x03, 0xDE, 0x07, 0x1F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1F, 0x3B, 0xFD, 0xDF, 0xFF, 0xF1, 0xFF, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xFC, 0x7D,
  0xFF, 0xEF, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x9F,
  0xFC, 0xFF, 0xC7, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x8F, 0x0E, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B, 0xC0, 0xEE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x7C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xF8, 0x0F, 0x70, 0x1E, 0xE0, 0x79,
  0xC1, 0xE3, 0x83, 0xC7, 0x0F, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x71,
  0xE0, 0xE1, 0xE1, 0xC1, 0xE3, 0x83, 0xC7, 0x03, 0xCE, 0x07, 0x9C, 0x07,
  0xB8, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFE, 0xEE, 0x39, 0xFE, 0xFF, 0xFF, 0xFF, 0x1C, 0x7E,
  0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1C, 0xE3, 0xC3, 0xBF, 0xCF, 0xFF, 0xBE, 0x3E, 0xF0, 0x3B, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xEE, 0x03,
  0x9E, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xE3, 0xC3, 0xBF, 0xCF,
  0xFF, 0xBE, 0x1E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xBF, 0xFE,
  0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x1F, 0x3D, 0xFE, 0xF7, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0xBC, 0xFC, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF3, 0xE3, 0xDF, 0xCF,
  0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7,
  0x01, 0xEE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03,
  0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBF, 0xFE, 0x3F, 0xFC,
  0x3F, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x07,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x01,
  0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1E,
  0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xFC, 0x3C, 0x76, 0x36, 0x3B, 0x9B, 0x19, 0xCD, 0x8C,
  0xE6, 0xCE, 0x73, 0x67, 0x39, 0x93, 0x9C, 0x8D, 0xC6, 0xC6, 0xE3, 0x63,
  0x61, 0xF1, 0xB0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0E, 0x0F, 0x00,
  0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0xC0, 0x7B,
  0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x78, 0x0F,
  0x7C, 0x03, 0xC0, 0xF0, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xE3,
  0xC0, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x0E, 0x3C, 0x07, 0x9C,
  0x03, 0xCE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x7F, 0x07, 0xFC, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xE0, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x1F, 0xFC, 0x3F, 0x3C, 0x7E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 11, 9, 19, 4, -23 },
  { 29, 17, 23, 19, 1, -23 },
  { 78, 15, 32, 19, 2, -28 },
  { 138, 19, 24, 19, 0, -24 },
  { 195, 16, 24, 19, 2, -24 },
  { 243, 3, 9, 19, 8, -23 },
  { 247, 10, 31, 19, 6, -27 },
  { 286, 10, 31, 19, 4, -27 },
  { 325, 17, 17, 19, 1, -20 },
  { 362, 15, 15, 19, 2, -18 },
  { 391, 7, 10, 19, 5, -5 },
  { 400, 11, 3, 19, 4, -12 },
  { 405, 5, 5, 19, 7, -5 },
  { 409, 15, 31, 19, 2, -27 },
  { 468, 15, 24, 19, 2, -24 },
  { 513, 14, 23, 19, 3, -23 },
  { 554, 15, 24, 19, 2, -24 },
  { 599, 15, 23, 19, 2, -23 },
  { 643, 14, 23, 19, 2, -23 },
  { 684, 15, 23, 19, 2, -23 },
  { 728, 15, 23, 19, 2, -23 },
  { 772, 15, 23, 19, 2, -23 },
  { 816, 15, 24, 19, 2, -24 },
  { 861, 15, 24, 19, 2, -24 },
  { 906, 5, 18, 19, 7, -18 },
  { 918, 7, 23, 19, 5, -18 },
  { 939, 14, 17, 19, 3, -19 },
  { 969, 14, 11, 19, 3, -16 },
  { 989, 14, 17, 19, 3, -19 },
  { 1019, 12, 23, 19, 4, -23 },
  { 1054, 17, 30, 19, 1, -24 },
  { 1118, 17, 23, 19, 1, -23 },
  { 1167, 14, 23, 19, 3, -23 },
  { 1208, 14, 24, 19, 3, -24 },
  { 1250, 14, 23, 19, 3, -23 },
  { 1291, 14, 23, 19, 3, -23 },
  { 1332, 14, 23, 19, 3, -23 },
  { 1373, 14, 24, 19, 3, -24 },
  { 1415, 13, 23, 19, 3, -23 },
  { 1453, 13, 23, 19, 3, -23 },
  { 1491, 15, 23, 19, 1, -23 },
  { 1535, 15, 23, 19, 3, -23 },
  { 1579, 14, 23, 19, 3, -23 },
  { 1620, 15, 23, 19, 2, -23 },
  { 1664, 14, 23, 19, 3, -23 },
  { 1705, 14, 24, 19, 3, -24 },
  { 1747, 15, 23, 19, 3, -23 },
  { 1791, 15, 30, 19, 2, -24 },
  { 1848, 15, 23, 19, 3, -23 },
  { 1892, 15, 24, 19, 2, -24 },
  { 1937, 16, 23, 19, 2, -23 },
  { 1983, 14, 23, 19, 3, -23 },
  { 2024, 17, 23, 19, 1, -23 },
  { 2073, 18, 23, 19, 1, -23 },
  { 2125, 17, 23, 19, 1, -23 },
  { 2174, 17, 23, 19, 1, -23 },
  { 2223, 14, 23, 19, 3, -23 },
  { 2264, 9, 31, 19, 6, -27 },
  { 2299, 15, 31, 19, 2, -27 },
  { 2358, 8, 31, 19, 5, -27 },
  { 2389, 15, 12, 19, 2, -23 },
  { 2412, 15, 3, 19, 2, 1 },
  { 2418, 8, 4, 19, 5, -25 },
  { 2422, 15, 18, 19, 2, -18 },
  { 2456, 14, 23, 19, 3, -23 },
  { 2497, 15, 18, 19, 2, -18 },
  { 2531, 15, 23, 19, 2, -23 },
  { 2575, 15, 18, 19, 2, -18 },
  { 2609, 15, 23, 19, 2, -23 },
  { 2653, 13, 24, 19, 3, -18 },
  { 2692, 14, 23, 19, 3, -23 },
  { 2733, 15, 25, 19, 3, -25 },
  { 2780, 12, 31, 19, 3, -25 },
  { 2827, 15, 23, 19, 3, -23 },
  { 2871, 17, 23, 19, 1, -23 },
  { 2920, 15, 18, 19, 2, -18 },
  { 2954, 14, 18, 19, 3, -18 },
  { 2986, 15, 18, 19, 2, -18 },
  { 3020, 14, 24, 19, 3, -18 },
  { 3062, 14, 24, 19, 3, -18 },
  { 3104, 14, 18, 19, 3, -18 },
  { 3136, 15, 18, 19, 2, -18 },
  { 3170, 15, 23, 19, 2, -23 },
  { 3214, 14, 18, 19, 3, -18 },
  { 3246, 17, 18, 19, 1, -18 },
  { 3285, 17, 18, 19, 1, -18 },
  { 3324, 17, 18, 19, 1, -18 },
  { 3363, 17, 24, 19, 1, -18 },
  { 3414, 14, 18, 19, 3, -18 },
  { 3446, 14, 31, 19, 3, -27 },
  { 3501, 3, 31, 19, 8, -27 },
  { 3513, 14, 31, 19, 3, -27 },
  { 3568, 15, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_Medium32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_MEDIUM32PT7B_H_
