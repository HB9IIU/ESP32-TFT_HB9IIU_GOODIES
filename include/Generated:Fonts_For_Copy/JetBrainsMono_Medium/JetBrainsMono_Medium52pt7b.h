#ifndef _JETBRAINSMONO_MEDIUM52PT7B_H_
#define _JETBRAINSMONO_MEDIUM52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0xBF, 0xEF, 0xF7, 0xF1, 0xF8, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3C, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xF9, 0xC7, 0xE1,
  0xF8, 0xE1, 0xF9, 0xF8, 0x70, 0xFC, 0xFC, 0x38, 0x3E, 0x7E, 0x1C, 0x1F,
  0x3F, 0x0E, 0x00, 0x1F, 0x87, 0x00, 0x07, 0xE3, 0x80, 0x03, 0xF1, 0xC0,
  0x01, 0xFC, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xEF, 0xF8, 0x00, 0x71, 0xFC, 0x00, 0x38, 0x7E, 0x00,
  0x1C, 0x1F, 0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xFF, 0x83, 0x83, 0xFF,
  0xC1, 0xC1, 0xFB, 0xF0, 0xE0, 0xFD, 0xF8, 0x70, 0xFC, 0xFE, 0x38, 0xFE,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x78, 0xFF, 0xF0,
  0x01, 0xE3, 0xFF, 0xF0, 0x07, 0xC7, 0xC1, 0xE0, 0x0F, 0x0F, 0x03, 0xC0,
  0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07,
  0x80, 0xF0, 0x3E, 0x1E, 0x01, 0xE0, 0x7C, 0x7C, 0x03, 0xC0, 0xF0, 0xF0,
  0x07, 0xC1, 0xE3, 0xC0, 0x0F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0x1E, 0x00,
  0x0F, 0xFC, 0x78, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x1F, 0x3F, 0xFC, 0x00,
  0x3C, 0xFF, 0xFC, 0x00, 0xF1, 0xF0, 0xF8, 0x03, 0xE3, 0xC0, 0xF0, 0x07,
  0x87, 0x81, 0xE0, 0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x3E, 0x01,
  0xF0, 0x78, 0x78, 0x03, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0xC7, 0xC0, 0x03,
  0xFF, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x03, 0xEF, 0xCF, 0xC0, 0xFD, 0xF0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC7, 0xE7,
  0xC1, 0xF8, 0xF8, 0xF8, 0x1F, 0xBF, 0x1F, 0x01, 0xFF, 0xC3, 0xE0, 0x1F,
  0xF0, 0x7C, 0x03, 0xFE, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x07, 0xFE, 0x1F, 0xE3, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xC3, 0xFF, 0xE0, 0xFC, 0x1F,
  0xF8, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x02, 0x00, 0xF8, 0x02, 0x78, 0x1F, 0x03, 0xCF, 0xC1, 0xE1, 0xFF,
  0xFE, 0x38, 0xFF, 0xFF, 0xF7, 0x3F, 0xF7, 0xFF, 0x7F, 0xFE, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1,
  0xFF, 0x87, 0xE3, 0xFF, 0x0F, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x7F,
  0x00, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xDF, 0x00, 0xFF, 0x9F, 0x00, 0xFE, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF0,
  0x1F, 0x00, 0xE0, 0x1F, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x7E, 0x01, 0xF3,
  0xF0, 0x07, 0xDF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xF0, 0x1F,
  0x3F, 0xF8, 0x3E, 0xFF, 0xF8, 0x7D, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFE,
  0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xFC, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F,
  0xF8, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xF1, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFC,
  0xFF, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x0F,
  0xF1, 0xFE, 0x1F, 0x80, 0xFE, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x01, 0xFD, 0xFF, 0xBF,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFC, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xF0,
  0x0F, 0xFB, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xF0, 0x40,
  0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF3,
  0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xEF, 0xF8, 0x1F, 0x8F, 0xFF, 0x03,
  0xE0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x00, 0xFF, 0x83, 0xE0, 0x1F,
  0xF0, 0x7C, 0x03, 0xFE, 0x0F, 0x80, 0x7F, 0xC1, 0xF0, 0x0F, 0xF8, 0x3E,
  0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xF8, 0x07, 0xFC, 0x1F, 0x00, 0xFF,
  0x83, 0xE0, 0x3F, 0xF0, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xC7, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x03,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F,
  0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFC,
  0x7F, 0xDF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x3F, 0xF7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x78, 0x07, 0xFF, 0xFC, 0x07, 0xBF,
  0xFE, 0x03, 0xDF, 0xF7, 0x81, 0xEF, 0xFB, 0xC1, 0xEF, 0xFD, 0xE0, 0xF7,
  0xFE, 0x78, 0x7B, 0xFF, 0x3C, 0x79, 0xFF, 0x9E, 0x3C, 0xFF, 0xCF, 0x9E,
  0x7F, 0xE3, 0xCE, 0x3F, 0xF1, 0xEF, 0x1F, 0xF8, 0xF7, 0x8F, 0xFC, 0x3F,
  0xC7, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE1, 0xFF, 0xC3, 0xF0, 0xFF, 0xE1,
  0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFB, 0xC0, 0x3F, 0xF7, 0xC0, 0x7F, 0xEF, 0x80, 0xFF,
  0xCF, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x3C, 0x0F, 0xFC,
  0x7C, 0x1F, 0xF8, 0xF8, 0x3F, 0xF0, 0xF0, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3,
  0xE1, 0xFF, 0x83, 0xC3, 0xFF, 0x07, 0xC7, 0xFE, 0x0F, 0x8F, 0xFC, 0x0F,
  0x9F, 0xF8, 0x1F, 0x3F, 0xF0, 0x1E, 0x7F, 0xE0, 0x3E, 0xFF, 0xC0, 0x7D,
  0xFF, 0x80, 0x7B, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F,
  0x80, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBF,
  0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0xDF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xEF,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x01,
  0xFC, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xE0,
  0x0F, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF,
  0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7F,
  0x01, 0xFC, 0x7F, 0xDF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07,
  0xFE, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0x81, 0xF7, 0xC0, 0xFC, 0x0F, 0xBE,
  0x0F, 0xE0, 0x7D, 0xF0, 0x77, 0x03, 0xCF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D,
  0xC1, 0xF3, 0xE0, 0xEE, 0x0F, 0x9F, 0x07, 0x70, 0x7C, 0xF8, 0x3B, 0xC3,
  0xE7, 0xC1, 0xCE, 0x1F, 0x1E, 0x1E, 0x70, 0xF8, 0xF0, 0xF3, 0x87, 0xC7,
  0xC7, 0x1C, 0x3C, 0x3E, 0x38, 0xE1, 0xE1, 0xF1, 0xC7, 0x0F, 0x0F, 0x8E,
  0x38, 0xF8, 0x7C, 0x71, 0xC7, 0xC3, 0xE3, 0x8F, 0x3E, 0x1F, 0x1C, 0x39,
  0xF0, 0x79, 0xE1, 0xCF, 0x83, 0xCE, 0x0E, 0x78, 0x1E, 0x70, 0x73, 0xC0,
  0xFB, 0x83, 0x9E, 0x07, 0xDC, 0x1C, 0xF0, 0x3E, 0xE0, 0xE7, 0x81, 0xF7,
  0x07, 0x7C, 0x0F, 0xB8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7F, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F,
  0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7F,
  0x03, 0xF3, 0xFF, 0x87, 0xEF, 0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0xE0, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFD, 0xFF, 0xDF, 0xFB, 0xF7, 0xFF,
  0xE7, 0xEF, 0xFF, 0xCF, 0xCF, 0xFF, 0x1F, 0x8F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x3F, 0xEF,
  0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0xF9, 0xF8,
  0xFF, 0xFB, 0xF3, 0xFF, 0xF7, 0xEF, 0xFF, 0xFF, 0xDF, 0xC0, 0xFF, 0xBF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0x7F, 0x01, 0xFE, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFB, 0xF0,
  0xFF, 0xE7, 0xE0, 0xFF, 0x8F, 0xC0, 0x10, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x8F,
  0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xFD, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7E, 0x1F,
  0xFC, 0xFC, 0x0F, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x03, 0xF3, 0xFF, 0x87, 0xEF, 0xFF, 0x8F,
  0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8,
  0x03, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0x7D,
  0xFC, 0x7F, 0x3E, 0xFF, 0x7F, 0xDF, 0xFF, 0xBF, 0xEF, 0xC7, 0xF1, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x3C, 0x1F, 0xF8, 0x1E, 0x0F,
  0xFC, 0x0F, 0x07, 0xFE, 0x07, 0x83, 0xFF, 0x03, 0xC1, 0xFF, 0x81, 0xE0,
  0xFF, 0xC0, 0xF0, 0x7F, 0xE0, 0x78, 0x3F, 0xF0, 0x3C, 0x1F, 0xF8, 0x1E,
  0x0F, 0xFC, 0x0F, 0x07, 0xFE, 0x07, 0x83, 0xFF, 0x03, 0xC1, 0xFF, 0x81,
  0xE0, 0xFF, 0xC0, 0xF0, 0x7F, 0xE0, 0x78, 0x3F, 0xF0, 0x3C, 0x1F, 0xF8,
  0x1E, 0x0F, 0xFC, 0x0F, 0x07, 0xFE, 0x07, 0x83, 0xFF, 0x03, 0xC1, 0xFF,
  0x81, 0xE0, 0xF8, 0xFC, 0x3F, 0x81, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7,
  0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xBF, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0x9F, 0x80, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFE,
  0x3F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x3F, 0x81, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7,
  0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7E,
  0xFF, 0xE7, 0xFD, 0xFB, 0xFF, 0xF3, 0xF7, 0xFF, 0xE7, 0xE7, 0xFF, 0x8F,
  0xC7, 0xFC, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F,
  0xFD, 0xF9, 0xFF, 0xFB, 0xF7, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xDF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF,
  0x80, 0xFF, 0x7F, 0xEF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF8, 0x7F,
  0xF3, 0xF0, 0x7F, 0xC7, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF9, 0xFF,
  0xC3, 0xF7, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F,
  0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0x7F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x3F, 0xEF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xFB, 0xC0, 0x7C,
  0x07, 0xDE, 0x03, 0xE0, 0x3C, 0xF8, 0x1F, 0x01, 0xE7, 0xC0, 0xFC, 0x0F,
  0x3E, 0x0E, 0xE0, 0xF9, 0xF0, 0x77, 0x07, 0xC7, 0x83, 0xB8, 0x3E, 0x3C,
  0x1D, 0xC1, 0xE1, 0xE0, 0xEE, 0x0F, 0x0F, 0x87, 0x78, 0x78, 0x7C, 0x39,
  0xC3, 0xC3, 0xE3, 0x8E, 0x3E, 0x1F, 0x1C, 0x71, 0xF0, 0x78, 0xE3, 0x8F,
  0x83, 0xC7, 0x1C, 0x78, 0x1E, 0x38, 0xE3, 0xC0, 0xF9, 0xC3, 0x9E, 0x07,
  0xDE, 0x1C, 0xF0, 0x3E, 0xE0, 0xEF, 0x80, 0xF7, 0x07, 0x7C, 0x07, 0xB8,
  0x3B, 0xC0, 0x3D, 0xC1, 0xDE, 0x01, 0xEE, 0x0F, 0xF0, 0x0F, 0x70, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xDF, 0xFE,
  0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xF0, 0x7F, 0xE0,
  0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x7C, 0x03, 0xFF, 0x3E,
  0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 38, 31, 11, -38 },
  { 44, 17, 16, 31, 7, -38 },
  { 78, 28, 38, 31, 2, -38 },
  { 211, 25, 52, 31, 3, -45 },
  { 374, 31, 38, 31, 0, -38 },
  { 522, 27, 39, 31, 3, -38 },
  { 654, 6, 16, 31, 12, -38 },
  { 666, 16, 50, 31, 9, -44 },
  { 766, 16, 50, 31, 6, -44 },
  { 866, 27, 27, 31, 2, -32 },
  { 958, 25, 24, 31, 3, -29 },
  { 1033, 12, 16, 31, 8, -8 },
  { 1057, 17, 5, 31, 7, -20 },
  { 1068, 9, 10, 31, 11, -9 },
  { 1080, 24, 49, 31, 4, -43 },
  { 1227, 23, 39, 31, 4, -38 },
  { 1340, 24, 38, 31, 4, -38 },
  { 1454, 25, 38, 31, 3, -38 },
  { 1573, 24, 39, 31, 3, -38 },
  { 1690, 22, 38, 31, 4, -38 },
  { 1795, 23, 39, 31, 4, -38 },
  { 1908, 25, 39, 31, 3, -38 },
  { 2030, 24, 38, 31, 4, -38 },
  { 2144, 23, 40, 31, 4, -39 },
  { 2259, 25, 38, 31, 3, -38 },
  { 2378, 9, 30, 31, 11, -29 },
  { 2412, 12, 37, 31, 8, -29 },
  { 2468, 23, 28, 31, 4, -31 },
  { 2549, 23, 18, 31, 4, -26 },
  { 2601, 23, 28, 31, 4, -31 },
  { 2682, 19, 38, 31, 7, -38 },
  { 2773, 27, 47, 31, 2, -38 },
  { 2932, 27, 38, 31, 2, -38 },
  { 3061, 24, 38, 31, 4, -38 },
  { 3175, 23, 39, 31, 4, -38 },
  { 3288, 23, 38, 31, 4, -38 },
  { 3398, 22, 38, 31, 5, -38 },
  { 3503, 23, 38, 31, 5, -38 },
  { 3613, 23, 39, 31, 4, -38 },
  { 3726, 23, 38, 31, 4, -38 },
  { 3836, 21, 38, 31, 5, -38 },
  { 3936, 24, 39, 31, 2, -38 },
  { 4053, 25, 38, 31, 4, -38 },
  { 4172, 22, 38, 31, 6, -38 },
  { 4277, 25, 38, 31, 3, -38 },
  { 4396, 23, 38, 31, 4, -38 },
  { 4506, 23, 39, 31, 4, -38 },
  { 4619, 25, 38, 31, 4, -38 },
  { 4738, 24, 47, 31, 4, -38 },
  { 4879, 25, 38, 31, 4, -38 },
  { 4998, 25, 40, 31, 3, -39 },
  { 5123, 26, 38, 31, 3, -38 },
  { 5247, 23, 39, 31, 4, -38 },
  { 5360, 27, 38, 31, 2, -38 },
  { 5489, 29, 38, 31, 1, -38 },
  { 5627, 27, 38, 31, 2, -38 },
  { 5756, 28, 38, 31, 2, -38 },
  { 5889, 23, 38, 31, 4, -38 },
  { 5999, 14, 49, 31, 10, -43 },
  { 6085, 25, 49, 31, 3, -43 },
  { 6239, 14, 49, 31, 7, -43 },
  { 6325, 23, 20, 31, 4, -38 },
  { 6383, 25, 5, 31, 3, 1 },
  { 6399, 12, 7, 31, 9, -41 },
  { 6410, 24, 30, 31, 3, -29 },
  { 6500, 23, 39, 31, 4, -38 },
  { 6613, 23, 30, 31, 4, -29 },
  { 6700, 23, 39, 31, 4, -38 },
  { 6813, 23, 30, 31, 4, -29 },
  { 6900, 25, 38, 31, 3, -38 },
  { 7019, 23, 38, 31, 4, -29 },
  { 7129, 23, 38, 31, 4, -38 },
  { 7239, 25, 41, 31, 4, -41 },
  { 7368, 20, 50, 31, 4, -41 },
  { 7493, 24, 38, 31, 5, -38 },
  { 7607, 27, 38, 31, 2, -38 },
  { 7736, 25, 29, 31, 3, -29 },
  { 7827, 23, 29, 31, 4, -29 },
  { 7911, 23, 29, 31, 4, -29 },
  { 7995, 23, 38, 31, 4, -29 },
  { 8105, 23, 38, 31, 4, -29 },
  { 8215, 23, 29, 31, 5, -29 },
  { 8299, 24, 29, 31, 4, -29 },
  { 8386, 24, 37, 31, 3, -37 },
  { 8497, 23, 30, 31, 4, -29 },
  { 8584, 27, 29, 31, 2, -29 },
  { 8682, 29, 29, 31, 1, -29 },
  { 8788, 27, 29, 31, 2, -29 },
  { 8886, 27, 38, 31, 2, -29 },
  { 9015, 23, 29, 31, 4, -29 },
  { 9099, 23, 49, 31, 4, -43 },
  { 9240, 5, 49, 31, 13, -43 },
  { 9271, 23, 49, 31, 4, -43 },
  { 9412, 25, 11, 31, 3, -24 },
};

const GFXfont JetBrainsMono_Medium52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_MEDIUM52PT7B_H_
