#ifndef _JETBRAINSMONO_MEDIUM20PT7B_H_
#define _JETBRAINSMONO_MEDIUM20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x0F, 0x60, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x18, 0x86, 0x21, 0x18, 0x46, 0xFF, 0xFF, 0xF3, 0x10, 0xC4,
  0x23, 0x08, 0xCF, 0xFD, 0x88, 0x62, 0x11, 0x84, 0x60, 0x0C, 0x03, 0x01,
  0xE0, 0xFE, 0x7D, 0x9B, 0x66, 0xC5, 0xB0, 0x7C, 0x0F, 0xC0, 0xF8, 0x36,
  0x0D, 0xF3, 0x36, 0xD9, 0xFE, 0x3F, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x37,
  0xC6, 0xCC, 0x4C, 0xCC, 0xCD, 0x86, 0xD0, 0x7B, 0x00, 0x60, 0x04, 0xC0,
  0xFE, 0x1B, 0x31, 0x33, 0x33, 0x36, 0x33, 0xC1, 0xE0, 0x1C, 0x0F, 0xC6,
  0x31, 0x8E, 0x60, 0x1C, 0x03, 0x01, 0xE0, 0xDC, 0xF3, 0x6C, 0x7B, 0x0C,
  0xC3, 0xBF, 0xE7, 0xCC, 0xFF, 0xF0, 0x04, 0x73, 0x98, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x70, 0xF1, 0xC0, 0x83, 0x87, 0x06,
  0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x3B, 0xCE, 0x00,
  0x0C, 0x03, 0x08, 0xC7, 0xB7, 0xFB, 0xC3, 0x01, 0xE0, 0xCC, 0x73, 0x88,
  0x40, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x3B, 0x9C, 0xC6, 0x60, 0xFF, 0xF0, 0xFF, 0x60, 0x01, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1E, 0x0F, 0xC6,
  0x19, 0x86, 0xE1, 0xF8, 0x7E, 0xDF, 0xB7, 0xED, 0xF8, 0x7E, 0x1D, 0x86,
  0x61, 0x9F, 0xE3, 0xF0, 0x1C, 0x1E, 0x3B, 0x19, 0x88, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x1E, 0x0F, 0xC6,
  0x3B, 0x86, 0xC1, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x1F, 0xF7, 0xFC, 0x7F, 0xBF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7C,
  0x3F, 0x01, 0x80, 0xC0, 0x78, 0x36, 0x1B, 0xFC, 0xFC, 0x03, 0x83, 0x81,
  0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE3, 0x61, 0xF0, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xCC, 0xFE, 0xE7, 0x03, 0x03,
  0x03, 0x03, 0xC3, 0xFF, 0x7E, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C,
  0x07, 0xF1, 0xFE, 0xE1, 0xB0, 0x3C, 0x0F, 0x03, 0x61, 0x9F, 0xE3, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0x86, 0xE1, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0x1E, 0x0F, 0xC7, 0x39, 0x86,
  0x61, 0x98, 0x63, 0xF0, 0x78, 0x3F, 0x18, 0x66, 0x1B, 0x87, 0x61, 0x9F,
  0xE3, 0xF0, 0x1E, 0x0F, 0xC6, 0x1B, 0x87, 0xC0, 0xF0, 0x3E, 0x1D, 0xCE,
  0x3D, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0x60, 0x00,
  0x00, 0x6F, 0xF0, 0x7B, 0xCC, 0x00, 0x00, 0x00, 0x3B, 0x9C, 0xC6, 0x60,
  0x01, 0x07, 0x1E, 0x78, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x1E, 0x07, 0x01,
  0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0xE1, 0xF8, 0x70, 0x70, 0x60, 0xC3, 0xBE,
  0x78, 0xC1, 0x80, 0x00, 0x1E, 0x18, 0x00, 0x1E, 0x0F, 0xE6, 0x1F, 0x03,
  0xC0, 0xF1, 0xDC, 0xF7, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCF, 0xF1,
  0xDC, 0x03, 0x00, 0x70, 0x0F, 0x80, 0xE0, 0x0C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0x67, 0xF9, 0x86, 0xE1, 0xF0,
  0x3C, 0x0C, 0xF8, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x3D, 0xFC, 0xC7,
  0x61, 0xF0, 0x78, 0x3C, 0x3F, 0xFB, 0xF8, 0x3C, 0x3F, 0x38, 0xD8, 0x6C,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x7C, 0x37, 0xF9, 0xF8,
  0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x3C,
  0x3F, 0x38, 0xD8, 0x6C, 0x0E, 0x03, 0x01, 0x9F, 0xCF, 0xE1, 0xF0, 0xF8,
  0x7C, 0x37, 0xF9, 0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x78, 0x3C,
  0x3B, 0xF8, 0xF8, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0xF1, 0xF8,
  0xCC, 0x67, 0x31, 0x98, 0xEC, 0x36, 0x1F, 0x06, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF,
  0xFE, 0xE1, 0xF8, 0x7F, 0x3F, 0xCF, 0xD2, 0xF7, 0xBD, 0xEF, 0x33, 0xCC,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xC3, 0xE3, 0xE3, 0xA3,
  0xF3, 0xF3, 0xD3, 0xDB, 0xDB, 0xCF, 0xCF, 0xCD, 0xC7, 0xC7, 0xC7, 0x3C,
  0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0x7E, 0xFC, 0x7F, 0xB1, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x61, 0x9F,
  0xE3, 0xF0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0xF8, 0x7F, 0xB1, 0xD8, 0x7C,
  0x1E, 0x0F, 0x0D, 0xFE, 0xFE, 0x66, 0x31, 0x98, 0xCC, 0x76, 0x1B, 0x0E,
  0x1E, 0x0F, 0xE7, 0x19, 0x86, 0x60, 0x58, 0x07, 0x80, 0xFC, 0x0F, 0x80,
  0x60, 0x1F, 0x03, 0xE1, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0x7E, 0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x61, 0x98,
  0x67, 0x18, 0xCC, 0x33, 0x0C, 0xC3, 0xB0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xC6, 0x34, 0x62, 0x66, 0x26, 0x66, 0x67, 0x66, 0xF6, 0x6F, 0x66, 0x96,
  0x69, 0x66, 0x96, 0x29, 0x42, 0x94, 0x29, 0x43, 0x9C, 0x39, 0xC0, 0xC0,
  0xD8, 0x66, 0x18, 0xCC, 0x33, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83,
  0x30, 0xCC, 0x61, 0x98, 0x6C, 0x0C, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x33,
  0x0C, 0xC3, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xFF, 0xFF, 0x03, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60,
  0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x1C, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0xFE, 0x0C, 0x03, 0x81, 0xE0, 0x48, 0x33, 0x0C, 0xC6,
  0x1B, 0x87, 0xFF, 0xFF, 0xF0, 0xE3, 0x8E, 0x3F, 0x3F, 0xD8, 0x60, 0x30,
  0x1B, 0xFF, 0x87, 0x83, 0xE1, 0xBB, 0xDF, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xDE, 0x7E,
  0x7F, 0xB0, 0xD8, 0x7C, 0x06, 0x03, 0x01, 0x87, 0xC3, 0x7F, 0x9F, 0x80,
  0x03, 0x03, 0x03, 0x03, 0x7B, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0x7B, 0x7E, 0xFF, 0xC3, 0xC3, 0xC3, 0xFF, 0xC0, 0xC0, 0xC3,
  0xFF, 0x7E, 0x03, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x3F, 0xFF, 0xFC, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7B, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x7E, 0x7C,
  0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x08, 0x0E, 0x07, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x06, 0x1C, 0x38,
  0x00, 0x1F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x3B, 0xF7, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3E, 0x1B, 0x1D, 0x9C,
  0xFC, 0x7E, 0x33, 0x18, 0xCC, 0x76, 0x1B, 0x0E, 0xF8, 0x3E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0xF0, 0x7C, 0xFB, 0xBB, 0x7C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF,
  0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0x7E, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0x7B, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x03, 0xDE, 0x7F, 0xB8,
  0xF8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x7E, 0x7F,
  0xB0, 0xD8, 0x0F, 0x03, 0xF8, 0x1C, 0x07, 0xC3, 0xFF, 0x9F, 0x80, 0x18,
  0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xF8, 0x7C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0x7E, 0xC0, 0xF8, 0x76, 0x19, 0x86, 0x73, 0x8C, 0xC3, 0x30, 0xEC,
  0x1E, 0x07, 0x81, 0xE0, 0x8C, 0x73, 0x3C, 0xCF, 0x33, 0xDE, 0xF4, 0xB5,
  0x29, 0x4A, 0x73, 0x9C, 0xE7, 0x38, 0xE1, 0xDC, 0xE3, 0x30, 0xFC, 0x1E,
  0x03, 0x01, 0xE0, 0xFC, 0x33, 0x18, 0x6E, 0x1C, 0xC0, 0xD8, 0x76, 0x19,
  0xC6, 0x33, 0x0C, 0xC3, 0xB0, 0x78, 0x1E, 0x03, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xE0,
  0xFF, 0xFF, 0x03, 0x0F, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0xF8,
  0xF8, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0xF0, 0x70, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x1F,
  0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xF0, 0xE0, 0x78, 0xFF, 0x3C,
  0xFF, 0x1E,
};

const GFXglyph JetBrainsMono_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 3, -15 },
  { 14, 10, 15, 12, 1, -15 },
  { 33, 10, 20, 12, 1, -17 },
  { 58, 12, 15, 12, 0, -15 },
  { 81, 10, 15, 12, 1, -15 },
  { 100, 2, 6, 12, 5, -15 },
  { 102, 6, 19, 12, 4, -17 },
  { 117, 6, 19, 12, 2, -17 },
  { 132, 10, 10, 12, 1, -12 },
  { 145, 10, 9, 12, 1, -11 },
  { 157, 5, 6, 12, 3, -3 },
  { 161, 6, 2, 12, 3, -8 },
  { 163, 4, 3, 12, 4, -3 },
  { 165, 10, 19, 12, 1, -17 },
  { 189, 10, 15, 12, 1, -15 },
  { 208, 9, 15, 12, 2, -15 },
  { 225, 10, 15, 12, 1, -15 },
  { 244, 9, 15, 12, 1, -15 },
  { 261, 9, 15, 12, 1, -15 },
  { 278, 8, 15, 12, 2, -15 },
  { 293, 10, 15, 12, 1, -15 },
  { 312, 10, 15, 12, 1, -15 },
  { 331, 10, 15, 12, 1, -15 },
  { 350, 10, 15, 12, 1, -15 },
  { 369, 4, 11, 12, 4, -11 },
  { 375, 5, 14, 12, 3, -11 },
  { 384, 8, 11, 12, 2, -12 },
  { 395, 8, 7, 12, 2, -10 },
  { 402, 8, 11, 12, 2, -12 },
  { 413, 7, 15, 12, 3, -15 },
  { 427, 10, 19, 12, 1, -15 },
  { 451, 10, 15, 12, 1, -15 },
  { 470, 9, 15, 12, 2, -15 },
  { 487, 9, 15, 12, 2, -15 },
  { 504, 8, 15, 12, 2, -15 },
  { 519, 8, 15, 12, 2, -15 },
  { 534, 9, 15, 12, 2, -15 },
  { 551, 9, 15, 12, 2, -15 },
  { 568, 8, 15, 12, 2, -15 },
  { 583, 8, 15, 12, 2, -15 },
  { 598, 9, 15, 12, 1, -15 },
  { 615, 9, 15, 12, 2, -15 },
  { 632, 9, 15, 12, 2, -15 },
  { 649, 10, 15, 12, 1, -15 },
  { 668, 8, 15, 12, 2, -15 },
  { 683, 8, 15, 12, 2, -15 },
  { 698, 9, 15, 12, 2, -15 },
  { 715, 10, 19, 12, 1, -15 },
  { 739, 9, 15, 12, 2, -15 },
  { 756, 10, 15, 12, 1, -15 },
  { 775, 10, 15, 12, 1, -15 },
  { 794, 8, 15, 12, 2, -15 },
  { 809, 10, 15, 12, 1, -15 },
  { 828, 12, 15, 12, 0, -15 },
  { 851, 10, 15, 12, 1, -15 },
  { 870, 10, 15, 12, 1, -15 },
  { 889, 8, 15, 12, 2, -15 },
  { 904, 5, 19, 12, 4, -17 },
  { 916, 10, 19, 12, 1, -17 },
  { 940, 5, 19, 12, 3, -17 },
  { 952, 10, 8, 12, 1, -15 },
  { 962, 10, 2, 12, 1, 0 },
  { 965, 5, 3, 12, 3, -16 },
  { 967, 9, 11, 12, 1, -11 },
  { 980, 8, 15, 12, 2, -15 },
  { 995, 9, 11, 12, 2, -11 },
  { 1008, 8, 15, 12, 2, -15 },
  { 1023, 8, 11, 12, 2, -11 },
  { 1034, 10, 15, 12, 1, -15 },
  { 1053, 8, 15, 12, 2, -11 },
  { 1068, 8, 15, 12, 2, -15 },
  { 1083, 9, 16, 12, 2, -16 },
  { 1101, 7, 20, 12, 2, -16 },
  { 1119, 9, 15, 12, 2, -15 },
  { 1136, 10, 15, 12, 1, -15 },
  { 1155, 10, 11, 12, 1, -11 },
  { 1169, 8, 11, 12, 2, -11 },
  { 1180, 8, 11, 12, 2, -11 },
  { 1191, 8, 15, 12, 2, -11 },
  { 1206, 8, 15, 12, 2, -11 },
  { 1221, 9, 11, 12, 2, -11 },
  { 1234, 9, 11, 12, 2, -11 },
  { 1247, 9, 14, 12, 1, -14 },
  { 1263, 8, 11, 12, 2, -11 },
  { 1274, 10, 11, 12, 1, -11 },
  { 1288, 10, 11, 12, 1, -11 },
  { 1302, 10, 11, 12, 1, -11 },
  { 1316, 10, 15, 12, 1, -11 },
  { 1335, 8, 11, 12, 2, -11 },
  { 1346, 8, 19, 12, 2, -17 },
  { 1365, 2, 19, 12, 5, -17 },
  { 1370, 8, 19, 12, 2, -17 },
  { 1389, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_Medium20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_MEDIUM20PT7B_H_
