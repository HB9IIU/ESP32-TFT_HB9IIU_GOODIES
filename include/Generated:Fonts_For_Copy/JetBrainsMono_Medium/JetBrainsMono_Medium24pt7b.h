#ifndef _JETBRAINSMONO_MEDIUM24PT7B_H_
#define _JETBRAINSMONO_MEDIUM24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x60, 0x07, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0x63, 0x63, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x30,
  0xC1, 0x86, 0x3F, 0xFD, 0xFF, 0xE3, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30,
  0x61, 0x8F, 0xFF, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x07, 0x07, 0xF8, 0xFF, 0xB9, 0x37, 0x27, 0xE4,
  0x1C, 0x81, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x81, 0x78, 0x27, 0xC4, 0xF8,
  0x9F, 0x97, 0x3F, 0xE3, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x18, 0x0D, 0xF0,
  0x3E, 0x61, 0xB1, 0x8C, 0xC6, 0x73, 0x19, 0x86, 0xEC, 0x1F, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x67, 0x01, 0xBF, 0x0D, 0x8C, 0x66, 0x31, 0x98, 0xCC,
  0x63, 0x60, 0xFF, 0x03, 0xE0, 0x0F, 0x01, 0xFC, 0x0E, 0xF0, 0xE1, 0x87,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x7C, 0x03, 0xF1, 0xF9, 0x9D, 0xCE,
  0xCE, 0x3E, 0x70, 0xE3, 0x87, 0x1C, 0x7C, 0x7F, 0x71, 0xF1, 0xC0, 0xFF,
  0xFF, 0x03, 0x0F, 0x1E, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x78, 0x3C, 0x1F, 0x0F, 0x03,
  0xC1, 0xC3, 0xE1, 0xC1, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x18, 0x71, 0xCF, 0x1C, 0x20, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x0E, 0x67, 0x7D, 0x7C, 0xFF, 0x80, 0xC0, 0x0D, 0x80,
  0xCE, 0x0E, 0x70, 0xE1, 0xC1, 0x04, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x3B, 0xDC, 0xE6, 0x73, 0x98, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xEC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xCE, 0xF9, 0xDF, 0x13, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x37, 0x0E, 0x7F, 0x87, 0xE0, 0x0E, 0x03, 0xC1, 0xF8, 0x7B,
  0x0C, 0x61, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0xF3, 0xFF,
  0x70, 0xEC, 0x0D, 0x81, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x7C, 0x1F, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xF0, 0x3C, 0x0F, 0x87, 0x7F, 0x8F, 0xC0, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0xF8, 0x3E, 0x0F, 0x03, 0xFF,
  0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xDF, 0xFB, 0xFF, 0x70,
  0x0E, 0x01, 0xC0, 0x39, 0x87, 0xFC, 0xFF, 0xDC, 0x38, 0x03, 0x00, 0x70,
  0x0E, 0x01, 0xF8, 0x37, 0x0E, 0x7F, 0x87, 0xE0, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0xB8, 0x7F, 0xE7, 0x8E, 0x70,
  0x76, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xEE, 0x0D, 0xC1, 0xB8, 0x73, 0x9C, 0x3F,
  0x07, 0xE1, 0xCF, 0x70, 0xEC, 0x0F, 0x81, 0xF0, 0x3F, 0x0E, 0x7F, 0xC7,
  0xE0, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x70, 0xF7, 0xFE, 0x3F, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0xFF, 0xF0, 0x7B,
  0xDE, 0x00, 0x00, 0x00, 0x01, 0xCE, 0xE7, 0x3B, 0x9C, 0xC0, 0x00, 0x40,
  0x70, 0x7C, 0xF8, 0xF8, 0x38, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x0C, 0x1F, 0x1F,
  0x1F, 0x0F, 0x03, 0x00, 0x80, 0x00, 0xE0, 0x7F, 0x3F, 0xC0, 0xF0, 0x38,
  0x1C, 0x0E, 0x07, 0x3F, 0x1F, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x78, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0x6E, 0x03, 0x60,
  0x1F, 0x06, 0xF8, 0xFB, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C, 0x63,
  0xE3, 0x1F, 0x18, 0xF8, 0xFB, 0xC1, 0x86, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1D, 0x81, 0xD8,
  0x19, 0x81, 0x9C, 0x39, 0xC3, 0x8C, 0x30, 0xC3, 0xFE, 0x7F, 0xE7, 0xFE,
  0x70, 0x66, 0x07, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x0F, 0xC1, 0xF8, 0x37, 0x0E, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0E, 0xFF, 0xDF, 0xE0, 0x1E, 0x0F, 0xF1, 0xFF, 0x70,
  0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC1, 0xF8, 0x37, 0x8E, 0x7F, 0xC7, 0xE0, 0xFC, 0x1F, 0xE3, 0xFF,
  0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0x1E, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E,
  0x0F, 0xF1, 0xFF, 0x70, 0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0xFF, 0x9F, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x8E, 0x7F, 0xC7, 0xE0,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0xFF,
  0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1,
  0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0xE0,
  0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE3, 0x0E, 0x70, 0xFE,
  0x0F, 0xF0, 0xE7, 0x0E, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF,
  0xF0, 0xE0, 0xFC, 0x3E, 0x87, 0xF8, 0xFF, 0x37, 0xE6, 0xF6, 0xDE, 0xD3,
  0xDE, 0xF9, 0xDF, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1C, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0x8F, 0x33,
  0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC6, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0,
  0x70, 0x1E, 0x1F, 0xE7, 0xFF, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC7, 0x7F, 0x8F, 0xC0,
  0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE1,
  0xFF, 0xFB, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xEC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x37, 0x8E, 0x7F,
  0x87, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xFC, 0x1F, 0xF3, 0xFF,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE3, 0xDF, 0xF3, 0xFC, 0x73,
  0x8E, 0x39, 0xC7, 0x38, 0x77, 0x0E, 0xE0, 0xFC, 0x1C, 0x1E, 0x0F, 0xF1,
  0xFF, 0x70, 0x6E, 0x0F, 0xC0, 0x38, 0x03, 0x80, 0x7F, 0x03, 0xF0, 0x1F,
  0x00, 0x70, 0x0F, 0x81, 0xF0, 0x3F, 0x0E, 0x7F, 0xC7, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC7, 0x7F, 0x8F, 0xC0,
  0xE0, 0x3E, 0x03, 0x60, 0x76, 0x07, 0x70, 0x67, 0x06, 0x30, 0xE3, 0x0E,
  0x38, 0xC3, 0x8C, 0x19, 0xC1, 0x9C, 0x1D, 0x81, 0xD8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0xE3, 0x0D, 0x8E, 0x36, 0x39, 0xD8, 0xE7, 0x63, 0x99,
  0x9A, 0x66, 0x69, 0x99, 0xA6, 0x76, 0x99, 0xD2, 0x63, 0x4D, 0x8D, 0x36,
  0x34, 0xF8, 0xF3, 0xC3, 0xC7, 0x0F, 0x1C, 0x3C, 0x70, 0xE1, 0xC0, 0xE0,
  0x73, 0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E,
  0x1C, 0x60, 0x77, 0x03, 0xC0, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xC3,
  0x0E, 0x1C, 0x60, 0x67, 0x03, 0xB0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xFF, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0xC0,
  0x78, 0x0D, 0x83, 0x30, 0x67, 0x1C, 0x63, 0x0E, 0xE0, 0xD8, 0x1C, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0x1F, 0xC7, 0xFD, 0xC3, 0x80, 0x30, 0x06,
  0x3F, 0xDF, 0xFB, 0x83, 0xE0, 0x7C, 0x0D, 0xC3, 0xBF, 0xF3, 0xF6, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0x0E, 0xE0, 0xDC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x8E, 0xFF, 0xDD, 0xF0,
  0x3F, 0x8F, 0xFB, 0x87, 0x70, 0x7C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x1F, 0xC7, 0x3F, 0xE3, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xDF, 0xB7, 0xFF, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x87, 0x7E, 0xCF, 0xB0, 0x3F, 0x8F, 0xFB, 0x87, 0x70, 0x6C, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x87, 0x3F, 0xE3, 0xF0, 0x00,
  0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x3E, 0xDF, 0xFE, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x77, 0xEC, 0xFB, 0x00, 0xC0, 0x30, 0x1C, 0xFF, 0x3F, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xEF, 0xFF, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0x04,
  0x01, 0xC0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0x03, 0xC0, 0xE0, 0x20, 0x00, 0x01, 0xFE, 0xFF, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x77, 0xFB, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x70, 0xFF, 0x0F, 0xE0, 0xE7, 0x0E,
  0x38, 0xE3, 0x8E, 0x1C, 0xE0, 0xEE, 0x0F, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xEF,
  0xF7, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E,
  0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x30, 0xFF, 0xBF, 0xFE, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xC0, 0x3F,
  0x8F, 0xFB, 0x87, 0x70, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1B, 0xC7, 0x3F, 0xC3, 0xF0, 0xEF, 0x9F, 0xFB, 0x87, 0x70, 0x6E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0xC7, 0x7F, 0xEE, 0xF9, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x7E, 0xDF, 0xFE, 0x1F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1D, 0xFB, 0x3E, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xEF, 0x9F, 0xFB, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0x8F, 0xFB,
  0x83, 0x70, 0x1E, 0x00, 0xFC, 0x0F, 0xF0, 0x1E, 0x00, 0xE0, 0x1F, 0x83,
  0xBF, 0xE3, 0xF8, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xFE, 0x07, 0xE0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x1D, 0xFE, 0x3F, 0x00, 0xE0, 0x76,
  0x07, 0x70, 0x67, 0x0E, 0x30, 0xE3, 0x8C, 0x38, 0xC1, 0x9C, 0x1D, 0x81,
  0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xC6, 0x3E, 0x39, 0xB1, 0xCD, 0x8E,
  0x6E, 0xD3, 0x36, 0x99, 0xB4, 0xCD, 0x26, 0x69, 0xE3, 0x4F, 0x1E, 0x78,
  0xF1, 0xC3, 0x8E, 0x00, 0xF0, 0x77, 0x0E, 0x39, 0xC1, 0xDC, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF8, 0x1D, 0x83, 0x9C, 0x38, 0xE7, 0x0E, 0xE0, 0x70,
  0xE0, 0x77, 0x07, 0x70, 0x63, 0x0E, 0x38, 0xE3, 0x8C, 0x19, 0xC1, 0xD8,
  0x0D, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xC1, 0xF0, 0x78, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xE3, 0xF0, 0xFE, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xC0, 0xF0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x3E, 0x07,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x07, 0x00, 0xFC, 0x1F,
  0x1F, 0xC7, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xF8, 0x3E,
  0x0C, 0x00, 0x3C, 0x37, 0xE3, 0xE7, 0x3E, 0x3F, 0xE1, 0xE0,
};

const GFXglyph JetBrainsMono_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 18, 14, 5, -18 },
  { 10, 8, 8, 14, 3, -18 },
  { 18, 13, 18, 14, 1, -18 },
  { 48, 11, 24, 14, 2, -21 },
  { 81, 14, 18, 14, 0, -18 },
  { 113, 13, 18, 14, 1, -18 },
  { 143, 2, 8, 14, 6, -18 },
  { 145, 8, 23, 14, 4, -20 },
  { 168, 7, 23, 14, 3, -20 },
  { 189, 13, 13, 14, 1, -15 },
  { 211, 12, 12, 14, 1, -14 },
  { 229, 5, 8, 14, 4, -4 },
  { 234, 8, 2, 14, 3, -9 },
  { 236, 4, 4, 14, 5, -4 },
  { 238, 11, 23, 14, 2, -20 },
  { 270, 11, 18, 14, 2, -18 },
  { 295, 11, 18, 14, 2, -18 },
  { 320, 11, 18, 14, 2, -18 },
  { 345, 10, 18, 14, 2, -18 },
  { 368, 10, 18, 14, 2, -18 },
  { 391, 11, 18, 14, 2, -18 },
  { 416, 12, 18, 14, 1, -18 },
  { 443, 11, 18, 14, 2, -18 },
  { 468, 11, 18, 14, 2, -18 },
  { 493, 12, 18, 14, 1, -18 },
  { 520, 4, 13, 14, 5, -13 },
  { 527, 5, 17, 14, 4, -13 },
  { 538, 10, 13, 14, 2, -14 },
  { 555, 10, 8, 14, 2, -12 },
  { 565, 10, 13, 14, 2, -14 },
  { 582, 9, 18, 14, 3, -18 },
  { 603, 13, 22, 14, 1, -18 },
  { 639, 12, 18, 14, 1, -18 },
  { 666, 11, 18, 14, 2, -18 },
  { 691, 11, 18, 14, 2, -18 },
  { 716, 11, 18, 14, 2, -18 },
  { 741, 11, 18, 14, 2, -18 },
  { 766, 11, 18, 14, 2, -18 },
  { 791, 11, 18, 14, 2, -18 },
  { 816, 10, 18, 14, 2, -18 },
  { 839, 10, 18, 14, 2, -18 },
  { 862, 11, 18, 14, 1, -18 },
  { 887, 12, 18, 14, 2, -18 },
  { 914, 10, 18, 14, 3, -18 },
  { 937, 11, 18, 14, 2, -18 },
  { 962, 10, 18, 14, 2, -18 },
  { 985, 10, 18, 14, 2, -18 },
  { 1008, 11, 18, 14, 2, -18 },
  { 1033, 11, 22, 14, 2, -18 },
  { 1064, 11, 18, 14, 2, -18 },
  { 1089, 11, 18, 14, 2, -18 },
  { 1114, 12, 18, 14, 1, -18 },
  { 1141, 10, 18, 14, 2, -18 },
  { 1164, 12, 18, 14, 1, -18 },
  { 1191, 14, 18, 14, 0, -18 },
  { 1223, 13, 18, 14, 1, -18 },
  { 1253, 13, 18, 14, 1, -18 },
  { 1283, 10, 18, 14, 2, -18 },
  { 1306, 6, 23, 14, 5, -20 },
  { 1324, 11, 23, 14, 2, -20 },
  { 1356, 7, 23, 14, 3, -20 },
  { 1377, 11, 10, 14, 2, -18 },
  { 1391, 12, 2, 14, 1, 1 },
  { 1394, 6, 4, 14, 4, -19 },
  { 1397, 11, 13, 14, 1, -13 },
  { 1415, 11, 18, 14, 2, -18 },
  { 1440, 11, 13, 14, 2, -13 },
  { 1458, 10, 18, 14, 2, -18 },
  { 1481, 11, 13, 14, 2, -13 },
  { 1499, 12, 18, 14, 1, -18 },
  { 1526, 10, 17, 14, 2, -13 },
  { 1548, 10, 18, 14, 2, -18 },
  { 1571, 11, 19, 14, 2, -19 },
  { 1598, 9, 23, 14, 2, -19 },
  { 1624, 12, 18, 14, 2, -18 },
  { 1651, 12, 18, 14, 1, -18 },
  { 1678, 12, 13, 14, 1, -13 },
  { 1698, 10, 13, 14, 2, -13 },
  { 1715, 11, 13, 14, 2, -13 },
  { 1733, 11, 17, 14, 2, -13 },
  { 1757, 10, 17, 14, 2, -13 },
  { 1779, 11, 13, 14, 2, -13 },
  { 1797, 11, 13, 14, 2, -13 },
  { 1815, 12, 17, 14, 1, -17 },
  { 1841, 10, 13, 14, 2, -13 },
  { 1858, 12, 13, 14, 1, -13 },
  { 1878, 13, 13, 14, 1, -13 },
  { 1900, 12, 13, 14, 1, -13 },
  { 1920, 12, 17, 14, 1, -13 },
  { 1946, 10, 13, 14, 2, -13 },
  { 1963, 10, 23, 14, 2, -20 },
  { 1992, 3, 23, 14, 6, -20 },
  { 2001, 10, 23, 14, 2, -20 },
  { 2030, 12, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_Medium24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_MEDIUM24PT7B_H_
