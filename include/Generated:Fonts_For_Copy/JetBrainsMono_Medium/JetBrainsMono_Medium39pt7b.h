#ifndef _JETBRAINSMONO_MEDIUM39PT7B_H_
#define _JETBRAINSMONO_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0xFB, 0xFF, 0xFE, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78,
  0x7B, 0x83, 0xDC, 0x1E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38,
  0x07, 0x83, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x33, 0xEF, 0x8C, 0x7B, 0xE3, 0x1E, 0xF0, 0xC7, 0xFC,
  0x30, 0x0F, 0x8C, 0x01, 0xE3, 0x00, 0x7E, 0xC0, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x0D, 0xF8, 0x03, 0x3E,
  0x00, 0xC7, 0xC0, 0x30, 0xFF, 0x0C, 0x3F, 0xC3, 0x0F, 0xF0, 0xC7, 0xFE,
  0x33, 0xE7, 0xEF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0x80, 0x3D, 0xFF, 0x80, 0x73, 0xCF, 0x01, 0xC7, 0x0F, 0x07,
  0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0xE0, 0x70, 0xF3, 0xC0,
  0xE1, 0xE7, 0x01, 0xE7, 0x9C, 0x01, 0xFF, 0x78, 0x01, 0xF8, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x71, 0xF0, 0x01,
  0xCF, 0xF0, 0x07, 0xBF, 0xF0, 0x0E, 0x78, 0xF0, 0x38, 0xE0, 0xE0, 0xF1,
  0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x07, 0x1E, 0x0E, 0x0E, 0x38, 0x1C,
  0x3C, 0xE0, 0x3F, 0xF3, 0x80, 0x3F, 0xEF, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x0F, 0xF1, 0xE1, 0xEF, 0x0F, 0x3E, 0xF0, 0xFB, 0xCF, 0x07, 0xFC,
  0xF0, 0x3F, 0x8F, 0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x3F,
  0x8F, 0xC7, 0xFC, 0x7F, 0xFB, 0xC3, 0xFF, 0x1E, 0x1F, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0x9C, 0x00, 0x10, 0x0F, 0x01, 0xF0, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x1F,
  0x00, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x87, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20, 0x38, 0x09, 0xE1, 0xC1, 0xCF,
  0xCE, 0x3F, 0xFF, 0x37, 0xFB, 0xFF, 0x7F, 0x83, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x0D, 0xC0, 0x00, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0x78, 0x3E, 0x07, 0xC0, 0xF0, 0x0C, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x10, 0xF9, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF1, 0xC7, 0xFC,
  0xF9, 0xFF, 0x3E, 0x7F, 0xCF, 0x9F, 0xF1, 0xC7, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E,
  0x78, 0x0F, 0x9F, 0x8F, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFC, 0xF0, 0x3E,
  0x3C, 0x0F, 0x0F, 0x03, 0x03, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0x7E, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xE0, 0xFD, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0x7E, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0xC0, 0x1F,
  0x7F, 0x03, 0xDF, 0xF8, 0xFF, 0xFF, 0x1F, 0x81, 0xF3, 0xE0, 0x1E, 0x78,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0,
  0x07, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xEF, 0x80, 0x7B, 0xC0,
  0x1E, 0xF8, 0x07, 0x9E, 0x03, 0xE7, 0xC0, 0xF0, 0xF8, 0x7C, 0x1F, 0x7E,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0x3E, 0x1F, 0x07, 0xCF,
  0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1E, 0xF8, 0x0F, 0x9F, 0x8F, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0,
  0xFC, 0xF8, 0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0x8F, 0xC3,
  0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0x80, 0xFD, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x1E, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x81, 0xFE, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xF0,
  0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3E, 0x7E, 0x0F, 0xF7, 0xE0, 0xFF, 0x7E,
  0x1F, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E, 0x0F,
  0xE1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE1, 0xE0,
  0xFE, 0x1F, 0x0F, 0xE0, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xBC, 0x00, 0x7B, 0xC0,
  0x07, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3E, 0x78, 0x01, 0xEF,
  0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF,
  0x00, 0x7B, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0xCF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x0F,
  0xEF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x1E,
  0x7C, 0x0F, 0x9F, 0xCF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xE0, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07,
  0xCF, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0x87, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0,
  0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x7C,
  0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x77, 0xFC, 0x1D, 0xFB, 0x87, 0x7E,
  0xE1, 0xDF, 0xB8, 0xEF, 0xEF, 0x3B, 0xF9, 0xCE, 0xFE, 0x77, 0x3F, 0x9D,
  0xCF, 0xE3, 0xF3, 0xF8, 0xF8, 0xFE, 0x3E, 0x3F, 0x87, 0x8F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xEE, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xE1,
  0xFE, 0x78, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x9F, 0xE1, 0xCF, 0xF0,
  0xE7, 0xF8, 0x7B, 0xFC, 0x1D, 0xFE, 0x0E, 0xFF, 0x07, 0xBF, 0x81, 0xDF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF3,
  0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0x7C, 0x0F, 0xBF, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x78, 0x0F,
  0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0xCF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF0, 0x3F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x9F, 0xCF, 0xE7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1E, 0xF8, 0x1F, 0x7F, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0,
  0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xEF, 0x0F, 0x83, 0xBC, 0x3E, 0x0E, 0xF0, 0xF8,
  0x7B, 0xC3, 0x61, 0xE7, 0x0D, 0xC7, 0x9C, 0x37, 0x1E, 0x70, 0xDC, 0x79,
  0xE3, 0x71, 0xC7, 0x8C, 0xC7, 0x1E, 0x73, 0x1C, 0x79, 0xCC, 0x71, 0xE7,
  0x31, 0xC7, 0x98, 0xCF, 0x0E, 0x63, 0xBC, 0x39, 0x8E, 0xF0, 0xE6, 0x3B,
  0xC3, 0x98, 0xEE, 0x0E, 0xE1, 0xB8, 0x3F, 0x86, 0xE0, 0xFE, 0x1B, 0x83,
  0xF0, 0x6E, 0x0F, 0xC1, 0xB8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0,
  0x7E, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF9,
  0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F,
  0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x03, 0xC3, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x0F, 0x78, 0x03, 0xCE,
  0x00, 0xE3, 0xC0, 0x78, 0x70, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E,
  0x07, 0xCF, 0x00, 0xF4, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFB, 0xC7, 0xFC, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xC1, 0xE7, 0xF8, 0xF7, 0xFF, 0x7B,
  0xFF, 0xBD, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF7, 0x3F, 0xFB, 0xFF, 0xBC,
  0xFF, 0x9E, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7C, 0x1F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x1E, 0xF8, 0x07, 0x9F, 0x03, 0xE7, 0xF3, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1E, 0x1E, 0x3F, 0xCF, 0x3F,
  0xF7, 0xBF, 0xFF, 0xDF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7E, 0x3F, 0xBF,
  0xFB, 0xCF, 0xFD, 0xE1, 0xFC, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xDF, 0x07, 0xE7, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x1F,
  0xBF, 0xFF, 0xCF, 0xFD, 0xE3, 0xFC, 0xF0, 0x30, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC3, 0xC1, 0xE7, 0xF8, 0xF7, 0xFF, 0x7B, 0xFF, 0xBD,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0x87, 0x1E, 0xF9, 0xFB, 0xFF, 0xFF, 0x7C, 0xF9, 0xFF, 0x0F,
  0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C,
  0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38,
  0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70,
  0xFF, 0x0E, 0x1F, 0xE1, 0xC3, 0xC0, 0x00, 0xF0, 0x79, 0xFE, 0x3D, 0xFF,
  0xDE, 0xFF, 0xEF, 0x41, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDF, 0xCF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDE, 0xFF,
  0xEF, 0x41, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFD, 0xCF, 0xFE, 0xFF, 0xEF, 0x3F,
  0xE7, 0x8F, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF3, 0xCF, 0xFD,
  0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x8F, 0xEF, 0xFE,
  0xF3, 0xFF, 0x78, 0x7F, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x79, 0xFE,
  0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xE7,
  0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F,
  0xBF, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0xF0, 0x01, 0xFF,
  0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x7C,
  0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00, 0x7B,
  0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xDC, 0x3E, 0x1E, 0xE1, 0xF0,
  0xF7, 0x0D, 0x87, 0xB8, 0x6C, 0x39, 0xE3, 0x71, 0xCF, 0x1B, 0x8E, 0x78,
  0xCC, 0x71, 0xCE, 0x67, 0x8E, 0x73, 0x3C, 0x73, 0x19, 0xC3, 0x98, 0xCE,
  0x1E, 0xC7, 0x70, 0xF6, 0x3B, 0x83, 0xF0, 0xDC, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0xFC, 0x03,
  0xE7, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF9,
  0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0x9E, 0x01,
  0xF1, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x7C, 0x07, 0xC7, 0x80, 0x3E,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x7B, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x00, 0x1F, 0x01, 0xE7, 0xF8, 0x3D, 0xFF, 0x87, 0xFD, 0xF0, 0xFF,
  0x0F, 0x1F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xFC, 0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 9, -28 },
  { 22, 13, 11, 23, 5, -28 },
  { 40, 21, 28, 23, 1, -28 },
  { 114, 18, 39, 23, 3, -34 },
  { 202, 23, 29, 23, 0, -29 },
  { 286, 20, 29, 23, 2, -29 },
  { 359, 5, 11, 23, 9, -28 },
  { 366, 12, 38, 23, 7, -33 },
  { 423, 13, 38, 23, 4, -33 },
  { 485, 21, 20, 23, 1, -24 },
  { 538, 19, 18, 23, 2, -22 },
  { 581, 9, 12, 23, 6, -6 },
  { 595, 13, 4, 23, 5, -15 },
  { 602, 7, 7, 23, 8, -7 },
  { 609, 18, 36, 23, 3, -32 },
  { 690, 18, 29, 23, 3, -29 },
  { 756, 18, 28, 23, 3, -28 },
  { 819, 18, 29, 23, 3, -29 },
  { 885, 17, 28, 23, 3, -28 },
  { 945, 17, 28, 23, 3, -28 },
  { 1005, 17, 28, 23, 3, -28 },
  { 1065, 19, 28, 23, 2, -28 },
  { 1132, 18, 28, 23, 3, -28 },
  { 1195, 18, 29, 23, 3, -29 },
  { 1261, 19, 29, 23, 2, -29 },
  { 1330, 7, 22, 23, 8, -22 },
  { 1350, 9, 28, 23, 6, -22 },
  { 1382, 17, 21, 23, 3, -23 },
  { 1427, 17, 14, 23, 3, -20 },
  { 1457, 17, 21, 23, 3, -23 },
  { 1502, 14, 28, 23, 5, -28 },
  { 1551, 20, 36, 23, 2, -29 },
  { 1641, 20, 28, 23, 2, -28 },
  { 1711, 18, 28, 23, 3, -28 },
  { 1774, 18, 29, 23, 3, -29 },
  { 1840, 17, 28, 23, 3, -28 },
  { 1900, 16, 28, 23, 4, -28 },
  { 1956, 18, 29, 23, 3, -29 },
  { 2022, 18, 29, 23, 3, -29 },
  { 2088, 17, 28, 23, 3, -28 },
  { 2148, 16, 28, 23, 4, -28 },
  { 2204, 19, 28, 23, 1, -28 },
  { 2271, 19, 28, 23, 3, -28 },
  { 2338, 17, 28, 23, 4, -28 },
  { 2398, 18, 28, 23, 3, -28 },
  { 2461, 17, 28, 23, 3, -28 },
  { 2521, 17, 29, 23, 3, -29 },
  { 2583, 19, 28, 23, 3, -28 },
  { 2650, 18, 36, 23, 3, -29 },
  { 2731, 18, 28, 23, 3, -28 },
  { 2794, 18, 29, 23, 3, -29 },
  { 2860, 19, 29, 23, 2, -29 },
  { 2929, 17, 28, 23, 3, -28 },
  { 2989, 20, 28, 23, 2, -28 },
  { 3059, 22, 28, 23, 1, -28 },
  { 3136, 21, 28, 23, 1, -28 },
  { 3210, 21, 28, 23, 1, -28 },
  { 3284, 17, 28, 23, 3, -28 },
  { 3344, 10, 36, 23, 8, -32 },
  { 3389, 18, 36, 23, 3, -32 },
  { 3470, 10, 36, 23, 6, -32 },
  { 3515, 18, 15, 23, 3, -28 },
  { 3549, 19, 4, 23, 2, 1 },
  { 3559, 9, 6, 23, 7, -31 },
  { 3566, 18, 22, 23, 2, -22 },
  { 3616, 17, 28, 23, 3, -28 },
  { 3676, 18, 22, 23, 3, -22 },
  { 3726, 17, 28, 23, 3, -28 },
  { 3786, 17, 22, 23, 3, -22 },
  { 3833, 19, 28, 23, 2, -28 },
  { 3900, 17, 29, 23, 3, -22 },
  { 3962, 17, 28, 23, 3, -28 },
  { 4022, 19, 31, 23, 3, -31 },
  { 4096, 15, 38, 23, 3, -31 },
  { 4168, 19, 28, 23, 3, -28 },
  { 4235, 21, 28, 23, 1, -28 },
  { 4309, 19, 22, 23, 2, -22 },
  { 4362, 17, 22, 23, 3, -22 },
  { 4409, 17, 22, 23, 3, -22 },
  { 4456, 17, 29, 23, 3, -22 },
  { 4518, 17, 29, 23, 3, -22 },
  { 4580, 17, 22, 23, 4, -22 },
  { 4627, 18, 22, 23, 3, -22 },
  { 4677, 18, 28, 23, 2, -28 },
  { 4740, 17, 21, 23, 3, -21 },
  { 4785, 20, 21, 23, 2, -21 },
  { 4838, 21, 21, 23, 1, -21 },
  { 4894, 20, 21, 23, 2, -21 },
  { 4947, 20, 28, 23, 2, -21 },
  { 5017, 17, 21, 23, 3, -21 },
  { 5062, 17, 36, 23, 3, -32 },
  { 5139, 4, 36, 23, 10, -32 },
  { 5157, 17, 36, 23, 3, -32 },
  { 5234, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_Medium39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_MEDIUM39PT7B_H_
