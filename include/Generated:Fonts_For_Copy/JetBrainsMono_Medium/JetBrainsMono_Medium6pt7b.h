#ifndef _JETBRAINSMONO_MEDIUM6PT7B_H_
#define _JETBRAINSMONO_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0xEF, 0xD0, 0x55, 0x1E, 0x80, 0xFA, 0x5A, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0x95, 0xA0, 0x55, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xB0, 0x97, 0xE5, 0x30, 0x6C, 0xF0, 0x6F, 0x90, 0xEC,
  0xF0, 0x6E, 0xB0, 0xE5, 0x20, 0xEE, 0xB0, 0xF5, 0xA0, 0xA0, 0xB0, 0x2B,
  0x10, 0xFC, 0x8D, 0xC0, 0xDA, 0xFF, 0xD4, 0x4D, 0xD0, 0xFF, 0xF2, 0x30,
  0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xB0, 0xFF, 0xEB, 0x64, 0xF0, 0xBA, 0xD0,
  0xAB, 0xBE, 0xD0, 0xFE, 0xD0, 0xF6, 0xB0, 0xFE, 0x40, 0xF6, 0xB2, 0xFE,
  0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xB0, 0xAD, 0xA0, 0xFF, 0xD0, 0xE9,
  0xD0, 0xAD, 0x20, 0x69, 0x70, 0xEA, 0xB0, 0x89, 0x12, 0x40, 0xFC, 0x74,
  0xE0, 0x80, 0xEF, 0x80, 0x9E, 0xF0, 0xF1, 0x80, 0x76, 0xB0, 0xFD, 0x80,
  0x7D, 0x20, 0xF5, 0xB0, 0x9E, 0xD0, 0x41, 0x2E, 0x21, 0x93, 0xC0, 0xBB,
  0xC9, 0x30, 0xFF, 0x80, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF5, 0x90,
  0xE8, 0xEF, 0x80, 0xE9, 0x30, 0xB5, 0x80, 0xAD, 0x00, 0xFE, 0x80, 0xEA,
  0x80, 0xAD, 0x20, 0x6B, 0x80, 0x27, 0x14, 0x40, 0xFC, 0xC9, 0xA5, 0x00,
  0x74,
};

const GFXglyph JetBrainsMono_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 1, -5 },
  { 17, 3, 3, 4, 0, -4 },
  { 19, 3, 2, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 6, 4, 0, -5 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 1, 3, 4, 1, -3 },
  { 46, 1, 4, 4, 1, -3 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 3, 4, 4, 0, -4 },
  { 95, 3, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 0, -4 },
  { 99, 3, 4, 4, 0, -4 },
  { 101, 2, 6, 4, 1, -5 },
  { 103, 3, 6, 4, 0, -5 },
  { 106, 1, 6, 4, 1, -5 },
  { 107, 3, 2, 4, 0, -4 },
  { 108, 3, 1, 4, 0, 0 },
  { 109, 1, 1, 4, 1, -5 },
  { 110, 3, 3, 4, 0, -3 },
  { 112, 3, 4, 4, 0, -4 },
  { 114, 3, 3, 4, 0, -3 },
  { 116, 3, 4, 4, 0, -4 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 3, 4, 4, 0, -4 },
  { 122, 3, 4, 4, 0, -3 },
  { 124, 3, 4, 4, 0, -4 },
  { 126, 3, 5, 4, 0, -5 },
  { 128, 3, 6, 4, 0, -5 },
  { 131, 2, 4, 4, 1, -4 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 3, 3, 4, 0, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 4, 4, 0, -3 },
  { 142, 3, 4, 4, 0, -3 },
  { 144, 2, 3, 4, 1, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -4 },
  { 149, 3, 3, 4, 0, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 3, 4, 4, 0, -3 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 3, 6, 4, 0, -5 },
  { 164, 1, 6, 4, 1, -5 },
  { 165, 3, 6, 4, 0, -5 },
  { 168, 3, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Medium6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_MEDIUM6PT7B_H_
