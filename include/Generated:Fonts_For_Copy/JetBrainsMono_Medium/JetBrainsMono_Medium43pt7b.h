#ifndef _JETBRAINSMONO_MEDIUM43PT7B_H_
#define _JETBRAINSMONO_MEDIUM43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xBC, 0x1E, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x81,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x78,
  0x1E, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF6, 0xFE, 0x7C,
  0x63, 0xE7, 0xC6, 0x3E, 0x78, 0x61, 0xF7, 0x86, 0x1F, 0x78, 0x60, 0x07,
  0xC6, 0x00, 0x7C, 0x60, 0x07, 0xE6, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x67,
  0xE0, 0x06, 0x3F, 0x00, 0x61, 0xF0, 0x06, 0x1F, 0x00, 0x61, 0xFF, 0x06,
  0x1F, 0xF8, 0x61, 0xFF, 0x86, 0x1F, 0x7E, 0x67, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x47, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x71, 0xFF, 0xC0, 0x3C, 0x78,
  0x78, 0x1E, 0x1C, 0x1E, 0x07, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xE1, 0xE0,
  0x70, 0x78, 0x70, 0x1C, 0x1E, 0x38, 0x07, 0x07, 0x9E, 0x01, 0xF3, 0xCF,
  0x00, 0x3F, 0xF3, 0x80, 0x07, 0xF9, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x8F, 0xC0,
  0x01, 0xC7, 0xFC, 0x00, 0xF3, 0xFF, 0x00, 0x79, 0xE1, 0xE0, 0x1C, 0x78,
  0x38, 0x0F, 0x1C, 0x0E, 0x07, 0x87, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xF0,
  0x70, 0x38, 0x78, 0x1E, 0x0E, 0x1C, 0x07, 0x87, 0x8F, 0x00, 0xFF, 0xC7,
  0x80, 0x3F, 0xF3, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xE0, 0xFB, 0xE3, 0xE1,
  0xE7, 0xC3, 0xE7, 0xCF, 0x87, 0xCF, 0x1F, 0x07, 0xFE, 0x3E, 0x07, 0xF8,
  0x7C, 0x07, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x87,
  0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x0F, 0xFF, 0x1E, 0x07,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0x80, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x83,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x18, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xF8, 0x7F, 0x83, 0xF0, 0x1E, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x0F, 0x07, 0x3F, 0x1C, 0x3F,
  0x7F, 0x99, 0xFF, 0xFF, 0xB7, 0xFC, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0, 0x03,
  0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x70,
  0x0E, 0x00, 0x40, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3,
  0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xC0, 0x3E, 0x78,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x84, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F,
  0xF9, 0xF9, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xEF, 0x81, 0xF9, 0xF0, 0x3C, 0x3E, 0x07, 0x07, 0xC0, 0xC0,
  0xF8, 0x10, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0xC0, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xE0, 0x3E, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF0, 0x3F, 0x7C, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0xFF, 0x07, 0xDF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFE,
  0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xC0, 0x7E, 0x7C,
  0x03, 0xE7, 0x80, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF,
  0xBE, 0x1F, 0xFF, 0xC0, 0x7E, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E,
  0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x3E, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xCF, 0xF0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F, 0x07, 0x87, 0xFC, 0x3C,
  0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F,
  0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC3, 0xE0, 0xFF, 0x07, 0xCF, 0xFC, 0x1F, 0xF7, 0xF0, 0x3F,
  0x9F, 0xC0, 0x18, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78,
  0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF0, 0x7C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00,
  0x7C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x3E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x00, 0xFD, 0xE0, 0x0F, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x9E, 0x01, 0xFB, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x01, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x01, 0xFB, 0xC0, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x3E,
  0xF0, 0x07, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0x00, 0xF8, 0xF0, 0x1F,
  0x8F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0x07,
  0xC0, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xFC,
  0xF0, 0x07, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x77, 0xEE, 0x07, 0x7E,
  0xE0, 0xFF, 0xEF, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x79, 0xEF,
  0xF3, 0x9C, 0xFF, 0x39, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8,
  0xFF, 0x1F, 0x8F, 0xF1, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xEE, 0x03, 0xFD, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFB, 0x81, 0xFF, 0x78, 0x3F, 0xEF, 0x07, 0xFC, 0xE0, 0xFF, 0x9E, 0x1F,
  0xF3, 0xC3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x0F, 0x3F,
  0xE1, 0xE7, 0xFC, 0x3C, 0xFF, 0x83, 0xDF, 0xF0, 0x7B, 0xFE, 0x0F, 0x7F,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF9, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBF,
  0x03, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x07, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x7C, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00, 0x7E,
  0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xEF, 0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x0F, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xE0,
  0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03,
  0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x7E, 0x1E, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x6E, 0x1E, 0x78, 0x66, 0x1E, 0x78,
  0x66, 0x1E, 0x78, 0xE6, 0x1E, 0x78, 0xE7, 0x1C, 0x78, 0xE7, 0x1C, 0x38,
  0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xC7, 0x3C, 0x3C, 0xC7, 0x3C, 0x3C,
  0xC3, 0x3C, 0x3D, 0xC3, 0x3C, 0x3D, 0xC3, 0x3C, 0x3D, 0xC3, 0xB8, 0x3D,
  0xC3, 0xB8, 0x3D, 0xC3, 0xB8, 0x1D, 0xC3, 0xF8, 0x1D, 0x83, 0xF8, 0x1D,
  0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xCF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01,
  0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xBC, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0x07,
  0x83, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0x7E, 0xF8, 0x07, 0xDE, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xE1, 0xFE, 0xFF, 0xFB, 0xCF,
  0xFE, 0x78, 0xFF, 0x8F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xF0, 0xF3, 0xFE,
  0x3D, 0xFF, 0xCF, 0x7F, 0xFB, 0xF8, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x3F, 0x0F, 0x1F, 0xF9, 0xE7,
  0xFF, 0xBC, 0xFF, 0xF7, 0xBF, 0x06, 0xF7, 0xC0, 0x7E, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0xBF, 0xFE, 0xF3, 0xFF, 0xDE, 0x3F,
  0xF3, 0xC3, 0xFC, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE7, 0xE0, 0x7C, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x07, 0xBE, 0x01, 0xF3, 0xF9, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0xFE, 0xF7, 0xE0, 0xDE, 0xF8,
  0x0F, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0,
  0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD, 0xFF, 0xF7, 0x9F, 0xFE, 0xF1, 0xFF,
  0x9E, 0x1F, 0xE3, 0xC0, 0x20, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0xF0, 0xF3, 0xFE, 0x3D,
  0xFF, 0xCF, 0x7F, 0xFB, 0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3C, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xF0, 0x07, 0xCF, 0x00,
  0xF8, 0xF0, 0x1F, 0x8F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xE0, 0xF0,
  0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF8,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x01,
  0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xE7, 0xC7, 0xCE, 0xFE, 0xFE,
  0xEF, 0xEF, 0xFF, 0x9F, 0x9F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xFC, 0x3C, 0xFF, 0x8F,
  0x7F, 0xF3, 0xDF, 0xFE, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0,
  0xFC, 0xF8, 0x07, 0xDE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x03,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0xF0, 0xFC,
  0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xBD, 0xFF, 0xEF,
  0x3F, 0xF3, 0xC7, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE1,
  0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0xFE, 0xF7, 0xE0, 0xDE, 0xF8, 0x0F,
  0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xF7, 0xFF, 0xDE,
  0x7F, 0xFB, 0xC7, 0xFE, 0x78, 0x7F, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xF8, 0xFE, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x03, 0xE7,
  0xC0, 0x1E, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0E,
  0x70, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x6E, 0x1C, 0x78, 0x66, 0x1C, 0x38, 0x66, 0x3C,
  0x3C, 0xE6, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xC7, 0x3C,
  0x3C, 0xC7, 0x38, 0x1C, 0xC3, 0x38, 0x1D, 0xC3, 0x78, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE3,
  0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0x80,
  0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xDF, 0xF8, 0x1E, 0xFF, 0xE0, 0xF7,
  0x8F, 0x87, 0xFC, 0x3E, 0x7F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0xF8, 0x0F,
  0xE0, 0x00, 0x08, 0x00,
};

const GFXglyph JetBrainsMono_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 9, -31 },
  { 29, 14, 13, 26, 6, -31 },
  { 52, 23, 31, 26, 1, -31 },
  { 142, 20, 43, 26, 3, -37 },
  { 250, 26, 32, 26, 0, -32 },
  { 354, 23, 32, 26, 2, -32 },
  { 446, 5, 13, 26, 10, -31 },
  { 455, 13, 41, 26, 8, -36 },
  { 522, 13, 41, 26, 5, -36 },
  { 589, 23, 22, 26, 1, -26 },
  { 653, 20, 20, 26, 3, -24 },
  { 703, 9, 14, 26, 7, -7 },
  { 719, 14, 4, 26, 6, -16 },
  { 726, 8, 7, 26, 9, -7 },
  { 733, 20, 41, 26, 3, -36 },
  { 836, 20, 32, 26, 3, -32 },
  { 916, 19, 31, 26, 4, -31 },
  { 990, 20, 32, 26, 3, -32 },
  { 1070, 19, 31, 26, 3, -31 },
  { 1144, 19, 31, 26, 3, -31 },
  { 1218, 19, 31, 26, 3, -31 },
  { 1292, 20, 31, 26, 3, -31 },
  { 1370, 20, 31, 26, 3, -31 },
  { 1448, 20, 32, 26, 3, -32 },
  { 1528, 20, 32, 26, 3, -32 },
  { 1608, 8, 24, 26, 9, -24 },
  { 1632, 10, 31, 26, 7, -24 },
  { 1671, 19, 23, 26, 3, -26 },
  { 1726, 18, 15, 26, 4, -22 },
  { 1760, 19, 23, 26, 3, -26 },
  { 1815, 16, 31, 26, 5, -31 },
  { 1877, 22, 40, 26, 2, -32 },
  { 1987, 22, 31, 26, 2, -31 },
  { 2073, 19, 31, 26, 4, -31 },
  { 2147, 20, 32, 26, 3, -32 },
  { 2227, 19, 31, 26, 4, -31 },
  { 2301, 18, 31, 26, 4, -31 },
  { 2371, 19, 31, 26, 4, -31 },
  { 2445, 20, 32, 26, 3, -32 },
  { 2525, 18, 31, 26, 4, -31 },
  { 2595, 18, 31, 26, 4, -31 },
  { 2665, 20, 31, 26, 2, -31 },
  { 2743, 20, 31, 26, 4, -31 },
  { 2821, 18, 31, 26, 5, -31 },
  { 2891, 20, 31, 26, 3, -31 },
  { 2969, 19, 31, 26, 3, -31 },
  { 3043, 19, 32, 26, 3, -32 },
  { 3119, 20, 31, 26, 4, -31 },
  { 3197, 20, 40, 26, 3, -32 },
  { 3297, 20, 31, 26, 4, -31 },
  { 3375, 20, 32, 26, 3, -32 },
  { 3455, 22, 31, 26, 2, -31 },
  { 3541, 19, 31, 26, 3, -31 },
  { 3615, 22, 31, 26, 2, -31 },
  { 3701, 24, 31, 26, 1, -31 },
  { 3794, 23, 31, 26, 1, -31 },
  { 3884, 24, 31, 26, 1, -31 },
  { 3977, 18, 31, 26, 4, -31 },
  { 4047, 12, 41, 26, 8, -36 },
  { 4109, 20, 41, 26, 3, -36 },
  { 4212, 11, 41, 26, 6, -36 },
  { 4269, 20, 16, 26, 3, -31 },
  { 4309, 20, 4, 26, 3, 1 },
  { 4319, 10, 6, 26, 7, -34 },
  { 4327, 19, 24, 26, 3, -24 },
  { 4384, 18, 31, 26, 4, -31 },
  { 4454, 20, 24, 26, 3, -24 },
  { 4514, 19, 31, 26, 3, -31 },
  { 4588, 19, 24, 26, 3, -24 },
  { 4645, 21, 31, 26, 2, -31 },
  { 4727, 19, 32, 26, 3, -24 },
  { 4803, 18, 31, 26, 4, -31 },
  { 4873, 21, 34, 26, 3, -34 },
  { 4963, 16, 42, 26, 4, -34 },
  { 5047, 20, 31, 26, 4, -31 },
  { 5125, 23, 31, 26, 1, -31 },
  { 5215, 20, 24, 26, 3, -24 },
  { 5275, 18, 24, 26, 4, -24 },
  { 5329, 19, 24, 26, 3, -24 },
  { 5386, 18, 32, 26, 4, -24 },
  { 5458, 19, 32, 26, 3, -24 },
  { 5534, 19, 24, 26, 4, -24 },
  { 5591, 20, 24, 26, 3, -24 },
  { 5651, 21, 30, 26, 2, -30 },
  { 5730, 18, 24, 26, 4, -24 },
  { 5784, 22, 24, 26, 2, -24 },
  { 5850, 24, 24, 26, 1, -24 },
  { 5922, 22, 24, 26, 2, -24 },
  { 5988, 22, 32, 26, 2, -24 },
  { 6076, 18, 24, 26, 4, -24 },
  { 6130, 18, 41, 26, 4, -36 },
  { 6223, 4, 41, 26, 11, -36 },
  { 6244, 18, 41, 26, 4, -36 },
  { 6337, 21, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_Medium43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_MEDIUM43PT7B_H_
