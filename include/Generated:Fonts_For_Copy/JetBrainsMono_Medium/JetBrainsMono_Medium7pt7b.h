#ifndef _JETBRAINSMONO_MEDIUM7PT7B_H_
#define _JETBRAINSMONO_MEDIUM7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0xA0, 0x27, 0xA6, 0xB6, 0x20, 0xDE, 0x27,
  0xB0, 0x64, 0xDA, 0xF0, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x2F, 0x60, 0x2F,
  0x20, 0xE0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x80, 0xD7, 0xDC, 0xD9, 0x2E,
  0x69, 0x24, 0x70, 0x62, 0x69, 0x60, 0x52, 0xF2, 0xD3, 0x9C, 0x24, 0x79,
  0x60, 0xF1, 0x22, 0x40, 0x65, 0x69, 0x60, 0x69, 0x72, 0x40, 0xC3, 0xC1,
  0x80, 0x73, 0x10, 0xE3, 0x80, 0x8F, 0x40, 0xDE, 0x80, 0x7B, 0xDD, 0xB6,
  0x66, 0x67, 0x90, 0xD7, 0x5C, 0xF2, 0x5C, 0xD6, 0xDC, 0xF3, 0x4E, 0xF3,
  0xC8, 0xF3, 0xDC, 0xB7, 0xDA, 0xE9, 0x2E, 0x31, 0x19, 0x60, 0xBB, 0x6A,
  0x92, 0x4E, 0xDF, 0xB9, 0x90, 0xB6, 0xFA, 0xD6, 0xDC, 0xF7, 0x48, 0xD6,
  0xDC, 0xC0, 0xF7, 0x6A, 0x78, 0x69, 0x60, 0xF2, 0x22, 0x20, 0xB6, 0xDC,
  0x95, 0x66, 0x60, 0xBB, 0xF7, 0x50, 0xD6, 0x26, 0x90, 0x96, 0x62, 0x20,
  0xE9, 0x4E, 0xEA, 0xAC, 0x84, 0x42, 0x22, 0x10, 0xD5, 0x5C, 0xDA, 0x80,
  0xF0, 0xC0, 0x63, 0xD7, 0x9A, 0xDC, 0xD6, 0x70, 0x3E, 0xDE, 0xD7, 0x70,
  0x3F, 0x44, 0x40, 0xF6, 0xFE, 0x9A, 0xDA, 0x59, 0x2E, 0x75, 0x70, 0x97,
  0x6A, 0xC4, 0x44, 0x30, 0xFB, 0xBB, 0xD6, 0xD0, 0xD6, 0xE0, 0xD6, 0xE8,
  0xF6, 0xF2, 0xD6, 0x40, 0xF1, 0xF0, 0x4F, 0x44, 0x30, 0xB6, 0xE0, 0x95,
  0x66, 0xBB, 0x76, 0xD6, 0x6D, 0x96, 0x62, 0x40, 0xEA, 0x70, 0x69, 0x44,
  0x98, 0xFE, 0x92, 0x39, 0x20, 0xF0,
};

const GFXglyph JetBrainsMono_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 4, 7, 4, 0, -6 },
  { 32, 3, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 1, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 1, -5 },
  { 44, 3, 5, 4, 1, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 5, 4, 1, -4 },
  { 61, 3, 4, 4, 1, -4 },
  { 63, 3, 3, 4, 1, -4 },
  { 65, 3, 4, 4, 1, -4 },
  { 67, 2, 5, 4, 1, -5 },
  { 69, 4, 6, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 3, 5, 4, 1, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 3, 5, 4, 1, -5 },
  { 107, 3, 6, 4, 1, -5 },
  { 110, 3, 5, 4, 1, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 4, 1, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 2, 7, 4, 1, -6 },
  { 136, 4, 7, 4, 0, -6 },
  { 140, 2, 7, 4, 1, -6 },
  { 142, 3, 3, 4, 1, -5 },
  { 144, 4, 1, 4, 0, 0 },
  { 145, 2, 1, 4, 1, -6 },
  { 146, 4, 4, 4, 0, -4 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 3, 4, 4, 1, -4 },
  { 152, 3, 5, 4, 1, -5 },
  { 154, 3, 4, 4, 1, -4 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 3, 5, 4, 1, -4 },
  { 161, 3, 5, 4, 1, -5 },
  { 163, 3, 5, 4, 1, -5 },
  { 165, 2, 6, 4, 1, -5 },
  { 167, 3, 5, 4, 1, -5 },
  { 169, 4, 5, 4, 0, -5 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 3, 4, 4, 1, -4 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 3, 5, 4, 1, -4 },
  { 180, 3, 5, 4, 1, -4 },
  { 182, 3, 4, 4, 1, -4 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 4, 5, 4, 0, -5 },
  { 189, 3, 4, 4, 1, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 5, 4, 0, -4 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 3, 7, 4, 1, -6 },
  { 205, 1, 7, 4, 2, -6 },
  { 206, 3, 7, 4, 1, -6 },
  { 209, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Medium7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_MEDIUM7PT7B_H_
