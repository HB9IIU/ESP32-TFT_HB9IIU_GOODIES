#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &JetBrainsMono_Medium6pt7b, 6, "JetBrainsMono_Medium6pt7b" },
  { &JetBrainsMono_Medium7pt7b, 7, "JetBrainsMono_Medium7pt7b" },
  { &JetBrainsMono_Medium8pt7b, 8, "JetBrainsMono_Medium8pt7b" },
  { &JetBrainsMono_Medium9pt7b, 9, "JetBrainsMono_Medium9pt7b" },
  { &JetBrainsMono_Medium10pt7b, 10, "JetBrainsMono_Medium10pt7b" },
  { &JetBrainsMono_Medium11pt7b, 11, "JetBrainsMono_Medium11pt7b" },
  { &JetBrainsMono_Medium12pt7b, 12, "JetBrainsMono_Medium12pt7b" },
  { &JetBrainsMono_Medium13pt7b, 13, "JetBrainsMono_Medium13pt7b" },
  { &JetBrainsMono_Medium14pt7b, 14, "JetBrainsMono_Medium14pt7b" },
  { &JetBrainsMono_Medium15pt7b, 15, "JetBrainsMono_Medium15pt7b" },
  { &JetBrainsMono_Medium16pt7b, 16, "JetBrainsMono_Medium16pt7b" },
  { &JetBrainsMono_Medium17pt7b, 17, "JetBrainsMono_Medium17pt7b" },
  { &JetBrainsMono_Medium18pt7b, 18, "JetBrainsMono_Medium18pt7b" },
  { &JetBrainsMono_Medium19pt7b, 19, "JetBrainsMono_Medium19pt7b" },
  { &JetBrainsMono_Medium20pt7b, 20, "JetBrainsMono_Medium20pt7b" },
  { &JetBrainsMono_Medium21pt7b, 21, "JetBrainsMono_Medium21pt7b" },
  { &JetBrainsMono_Medium22pt7b, 22, "JetBrainsMono_Medium22pt7b" },
  { &JetBrainsMono_Medium23pt7b, 23, "JetBrainsMono_Medium23pt7b" },
  { &JetBrainsMono_Medium24pt7b, 24, "JetBrainsMono_Medium24pt7b" },
  { &JetBrainsMono_Medium25pt7b, 25, "JetBrainsMono_Medium25pt7b" },
  { &JetBrainsMono_Medium26pt7b, 26, "JetBrainsMono_Medium26pt7b" },
  { &JetBrainsMono_Medium27pt7b, 27, "JetBrainsMono_Medium27pt7b" },
  { &JetBrainsMono_Medium28pt7b, 28, "JetBrainsMono_Medium28pt7b" },
  { &JetBrainsMono_Medium29pt7b, 29, "JetBrainsMono_Medium29pt7b" },
  { &JetBrainsMono_Medium30pt7b, 30, "JetBrainsMono_Medium30pt7b" },
  { &JetBrainsMono_Medium31pt7b, 31, "JetBrainsMono_Medium31pt7b" },
  { &JetBrainsMono_Medium32pt7b, 32, "JetBrainsMono_Medium32pt7b" },
  { &JetBrainsMono_Medium33pt7b, 33, "JetBrainsMono_Medium33pt7b" },
  { &JetBrainsMono_Medium34pt7b, 34, "JetBrainsMono_Medium34pt7b" },
  { &JetBrainsMono_Medium35pt7b, 35, "JetBrainsMono_Medium35pt7b" },
  { &JetBrainsMono_Medium36pt7b, 36, "JetBrainsMono_Medium36pt7b" },
  { &JetBrainsMono_Medium37pt7b, 37, "JetBrainsMono_Medium37pt7b" },
  { &JetBrainsMono_Medium38pt7b, 38, "JetBrainsMono_Medium38pt7b" },
  { &JetBrainsMono_Medium39pt7b, 39, "JetBrainsMono_Medium39pt7b" },
  { &JetBrainsMono_Medium40pt7b, 40, "JetBrainsMono_Medium40pt7b" },
  { &JetBrainsMono_Medium41pt7b, 41, "JetBrainsMono_Medium41pt7b" },
  { &JetBrainsMono_Medium42pt7b, 42, "JetBrainsMono_Medium42pt7b" },
  { &JetBrainsMono_Medium43pt7b, 43, "JetBrainsMono_Medium43pt7b" },
  { &JetBrainsMono_Medium44pt7b, 44, "JetBrainsMono_Medium44pt7b" },
  { &JetBrainsMono_Medium45pt7b, 45, "JetBrainsMono_Medium45pt7b" },
  { &JetBrainsMono_Medium46pt7b, 46, "JetBrainsMono_Medium46pt7b" },
  { &JetBrainsMono_Medium47pt7b, 47, "JetBrainsMono_Medium47pt7b" },
  { &JetBrainsMono_Medium48pt7b, 48, "JetBrainsMono_Medium48pt7b" },
  { &JetBrainsMono_Medium49pt7b, 49, "JetBrainsMono_Medium49pt7b" },
  { &JetBrainsMono_Medium50pt7b, 50, "JetBrainsMono_Medium50pt7b" },
  { &JetBrainsMono_Medium51pt7b, 51, "JetBrainsMono_Medium51pt7b" },
  { &JetBrainsMono_Medium52pt7b, 52, "JetBrainsMono_Medium52pt7b" },
  { &JetBrainsMono_Medium53pt7b, 53, "JetBrainsMono_Medium53pt7b" },
  { &JetBrainsMono_Medium54pt7b, 54, "JetBrainsMono_Medium54pt7b" },
  { &JetBrainsMono_Medium55pt7b, 55, "JetBrainsMono_Medium55pt7b" },
  { &JetBrainsMono_Medium56pt7b, 56, "JetBrainsMono_Medium56pt7b" },
  { &JetBrainsMono_Medium57pt7b, 57, "JetBrainsMono_Medium57pt7b" },
  { &JetBrainsMono_Medium58pt7b, 58, "JetBrainsMono_Medium58pt7b" },
  { &JetBrainsMono_Medium59pt7b, 59, "JetBrainsMono_Medium59pt7b" },
  { &JetBrainsMono_Medium60pt7b, 60, "JetBrainsMono_Medium60pt7b" },
  { &JetBrainsMono_Medium61pt7b, 61, "JetBrainsMono_Medium61pt7b" },
  { &JetBrainsMono_Medium62pt7b, 62, "JetBrainsMono_Medium62pt7b" },
  { &JetBrainsMono_Medium63pt7b, 63, "JetBrainsMono_Medium63pt7b" },
  { &JetBrainsMono_Medium64pt7b, 64, "JetBrainsMono_Medium64pt7b" },
  { &JetBrainsMono_Medium65pt7b, 65, "JetBrainsMono_Medium65pt7b" },
  { &JetBrainsMono_Medium66pt7b, 66, "JetBrainsMono_Medium66pt7b" },
  { &JetBrainsMono_Medium67pt7b, 67, "JetBrainsMono_Medium67pt7b" },
  { &JetBrainsMono_Medium68pt7b, 68, "JetBrainsMono_Medium68pt7b" },
  { &JetBrainsMono_Medium69pt7b, 69, "JetBrainsMono_Medium69pt7b" },
  { &JetBrainsMono_Medium70pt7b, 70, "JetBrainsMono_Medium70pt7b" },
  { &JetBrainsMono_Medium71pt7b, 71, "JetBrainsMono_Medium71pt7b" },
  { &JetBrainsMono_Medium72pt7b, 72, "JetBrainsMono_Medium72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
