#ifndef _JETBRAINSMONO_MEDIUM23PT7B_H_
#define _JETBRAINSMONO_MEDIUM23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xE0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0x0C, 0x60, 0x86, 0x18, 0x61, 0x84, 0x18,
  0xCF, 0xFF, 0x18, 0xC1, 0x0C, 0x30, 0x83, 0x18, 0x31, 0x8F, 0xFE, 0xFF,
  0xE6, 0x18, 0x61, 0x06, 0x30, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0xC3, 0xFC, 0xED, 0xD9, 0xBB, 0x33, 0x76, 0x0E, 0xC0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x0D, 0xC1, 0x9C, 0x33, 0x66, 0x6E, 0xDC, 0xFF, 0x0F, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0x38, 0x0D, 0xF0, 0x6C, 0x63, 0x31, 0x98, 0xC6, 0x63,
  0x1B, 0x07, 0xD8, 0x0E, 0x60, 0x03, 0x00, 0x19, 0x80, 0x6F, 0x83, 0x66,
  0x19, 0x88, 0x46, 0x23, 0x18, 0x98, 0x7E, 0xC0, 0xF0, 0x1F, 0x03, 0xF8,
  0x71, 0xC7, 0x1C, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x7C, 0x0E, 0xE7,
  0xE6, 0x6E, 0x3C, 0xE3, 0xCE, 0x1C, 0xE3, 0xC7, 0xFE, 0x3E, 0x70, 0xFF,
  0xFC, 0x06, 0x3C, 0xF1, 0xC7, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x60, 0xE0, 0xE0, 0xF0, 0xE0, 0x40, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C,
  0x38, 0xE7, 0x8E, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xF6,
  0xFF, 0xFE, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x9C, 0x70, 0xC1, 0x08, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x7B, 0x9D, 0xCE, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0x6F,
  0xFF, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x00, 0x3E, 0x1F, 0xEE, 0x3F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x33, 0xDC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D,
  0xFE, 0x3F, 0x00, 0x1E, 0x07, 0xC1, 0xF8, 0x77, 0x0C, 0xE1, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x76, 0x0F, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x7E, 0x0E, 0xC1, 0xDC, 0x39,
  0xFE, 0x1F, 0x80, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81,
  0xC7, 0x61, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xE1,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xF0, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0xFE, 0x7F, 0xEE,
  0x1F, 0x81, 0xF0, 0x3E, 0x06, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0x80, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0xC1, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x3F, 0x1F, 0xEE,
  0x3B, 0x87, 0xC1, 0xF8, 0x76, 0x38, 0xFC, 0x1E, 0x1D, 0xEE, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0x1F, 0x07, 0xF9, 0xC7, 0xB0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1B, 0x07, 0x79, 0xE7, 0xF8, 0x37, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x1E, 0xE7, 0x33, 0x98,
  0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0C, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x30, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0C, 0x0F, 0x0F, 0x1F, 0x0F, 0x03, 0x00, 0x80, 0x00, 0xF8, 0xFE, 0xFF,
  0x07, 0x03, 0x03, 0x03, 0x07, 0x3E, 0x3C, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x78, 0x70, 0x1F, 0x83, 0xFC, 0x70, 0x6E, 0x07, 0xC0, 0x3C, 0x03, 0xC7,
  0xBC, 0x77, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0x63, 0xC7,
  0xFC, 0x3B, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1B, 0x81, 0x98, 0x19, 0x83, 0x98, 0x39, 0xC3,
  0x0C, 0x30, 0xC7, 0xFC, 0x7F, 0xE6, 0x0E, 0x60, 0x6E, 0x06, 0xE0, 0x70,
  0xFE, 0x3F, 0xEC, 0x3F, 0x07, 0xC0, 0xF0, 0x7C, 0x1F, 0xFE, 0xFF, 0x30,
  0xFC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFE, 0xFF, 0x00, 0x3F, 0x1F,
  0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0xCC, 0x7B,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x3B, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x0C, 0x03, 0x00,
  0xC7, 0xF1, 0xFC, 0x0F, 0x03, 0xC0, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x7C, 0x0F, 0xC1, 0xB8, 0x73, 0xFC, 0x3F, 0x00, 0xC0, 0xF8, 0x3B, 0x07,
  0x61, 0xCC, 0x39, 0x8E, 0x31, 0xC7, 0xF0, 0xFE, 0x18, 0xC3, 0x1C, 0x61,
  0x8C, 0x39, 0x83, 0x30, 0x76, 0x0E, 0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xE1, 0xF8, 0x7E, 0x16, 0xCF, 0xF3,
  0xFC, 0xBD, 0xEF, 0x7B, 0xDC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xC0, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xF6, 0x3D,
  0x8F, 0x73, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC6, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xC0, 0x3E, 0x1F, 0xEE, 0x3B, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00,
  0xFE, 0x1F, 0xF3, 0x0F, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0E, 0xFF,
  0xDF, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00,
  0x3E, 0x1F, 0xEE, 0x3F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D, 0xFE, 0x3F, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0xFE, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x0D, 0x81, 0xB0,
  0x36, 0x0E, 0xFF, 0x9F, 0xE3, 0x1C, 0x63, 0x8C, 0x39, 0x87, 0x30, 0x66,
  0x0E, 0xC0, 0xE0, 0x1F, 0x87, 0xF9, 0xC7, 0xB8, 0x76, 0x06, 0xE0, 0x1C,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x38, 0x06, 0xC0, 0xDC, 0x3B,
  0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1D,
  0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x06, 0x60, 0x66, 0x06, 0x70, 0xE7, 0x0C,
  0x30, 0xC3, 0x0C, 0x39, 0xC3, 0x98, 0x19, 0x81, 0x98, 0x1B, 0x81, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE3, 0x1B, 0x18, 0xD8, 0xC6, 0xCE, 0x36,
  0x79, 0xB3, 0xCD, 0x96, 0x6C, 0x96, 0x64, 0xB3, 0xA5, 0x8D, 0x2C, 0x79,
  0x63, 0xCB, 0x1E, 0x78, 0xE3, 0xC7, 0x1E, 0x38, 0x60, 0xE0, 0x77, 0x0E,
  0x70, 0xC3, 0x9C, 0x39, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xF0,
  0x1F, 0x01, 0xB8, 0x39, 0xC3, 0x1C, 0x70, 0xE6, 0x0E, 0xE0, 0x70, 0xC0,
  0x7E, 0x07, 0x60, 0x67, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xFF, 0xF0, 0x0C, 0x07, 0x81, 0xE0, 0xDC, 0x33, 0x1C, 0xC6,
  0x1B, 0x86, 0xC0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x0F, 0x07, 0xF9,
  0xE7, 0xB8, 0x70, 0x0E, 0x01, 0xCF, 0xFB, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xBF, 0xF3, 0xEE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37, 0xEF, 0x3F,
  0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7E, 0x1F, 0x7E, 0xDF,
  0x00, 0x1E, 0x1F, 0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3D,
  0xDF, 0xFF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E,
  0x1D, 0xFF, 0x3D, 0xC0, 0x1E, 0x1F, 0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3F,
  0xFF, 0x00, 0xC0, 0x30, 0x0E, 0x1D, 0xFE, 0x3F, 0x00, 0x03, 0xE0, 0xFC,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF, 0xFF, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x3D, 0xDF, 0xFF,
  0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x77, 0xFC, 0xF7,
  0x01, 0xC0, 0x70, 0x1C, 0xFE, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xCF, 0x37, 0xEF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x0E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0xC1, 0xC0, 0x00, 0x03,
  0xF9, 0xFC, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xEF, 0xE7, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x0F, 0x83, 0xB0, 0x66, 0x1C, 0xC7, 0x1F, 0xC3, 0xF8, 0x7F, 0x8C,
  0x71, 0x87, 0x30, 0x66, 0x0E, 0xC0, 0xE0, 0xFC, 0x0F, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xDC, 0xDB, 0xFF,
  0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9, 0x9F, 0x33, 0xE6, 0x7C, 0xCF, 0x99,
  0xF3, 0x3E, 0x66, 0xCF, 0x37, 0xEF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x1E, 0x1F, 0xEF, 0x3B,
  0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D, 0xFE, 0x3F,
  0x00, 0xCF, 0x37, 0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x7E, 0x1F, 0x7E, 0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3D,
  0xDF, 0xFF, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E,
  0x1D, 0xFF, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xEF, 0x1F, 0xF3,
  0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x3F, 0x1F, 0xEE, 0x1F, 0x80, 0xE0, 0x3E, 0x07, 0xF8,
  0x3F, 0x01, 0xC0, 0x3E, 0x1F, 0xFF, 0x3F, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x03, 0xF8, 0x3F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0xE0,
  0x7E, 0x06, 0x60, 0x67, 0x0E, 0x70, 0xC3, 0x0C, 0x39, 0xC3, 0x98, 0x19,
  0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0xE3, 0xCF, 0x2C, 0xB6, 0x69, 0x66, 0x96, 0x69, 0x67, 0x96, 0x79, 0xE7,
  0x1C, 0x31, 0xC0, 0xE0, 0x77, 0x0E, 0x31, 0xC3, 0x98, 0x1F, 0x80, 0xF0,
  0x0E, 0x00, 0xF0, 0x1F, 0x83, 0x98, 0x31, 0xC7, 0x0E, 0xE0, 0x70, 0xE0,
  0x76, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0x81, 0x98, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x07, 0x8F, 0x83, 0xF0, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x07, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xFC, 0x3F, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x83, 0xE0, 0xF0, 0x30, 0x00, 0x38, 0x0F, 0x8F, 0xB9,
  0xF3, 0xFE, 0x3E,
};

const GFXglyph JetBrainsMono_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 3, -17 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 11, 23, 14, 1, -20 },
  { 75, 14, 17, 14, 0, -17 },
  { 105, 12, 17, 14, 1, -17 },
  { 131, 2, 7, 14, 6, -17 },
  { 133, 7, 22, 14, 4, -19 },
  { 153, 7, 22, 14, 3, -19 },
  { 173, 12, 12, 14, 1, -14 },
  { 191, 11, 11, 14, 1, -13 },
  { 207, 5, 7, 14, 4, -3 },
  { 212, 8, 3, 14, 3, -9 },
  { 215, 4, 4, 14, 5, -4 },
  { 217, 10, 22, 14, 2, -19 },
  { 245, 10, 17, 14, 2, -17 },
  { 267, 11, 17, 14, 2, -17 },
  { 291, 11, 17, 14, 1, -17 },
  { 315, 11, 17, 14, 1, -17 },
  { 339, 10, 17, 14, 2, -17 },
  { 361, 10, 17, 14, 2, -17 },
  { 383, 11, 17, 14, 1, -17 },
  { 407, 10, 17, 14, 2, -17 },
  { 429, 10, 17, 14, 2, -17 },
  { 451, 11, 17, 14, 1, -17 },
  { 475, 4, 13, 14, 5, -13 },
  { 482, 5, 17, 14, 4, -13 },
  { 493, 10, 13, 14, 2, -14 },
  { 510, 10, 8, 14, 2, -12 },
  { 520, 10, 13, 14, 2, -14 },
  { 537, 8, 17, 14, 3, -17 },
  { 554, 12, 21, 14, 1, -17 },
  { 586, 12, 17, 14, 1, -17 },
  { 612, 10, 17, 14, 2, -17 },
  { 634, 10, 17, 14, 2, -17 },
  { 656, 10, 17, 14, 2, -17 },
  { 678, 10, 17, 14, 2, -17 },
  { 700, 10, 17, 14, 2, -17 },
  { 722, 10, 17, 14, 2, -17 },
  { 744, 10, 17, 14, 2, -17 },
  { 766, 10, 17, 14, 2, -17 },
  { 788, 11, 17, 14, 1, -17 },
  { 812, 11, 17, 14, 2, -17 },
  { 836, 10, 17, 14, 2, -17 },
  { 858, 10, 17, 14, 2, -17 },
  { 880, 10, 17, 14, 2, -17 },
  { 902, 10, 17, 14, 2, -17 },
  { 924, 11, 17, 14, 2, -17 },
  { 948, 10, 21, 14, 2, -17 },
  { 975, 11, 17, 14, 2, -17 },
  { 999, 11, 17, 14, 1, -17 },
  { 1023, 12, 17, 14, 1, -17 },
  { 1049, 10, 17, 14, 2, -17 },
  { 1071, 12, 17, 14, 1, -17 },
  { 1097, 13, 17, 14, 0, -17 },
  { 1125, 12, 17, 14, 1, -17 },
  { 1151, 12, 17, 14, 1, -17 },
  { 1177, 10, 17, 14, 2, -17 },
  { 1199, 7, 22, 14, 4, -19 },
  { 1219, 10, 22, 14, 2, -19 },
  { 1247, 6, 22, 14, 3, -19 },
  { 1264, 10, 9, 14, 2, -17 },
  { 1276, 11, 2, 14, 1, 1 },
  { 1279, 5, 3, 14, 4, -18 },
  { 1281, 11, 13, 14, 1, -13 },
  { 1299, 10, 17, 14, 2, -17 },
  { 1321, 10, 13, 14, 2, -13 },
  { 1338, 10, 17, 14, 2, -17 },
  { 1360, 10, 13, 14, 2, -13 },
  { 1377, 11, 17, 14, 1, -17 },
  { 1401, 10, 17, 14, 2, -13 },
  { 1423, 10, 17, 14, 2, -17 },
  { 1445, 11, 18, 14, 2, -18 },
  { 1470, 9, 22, 14, 2, -18 },
  { 1495, 11, 17, 14, 2, -17 },
  { 1519, 12, 17, 14, 1, -17 },
  { 1545, 11, 13, 14, 1, -13 },
  { 1563, 10, 13, 14, 2, -13 },
  { 1580, 10, 13, 14, 2, -13 },
  { 1597, 10, 17, 14, 2, -13 },
  { 1619, 10, 17, 14, 2, -13 },
  { 1641, 11, 13, 14, 2, -13 },
  { 1659, 10, 13, 14, 2, -13 },
  { 1676, 11, 16, 14, 1, -16 },
  { 1698, 10, 13, 14, 2, -13 },
  { 1715, 12, 13, 14, 1, -13 },
  { 1735, 12, 13, 14, 1, -13 },
  { 1755, 12, 13, 14, 1, -13 },
  { 1775, 12, 17, 14, 1, -13 },
  { 1801, 10, 13, 14, 2, -13 },
  { 1818, 10, 22, 14, 2, -19 },
  { 1846, 2, 22, 14, 6, -19 },
  { 1852, 10, 22, 14, 2, -19 },
  { 1880, 11, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_Medium23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_MEDIUM23PT7B_H_
