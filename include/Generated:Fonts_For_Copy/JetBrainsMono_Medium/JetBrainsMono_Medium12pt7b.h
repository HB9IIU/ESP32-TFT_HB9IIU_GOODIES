#ifndef _JETBRAINSMONO_MEDIUM12PT7B_H_
#define _JETBRAINSMONO_MEDIUM12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0xBB, 0xAA, 0x24, 0x49, 0xF9, 0x22, 0x85, 0x3F,
  0x24, 0x48, 0x23, 0xBB, 0x5E, 0x38, 0xE5, 0xAB, 0xC8, 0x40, 0x63, 0x2A,
  0x57, 0x41, 0x05, 0xCA, 0xA5, 0x8E, 0x73, 0x68, 0x10, 0xE6, 0xA9, 0xA6,
  0xEC, 0xF0, 0x36, 0x4C, 0x88, 0x88, 0xC6, 0x30, 0xC6, 0x31, 0x11, 0x11,
  0x32, 0xC0, 0x10, 0xA7, 0xF8, 0xC2, 0x8C, 0x80, 0x21, 0x3F, 0xF2, 0x10,
  0x6B, 0x40, 0xFF, 0xF0, 0x08, 0x44, 0x23, 0x10, 0x8C, 0x46, 0x20, 0x76,
  0x63, 0x1A, 0xC6, 0x31, 0x70, 0x33, 0xCB, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0x76, 0xE2, 0x11, 0x99, 0x98, 0xF8, 0xF8, 0xCC, 0x43, 0x84, 0x31, 0x70,
  0x19, 0x88, 0xCC, 0xC7, 0xE1, 0x08, 0xFC, 0x21, 0x6D, 0x84, 0x31, 0x70,
  0x31, 0x18, 0x8F, 0xC6, 0x31, 0x70, 0xFC, 0x62, 0x31, 0x18, 0x84, 0x60,
  0x76, 0xE3, 0xB7, 0x66, 0x31, 0x78, 0x76, 0x63, 0x1D, 0xBC, 0x44, 0x60,
  0xB0, 0x2C, 0x4C, 0x00, 0xD6, 0x80, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01,
  0xF0, 0x83, 0x06, 0x37, 0x60, 0xE3, 0x11, 0xEC, 0x00, 0xC0, 0x38, 0x89,
  0x0E, 0xFD, 0x3A, 0x74, 0xEF, 0x40, 0x80, 0xE0, 0x31, 0xC5, 0x14, 0x5B,
  0x2F, 0xA2, 0x8C, 0xF4, 0xE3, 0x1F, 0x46, 0x31, 0xF8, 0x76, 0x63, 0x08,
  0x42, 0x19, 0x78, 0xF4, 0xE3, 0x18, 0xC6, 0x33, 0xF0, 0xFC, 0x21, 0x0F,
  0xC2, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x76, 0x63, 0x0B,
  0xDE, 0x39, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0xF8, 0x1C, 0x10, 0x41, 0x04, 0x1C, 0x53, 0x78, 0x8E, 0x29,
  0xA4, 0xF2, 0x49, 0xA2, 0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0x8E,
  0xF7, 0xBA, 0xC6, 0x31, 0x88, 0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x98, 0x76,
  0xE3, 0x18, 0xC6, 0x39, 0x70, 0xF2, 0x68, 0xE3, 0xFB, 0x88, 0x20, 0x80,
  0x76, 0xE3, 0x18, 0xC6, 0x31, 0x70, 0x82, 0xF2, 0x68, 0xA2, 0xFA, 0x49,
  0x26, 0x8C, 0x76, 0x63, 0x87, 0x0C, 0x31, 0x78, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x39, 0x70, 0x8E, 0x28, 0xB2,
  0x59, 0x45, 0x1C, 0x30, 0x93, 0xA7, 0x4B, 0x56, 0xCD, 0x9B, 0x36, 0x6C,
  0x46, 0xC8, 0xA1, 0xC1, 0x07, 0x0A, 0x32, 0xC6, 0xC6, 0x89, 0xB1, 0x43,
  0x82, 0x04, 0x08, 0x10, 0xF8, 0x46, 0x62, 0x31, 0x18, 0xF8, 0xFB, 0x6D,
  0xB6, 0xDB, 0x80, 0x86, 0x10, 0x86, 0x10, 0xC2, 0x10, 0xC2, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x23, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x76, 0xC2, 0xF8,
  0xC7, 0xE0, 0x84, 0x2D, 0xB8, 0xC6, 0x39, 0xB8, 0x76, 0xE3, 0x08, 0x65,
  0xE0, 0x08, 0x5B, 0xB8, 0xC6, 0x31, 0x78, 0x76, 0xE3, 0xF8, 0x45, 0xE0,
  0x39, 0x09, 0xF2, 0x10, 0x84, 0x20, 0x6E, 0xE3, 0x18, 0xFD, 0xA1, 0x78,
  0x84, 0x2D, 0xB8, 0xC6, 0x31, 0x88, 0x30, 0x0F, 0x3C, 0x30, 0xC3, 0x0C,
  0xFC, 0x18, 0x3D, 0xE1, 0x08, 0x42, 0x10, 0xBC, 0x82, 0x08, 0xE2, 0x93,
  0xC9, 0x26, 0x8C, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xFD,
  0x6B, 0x5A, 0xD6, 0xA0, 0xB6, 0xE3, 0x18, 0xC6, 0x20, 0x76, 0xE3, 0x18,
  0xC5, 0xC0, 0xB6, 0xE3, 0x18, 0xE6, 0xF0, 0x80, 0x6E, 0xE3, 0x18, 0xC5,
  0xE1, 0x08, 0xB3, 0x6C, 0xF0, 0xC3, 0x0C, 0x00, 0x76, 0x60, 0xE0, 0xC5,
  0xE0, 0x67, 0xFE, 0xC6, 0x31, 0x87, 0x8C, 0x63, 0x18, 0xE5, 0xC0, 0x8E,
  0x2C, 0x96, 0x51, 0xC3, 0x00, 0x92, 0xA5, 0x4B, 0x66, 0xCD, 0x9B, 0x00,
  0x8F, 0x65, 0x08, 0x71, 0x68, 0xC0, 0x8E, 0x2C, 0x96, 0x50, 0xC2, 0x08,
  0x60, 0xFF, 0xC4, 0x46, 0x63, 0xE0, 0x19, 0x8C, 0x63, 0x70, 0xC6, 0x31,
  0x86, 0xFF, 0xE0, 0xC3, 0x08, 0xC6, 0x1C, 0x8C, 0x21, 0x38, 0x43, 0xB9,
  0x80,
};

const GFXglyph JetBrainsMono_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 4, 4, 7, 2, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 12, 7, 1, -10 },
  { 22, 7, 9, 7, 0, -9 },
  { 30, 6, 9, 7, 1, -9 },
  { 37, 1, 4, 7, 3, -9 },
  { 38, 4, 11, 7, 2, -10 },
  { 44, 4, 11, 7, 1, -10 },
  { 50, 7, 6, 7, 0, -7 },
  { 56, 5, 6, 7, 1, -7 },
  { 60, 3, 4, 7, 2, -2 },
  { 62, 4, 2, 7, 2, -5 },
  { 63, 2, 2, 7, 3, -2 },
  { 64, 5, 11, 7, 1, -10 },
  { 71, 5, 9, 7, 1, -9 },
  { 77, 6, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 5, 9, 7, 1, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 5, 9, 7, 1, -9 },
  { 108, 5, 9, 7, 1, -9 },
  { 114, 5, 9, 7, 1, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 5, 9, 7, 1, -9 },
  { 132, 2, 7, 7, 3, -7 },
  { 134, 3, 9, 7, 2, -7 },
  { 138, 5, 6, 7, 1, -7 },
  { 142, 5, 4, 7, 1, -6 },
  { 145, 5, 6, 7, 1, -7 },
  { 149, 4, 9, 7, 2, -9 },
  { 154, 7, 11, 7, 0, -9 },
  { 164, 6, 9, 7, 1, -9 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 5, 9, 7, 1, -9 },
  { 189, 5, 9, 7, 1, -9 },
  { 195, 5, 9, 7, 1, -9 },
  { 201, 5, 9, 7, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 6, 9, 7, 0, -9 },
  { 226, 6, 9, 7, 1, -9 },
  { 233, 5, 9, 7, 1, -9 },
  { 239, 5, 9, 7, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 6, 9, 7, 1, -9 },
  { 264, 5, 11, 7, 1, -9 },
  { 271, 6, 9, 7, 1, -9 },
  { 278, 5, 9, 7, 1, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 5, 9, 7, 1, -9 },
  { 297, 6, 9, 7, 1, -9 },
  { 304, 7, 9, 7, 0, -9 },
  { 312, 7, 9, 7, 0, -9 },
  { 320, 7, 9, 7, 0, -9 },
  { 328, 5, 9, 7, 1, -9 },
  { 334, 3, 11, 7, 2, -10 },
  { 339, 5, 11, 7, 1, -10 },
  { 346, 3, 11, 7, 2, -10 },
  { 351, 5, 5, 7, 1, -9 },
  { 355, 5, 1, 7, 1, 0 },
  { 356, 3, 1, 7, 2, -9 },
  { 357, 5, 7, 7, 1, -7 },
  { 362, 5, 9, 7, 1, -9 },
  { 368, 5, 7, 7, 1, -7 },
  { 373, 5, 9, 7, 1, -9 },
  { 379, 5, 7, 7, 1, -7 },
  { 384, 5, 9, 7, 1, -9 },
  { 390, 5, 9, 7, 1, -7 },
  { 396, 5, 9, 7, 1, -9 },
  { 402, 6, 9, 7, 1, -9 },
  { 409, 5, 11, 7, 1, -9 },
  { 416, 6, 9, 7, 1, -9 },
  { 423, 7, 9, 7, 0, -9 },
  { 431, 5, 7, 7, 1, -7 },
  { 436, 5, 7, 7, 1, -7 },
  { 441, 5, 7, 7, 1, -7 },
  { 446, 5, 9, 7, 1, -7 },
  { 452, 5, 9, 7, 1, -7 },
  { 458, 6, 7, 7, 1, -7 },
  { 464, 5, 7, 7, 1, -7 },
  { 469, 5, 8, 7, 1, -8 },
  { 474, 5, 7, 7, 1, -7 },
  { 479, 6, 7, 7, 1, -7 },
  { 485, 7, 7, 7, 0, -7 },
  { 492, 6, 7, 7, 1, -7 },
  { 498, 6, 9, 7, 1, -7 },
  { 505, 5, 7, 7, 1, -7 },
  { 510, 5, 11, 7, 1, -10 },
  { 517, 1, 11, 7, 3, -10 },
  { 519, 5, 11, 7, 1, -10 },
  { 526, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_Medium12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_MEDIUM12PT7B_H_
