#ifndef _JETBRAINSMONO_MEDIUM21PT7B_H_
#define _JETBRAINSMONO_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0xD8, 0x05, 0xF8, 0xCF, 0x9F, 0x3E, 0x7C, 0x78,
  0x80, 0x18, 0xC3, 0x18, 0x62, 0x08, 0x4F, 0xFE, 0x63, 0x0C, 0x61, 0x8C,
  0x31, 0x1F, 0xFB, 0xFF, 0x31, 0x86, 0x30, 0xC4, 0x11, 0x80, 0x04, 0x01,
  0x00, 0x40, 0xFE, 0x7F, 0xD9, 0x36, 0x4D, 0x90, 0x74, 0x0F, 0x81, 0xF8,
  0x1F, 0x05, 0xC1, 0x3E, 0x4D, 0x97, 0x7F, 0x8F, 0xC0, 0x40, 0x10, 0x04,
  0x00, 0x7C, 0x3E, 0x63, 0x31, 0x19, 0x89, 0x8C, 0xD8, 0x3E, 0x80, 0xCC,
  0x00, 0xC0, 0x04, 0xE0, 0x6F, 0x86, 0xC4, 0x26, 0x23, 0x31, 0x30, 0xDB,
  0x07, 0x80, 0x0C, 0x07, 0xE1, 0xCE, 0x30, 0xC6, 0x00, 0xE0, 0x0C, 0x03,
  0xC0, 0xFC, 0x79, 0x9B, 0x1B, 0x63, 0xCC, 0x39, 0x87, 0x3F, 0xB3, 0xE7,
  0xFF, 0xF0, 0x04, 0x73, 0xDC, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x38, 0x61, 0xC3, 0xC3, 0x04, 0x81, 0xC3, 0xC1, 0xC1, 0xC1, 0x83,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x1C, 0x73, 0xC7, 0x08,
  0x00, 0x0C, 0x01, 0x80, 0x30, 0x66, 0x2F, 0x5E, 0xFF, 0x83, 0x00, 0xD8,
  0x3B, 0x0E, 0x30, 0x86, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x39, 0x9C, 0xC6, 0x70, 0xFF, 0xFC,
  0x27, 0xF7, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x00, 0x08, 0x3F, 0xBD, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0xB3, 0xDD,
  0xE4, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFC, 0x7C, 0x3C, 0x3E, 0x3B, 0x11,
  0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF,
  0xFE, 0x0C, 0x0F, 0xC7, 0xB9, 0x87, 0xE0, 0xC0, 0x30, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0xFD, 0xFF, 0x7F, 0x9F, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0x81, 0xF8, 0x06, 0x01, 0xC0, 0x30, 0x0F, 0x83,
  0x61, 0xDF, 0xE3, 0xF0, 0x07, 0x07, 0x03, 0x03, 0x03, 0x81, 0x81, 0x8F,
  0xC7, 0xC3, 0xE1, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0xFF, 0x7F, 0xB0,
  0x18, 0x0C, 0x06, 0xF3, 0xFD, 0xC7, 0x01, 0x80, 0xC0, 0x78, 0x3C, 0x3F,
  0xF9, 0xF8, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0xF9, 0xCF,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x61, 0xDF, 0xE1, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0x87, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x18, 0x3F, 0xBD, 0xD8, 0x7C, 0x1E, 0x1F, 0x8C,
  0xFC, 0x3E, 0x73, 0xB0, 0xF8, 0x3C, 0x1E, 0x1F, 0xFC, 0xFC, 0x0C, 0x0F,
  0xE7, 0xB9, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0x7F, 0xCF, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x6F, 0x72, 0x00, 0x00, 0x07, 0xF7,
  0x33, 0xCE, 0x20, 0x00, 0x00, 0x01, 0xCC, 0xE7, 0x33, 0x80, 0x00, 0x80,
  0xC1, 0xE3, 0xC7, 0x87, 0x03, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0x10,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x0E, 0x1E, 0x3C, 0x78, 0x30, 0x10, 0x00, 0xFD,
  0xFC, 0x18, 0x30, 0x60, 0xC7, 0xBE, 0x70, 0xC1, 0x80, 0x02, 0x0E, 0x1C,
  0x00, 0x04, 0x07, 0xF1, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF1, 0xFE, 0x67,
  0xCC, 0x79, 0x8F, 0x31, 0xE6, 0x3C, 0xC7, 0x9F, 0xF1, 0xDE, 0x00, 0xE0,
  0x0E, 0x00, 0xF8, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x7C, 0x0D, 0x81, 0xB0,
  0x66, 0x0C, 0xE1, 0x8C, 0x31, 0x8F, 0xF1, 0xFF, 0x30, 0x66, 0x0D, 0xC1,
  0xB0, 0x38, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x1B, 0xF9, 0xFE, 0xC3,
  0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xFB, 0xF8, 0x08, 0x3F, 0xBD, 0xD8, 0x7C,
  0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x1F, 0x1F, 0xFC,
  0x7C, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3F, 0xFB, 0xF0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x08, 0x3F, 0xBD, 0xD8, 0x7C, 0x1E, 0x03, 0x01,
  0x80, 0xCF, 0xE7, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0xFC, 0x7C, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x06, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x06, 0xE1,
  0x9F, 0xE3, 0xF0, 0xC1, 0xF0, 0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8F, 0xC3,
  0xF0, 0xCE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xFF, 0xFE, 0xE1, 0xFC, 0x7F, 0x17, 0x4F, 0xDB, 0xF6, 0xBC, 0xEF,
  0x3B, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C, 0xE1, 0xF0,
  0xFC, 0x7E, 0x3F, 0x1E, 0xCF, 0x67, 0xB3, 0xCD, 0xE6, 0xF3, 0x78, 0xFC,
  0x7E, 0x1F, 0x0E, 0x08, 0x3F, 0xBD, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1F, 0xFC, 0x7C, 0xFF, 0x3F, 0xEC,
  0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x3B, 0xFC, 0xFE, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x08, 0x3F, 0xBD, 0xD8, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFC, 0x7C, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0xFF, 0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x3B,
  0xFC, 0xFC, 0x31, 0x8C, 0x63, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0x0C, 0x0F,
  0xE7, 0xBD, 0x83, 0x60, 0xD8, 0x07, 0x00, 0xF8, 0x1F, 0x80, 0xF0, 0x0C,
  0x03, 0xE0, 0xD8, 0x77, 0xF8, 0xFC, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x3F, 0xF8, 0xF8, 0xC0, 0xFC, 0x19, 0x83,
  0x30, 0x66, 0x18, 0xE3, 0x0C, 0x61, 0x8C, 0x33, 0x07, 0x60, 0x6C, 0x0D,
  0x81, 0xE0, 0x3C, 0x03, 0x80, 0xE6, 0x36, 0x73, 0x67, 0x36, 0x53, 0x65,
  0x36, 0x53, 0x6D, 0x26, 0xD6, 0x6D, 0x66, 0x96, 0x29, 0xE3, 0x9E, 0x38,
  0xE3, 0x8E, 0x38, 0xC0, 0xE0, 0xEC, 0x38, 0xC6, 0x19, 0xC1, 0xB0, 0x3C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xEC, 0x19, 0xC7, 0x1C, 0xC1, 0xB0,
  0x38, 0xC0, 0xFC, 0x19, 0x87, 0x38, 0xC3, 0x38, 0x76, 0x06, 0xC0, 0xF0,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFF,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0C,
  0x07, 0xFF, 0xFE, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x1C, 0x1E, 0x0D,
  0x84, 0xC6, 0x33, 0x1B, 0x0D, 0x83, 0xFF, 0xFF, 0xF0, 0xE7, 0x0E, 0x0F,
  0xE7, 0x1D, 0x83, 0x00, 0xC7, 0xF7, 0xFF, 0x83, 0xE0, 0xF8, 0x77, 0xEC,
  0xFB, 0xC0, 0x60, 0x30, 0x19, 0xCF, 0xF7, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x3F, 0xFB, 0x78, 0x1C, 0x3F, 0xB8, 0xF8, 0x3C, 0x06,
  0x03, 0x01, 0x80, 0xC1, 0xF1, 0xFF, 0xC7, 0xC0, 0x01, 0x80, 0xC0, 0x67,
  0x37, 0xDF, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0xED,
  0xF6, 0x1C, 0x3F, 0xB8, 0xD8, 0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x61,
  0xFF, 0xC7, 0xC0, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x39, 0xBE,
  0xF9, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xFE, 0xDF, 0x60, 0x30,
  0x18, 0x1D, 0xFC, 0xFC, 0xC0, 0x60, 0x30, 0x19, 0xCF, 0xF7, 0x1F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x00, 0xFE, 0xFE, 0xFE,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0xFC,
  0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xC1, 0xB0, 0xCC, 0x73, 0x18, 0xFC,
  0x3F, 0x0C, 0xE3, 0x1C, 0xC3, 0x30, 0xEC, 0x1C, 0xFC, 0x1F, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x1F, 0xC1, 0xF8, 0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCE, 0x7F, 0xB8, 0xF8,
  0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1C, 0x3F,
  0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xFF, 0xC7, 0xC0,
  0xCE, 0x7F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xFF,
  0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x39, 0xBE, 0xF9, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xFF, 0x6F, 0xB0, 0x18, 0x0C, 0x06, 0x03,
  0xCE, 0x6F, 0xB8, 0xFC, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x00, 0x3E, 0x3F, 0xB8, 0xF8, 0x0C, 0x07, 0xF0, 0xFC, 0x07, 0x01,
  0xE0, 0xFF, 0xEF, 0xE0, 0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xF1,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0xF0, 0x7C, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xDF, 0xC7,
  0xC0, 0xC0, 0xFC, 0x19, 0x83, 0x30, 0xE7, 0x18, 0x63, 0x0C, 0xE1, 0xD8,
  0x1B, 0x03, 0x60, 0x78, 0x07, 0x00, 0xCC, 0x79, 0x8F, 0x39, 0xE7, 0x3C,
  0xA5, 0x95, 0x96, 0xB2, 0x96, 0x73, 0xCE, 0x79, 0xC6, 0x38, 0xC0, 0xE0,
  0xCC, 0x38, 0xC6, 0x1D, 0x81, 0xF0, 0x1C, 0x03, 0x80, 0xF8, 0x3B, 0x06,
  0x71, 0x87, 0x70, 0x70, 0xC0, 0xFC, 0x19, 0x83, 0x38, 0xE3, 0x18, 0x67,
  0x0E, 0xC0, 0xD8, 0x1B, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70,
  0x70, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0xFC, 0x78, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x0E, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x1F, 0x87, 0xC7, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x38, 0x78, 0x3C, 0x00, 0x30, 0x1F, 0x3C, 0xCF, 0x1F, 0xC3, 0x80,
};

const GFXglyph JetBrainsMono_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 7, 6, 13, 3, -15 },
  { 13, 11, 15, 13, 1, -15 },
  { 34, 10, 21, 13, 1, -18 },
  { 61, 13, 15, 13, 0, -15 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 2, 6, 13, 5, -15 },
  { 110, 6, 21, 13, 4, -18 },
  { 126, 7, 21, 13, 2, -18 },
  { 145, 11, 11, 13, 1, -13 },
  { 161, 10, 10, 13, 1, -12 },
  { 174, 5, 6, 13, 3, -3 },
  { 178, 7, 2, 13, 3, -8 },
  { 180, 4, 4, 13, 4, -4 },
  { 182, 10, 19, 13, 1, -17 },
  { 206, 9, 16, 13, 2, -16 },
  { 224, 9, 15, 13, 2, -15 },
  { 241, 10, 16, 13, 1, -16 },
  { 261, 10, 15, 13, 1, -15 },
  { 280, 9, 15, 13, 2, -15 },
  { 297, 9, 15, 13, 2, -15 },
  { 314, 10, 15, 13, 1, -15 },
  { 333, 10, 15, 13, 1, -15 },
  { 352, 9, 16, 13, 2, -16 },
  { 370, 10, 16, 13, 1, -16 },
  { 390, 4, 12, 13, 4, -12 },
  { 396, 5, 15, 13, 3, -12 },
  { 406, 9, 12, 13, 2, -13 },
  { 420, 9, 8, 13, 2, -11 },
  { 429, 9, 12, 13, 2, -13 },
  { 443, 7, 15, 13, 3, -15 },
  { 457, 11, 20, 13, 1, -16 },
  { 485, 11, 15, 13, 1, -15 },
  { 506, 9, 15, 13, 2, -15 },
  { 523, 9, 16, 13, 2, -16 },
  { 541, 9, 15, 13, 2, -15 },
  { 558, 9, 15, 13, 2, -15 },
  { 575, 9, 15, 13, 2, -15 },
  { 592, 9, 16, 13, 2, -16 },
  { 610, 9, 15, 13, 2, -15 },
  { 627, 9, 15, 13, 2, -15 },
  { 644, 10, 15, 13, 1, -15 },
  { 663, 10, 15, 13, 2, -15 },
  { 682, 9, 15, 13, 2, -15 },
  { 699, 10, 15, 13, 1, -15 },
  { 718, 9, 15, 13, 2, -15 },
  { 735, 9, 16, 13, 2, -16 },
  { 753, 10, 15, 13, 2, -15 },
  { 772, 9, 20, 13, 2, -16 },
  { 795, 10, 15, 13, 2, -15 },
  { 814, 10, 16, 13, 1, -16 },
  { 834, 11, 15, 13, 1, -15 },
  { 855, 9, 15, 13, 2, -15 },
  { 872, 11, 15, 13, 1, -15 },
  { 893, 12, 15, 13, 0, -15 },
  { 916, 11, 15, 13, 1, -15 },
  { 937, 11, 15, 13, 1, -15 },
  { 958, 9, 15, 13, 2, -15 },
  { 975, 6, 19, 13, 4, -17 },
  { 990, 10, 19, 13, 1, -17 },
  { 1014, 6, 19, 13, 3, -17 },
  { 1029, 9, 8, 13, 2, -15 },
  { 1038, 10, 2, 13, 1, 1 },
  { 1041, 4, 2, 13, 4, -16 },
  { 1042, 10, 12, 13, 1, -12 },
  { 1057, 9, 15, 13, 2, -15 },
  { 1074, 9, 12, 13, 2, -12 },
  { 1088, 9, 15, 13, 2, -15 },
  { 1105, 9, 12, 13, 2, -12 },
  { 1119, 10, 15, 13, 1, -15 },
  { 1138, 9, 16, 13, 2, -12 },
  { 1156, 9, 15, 13, 2, -15 },
  { 1173, 10, 16, 13, 2, -16 },
  { 1193, 8, 20, 13, 2, -16 },
  { 1213, 10, 15, 13, 2, -15 },
  { 1232, 11, 15, 13, 1, -15 },
  { 1253, 10, 12, 13, 1, -12 },
  { 1268, 9, 12, 13, 2, -12 },
  { 1282, 9, 12, 13, 2, -12 },
  { 1296, 9, 16, 13, 2, -12 },
  { 1314, 9, 16, 13, 2, -12 },
  { 1332, 9, 12, 13, 2, -12 },
  { 1346, 9, 12, 13, 2, -12 },
  { 1360, 10, 15, 13, 1, -15 },
  { 1379, 9, 12, 13, 2, -12 },
  { 1393, 11, 12, 13, 1, -12 },
  { 1410, 11, 12, 13, 1, -12 },
  { 1427, 11, 12, 13, 1, -12 },
  { 1444, 11, 16, 13, 1, -12 },
  { 1466, 9, 12, 13, 2, -12 },
  { 1480, 9, 19, 13, 2, -17 },
  { 1502, 2, 19, 13, 5, -17 },
  { 1507, 9, 19, 13, 2, -17 },
  { 1529, 10, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Medium21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_MEDIUM21PT7B_H_
