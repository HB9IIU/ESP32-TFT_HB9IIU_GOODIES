#ifndef _NOTOSANS_EXTRACONDENSED_BLACK69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xCF, 0xFC, 0x3F, 0xE0, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0,
  0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0xF9, 0xFC, 0xFF, 0xCF, 0x83, 0x8F,
  0xF8, 0xF8, 0x08, 0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0xF8, 0x00, 0xFF, 0x8F,
  0x80, 0x0F, 0xFC, 0xF8, 0x00, 0x7F, 0xEF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFB, 0xFF, 0x00, 0x0F, 0x9F, 0xF0, 0x00, 0xF9,
  0xFF, 0x00, 0x0F, 0x9F, 0xF4, 0x00, 0xF9, 0xFF, 0x60, 0x0F, 0x9F, 0xF7,
  0x80, 0xF9, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x3F, 0xE3,
  0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x7F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x1F, 0xFB, 0xFE, 0x0F, 0xFF, 0x87, 0xFC,
  0x7F, 0xC7, 0xF8, 0x1F, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xE1, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x87, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x18, 0x0F, 0xF8, 0x0C, 0x3C, 0x1F, 0xE0, 0x78,
  0x7F, 0x3F, 0xC7, 0xF1, 0xFF, 0xBF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0x81,
  0xFE, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9F, 0xFC,
  0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xCF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE,
  0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF7, 0xFF, 0x9F, 0xF3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0,
  0x70, 0x7F, 0xF8, 0x10, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF,
  0x07, 0xF0, 0x3F, 0xFE, 0x0F, 0x80, 0x7F, 0xF8, 0x1C, 0x01, 0xFF, 0xE0,
  0x60, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x7F, 0xFC, 0x1C, 0x01, 0xFF, 0xE0, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xE0,
  0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xE0,
  0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x80,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC1, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0xE0, 0x7F, 0xEF,
  0xFF, 0xC1, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0x1F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0,
  0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xCF, 0xFE, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x9F, 0xFC,
  0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x03,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xFE, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0xE0, 0xFF, 0xF9,
  0xFF, 0x81, 0xFF, 0xE7, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x40, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x20,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F,
  0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF8, 0xFF, 0x80, 0xF0, 0x03, 0x80,
  0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0x8F, 0x00, 0xFF, 0xF1, 0x80,
  0x0F, 0xFE, 0x20, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x06, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xC7, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xE3,
  0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xCF, 0xF8, 0x3F, 0xE1, 0xFE,
  0x1F, 0xE7, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xF9, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x7F, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0xCF, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0x81,
  0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xF0, 0x3F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0x0F, 0xFF, 0xC0, 0x3C, 0x3F, 0xFE, 0x00, 0x21, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x27, 0xFF, 0xE0, 0x01, 0x8F,
  0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFC,
  0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0xFF,
  0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0xC0, 0x07,
  0x03, 0xFF, 0xF0, 0x00, 0x20, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0xEF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F,
  0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFE,
  0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F,
  0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF7,
  0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xE7,
  0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xEF,
  0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFD,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFE,
  0x1F, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F,
  0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFB, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xFE, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0x80, 0xF8, 0xFF, 0xF0,
  0x03, 0x8F, 0xFF, 0x00, 0x08, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0xF8, 0x01, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xE0, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xEF, 0xF8,
  0xFF, 0xF0, 0x07, 0xFE, 0x3F, 0xE7, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F,
  0xE7, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0xE0, 0x07,
  0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xC3,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC3, 0xFD, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xC3, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC3, 0xFD, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0x07, 0xFF,
  0x81, 0xC0, 0x1F, 0xFC, 0x08, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFE, 0x7F, 0xFF, 0x3F, 0xF3, 0xFF,
  0xF8, 0xFF, 0x8F, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x1C, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x3F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF,
  0xBF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFE, 0xFF, 0xF8,
  0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE,
  0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xF0, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF,
  0xCF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xC0, 0x71, 0xFF, 0xE0, 0x04, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x02, 0x7F, 0xF8,
  0x01, 0x9F, 0xFF, 0x01, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0x81, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x83,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xDF, 0xFC, 0x7F,
  0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0x7F, 0xF8,
  0x3F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFE, 0x0F,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x02,
  0x3F, 0xFC, 0x00, 0x70, 0xFF, 0xFC, 0x1F, 0x87, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xFE, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1,
  0xFF, 0xFB, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF8, 0x7F,
  0xFF, 0x7F, 0xF0, 0x7F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFF, 0x80, 0x1C, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF1, 0x00, 0x00, 0xFF, 0xE3, 0x80, 0x03,
  0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xF0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF9, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xE3,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x02,
  0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFE, 0x7F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x08, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x70, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xC0,
  0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xF8,
  0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF3,
  0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0xE7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFF,
  0x07, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xEF,
  0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x80,
  0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xBF, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0x0F, 0xFE, 0x7F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8, 0x1E, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF,
  0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x80, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0x8F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0x7F, 0xF0, 0x7F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x80, 0x1C, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE0, 0xF8, 0xFF, 0xE0, 0x38, 0xFF, 0xE0, 0x08, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x60, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F,
  0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFE,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFE, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xBF, 0xC7, 0xFF, 0x07, 0xFF, 0x1F, 0xEF,
  0xF1, 0xFF, 0xC1, 0xFF, 0xCF, 0xFB, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F,
  0xCF, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xF3, 0xFE, 0xFF, 0xE0, 0x3F, 0xF3,
  0xFC, 0x7F, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0x1F, 0xEF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC7, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xF1, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xBF, 0xE0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x09, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x0D, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF6, 0x00, 0x0F, 0xFF,
  0x88, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 50, 19, 3, -49 },
  { 83, 28, 18, 33, 3, -49 },
  { 146, 36, 49, 38, 1, -49 },
  { 367, 28, 56, 34, 3, -52 },
  { 563, 54, 51, 58, 2, -50 },
  { 908, 43, 51, 44, 2, -50 },
  { 1183, 12, 18, 17, 3, -49 },
  { 1210, 19, 62, 23, 3, -51 },
  { 1358, 20, 62, 23, 0, -51 },
  { 1513, 31, 31, 33, 1, -53 },
  { 1634, 30, 33, 35, 2, -41 },
  { 1758, 14, 20, 19, 2, -10 },
  { 1793, 18, 11, 22, 2, -24 },
  { 1818, 13, 13, 19, 3, -12 },
  { 1840, 29, 51, 29, 0, -50 },
  { 2025, 30, 51, 34, 2, -50 },
  { 2217, 25, 49, 34, 3, -49 },
  { 2371, 30, 50, 34, 1, -50 },
  { 2559, 29, 51, 34, 2, -50 },
  { 2744, 32, 49, 34, 1, -49 },
  { 2940, 28, 50, 34, 3, -49 },
  { 3115, 30, 51, 34, 2, -50 },
  { 3307, 29, 49, 34, 3, -49 },
  { 3485, 30, 51, 34, 2, -50 },
  { 3677, 30, 51, 34, 2, -50 },
  { 3869, 13, 40, 19, 3, -39 },
  { 3934, 14, 49, 19, 2, -39 },
  { 4020, 30, 34, 35, 2, -42 },
  { 4148, 30, 25, 35, 2, -37 },
  { 4242, 31, 34, 35, 2, -42 },
  { 4374, 27, 51, 28, 0, -50 },
  { 4547, 49, 55, 53, 2, -50 },
  { 4884, 40, 49, 40, 0, -49 },
  { 5129, 32, 49, 39, 4, -49 },
  { 5325, 30, 51, 35, 3, -50 },
  { 5517, 34, 49, 41, 4, -49 },
  { 5726, 24, 49, 31, 4, -49 },
  { 5873, 24, 49, 30, 4, -49 },
  { 6020, 35, 51, 41, 3, -50 },
  { 6244, 34, 49, 42, 4, -49 },
  { 6453, 21, 49, 24, 2, -49 },
  { 6582, 20, 64, 20, -4, -49 },
  { 6742, 35, 49, 38, 4, -49 },
  { 6957, 25, 49, 30, 4, -49 },
  { 7111, 48, 49, 56, 4, -49 },
  { 7405, 37, 49, 45, 4, -49 },
  { 7632, 37, 51, 43, 3, -50 },
  { 7868, 30, 49, 36, 4, -49 },
  { 8052, 37, 62, 43, 3, -50 },
  { 8339, 34, 49, 38, 4, -49 },
  { 8548, 28, 51, 31, 2, -50 },
  { 8727, 30, 49, 32, 1, -49 },
  { 8911, 33, 50, 41, 4, -49 },
  { 9118, 39, 49, 39, 0, -49 },
  { 9357, 56, 49, 56, 0, -49 },
  { 9700, 36, 49, 36, 0, -49 },
  { 9921, 36, 49, 36, 0, -49 },
  { 10142, 30, 49, 33, 1, -49 },
  { 10326, 17, 63, 21, 3, -51 },
  { 10460, 29, 51, 29, 0, -50 },
  { 10645, 17, 63, 21, 1, -51 },
  { 10779, 37, 32, 37, 0, -49 },
  { 10927, 35, 9, 35, 0, 4 },
  { 10967, 18, 11, 23, 3, -53 },
  { 10992, 29, 40, 34, 2, -39 },
  { 11137, 31, 53, 36, 3, -52 },
  { 11343, 26, 40, 30, 2, -39 },
  { 11473, 31, 53, 36, 2, -52 },
  { 11679, 29, 40, 33, 2, -39 },
  { 11824, 24, 53, 23, 0, -53 },
  { 11983, 31, 56, 36, 2, -39 },
  { 12200, 30, 52, 37, 3, -52 },
  { 12395, 12, 54, 18, 3, -54 },
  { 12476, 18, 71, 18, -3, -54 },
  { 12636, 33, 52, 36, 3, -52 },
  { 12851, 12, 52, 18, 3, -52 },
  { 12929, 48, 39, 54, 3, -39 },
  { 13163, 30, 39, 37, 3, -39 },
  { 13310, 31, 40, 36, 2, -39 },
  { 13465, 31, 56, 36, 3, -39 },
  { 13682, 31, 56, 36, 2, -39 },
  { 13899, 21, 39, 26, 4, -39 },
  { 14002, 24, 40, 27, 2, -39 },
  { 14122, 23, 47, 24, 0, -46 },
  { 14258, 30, 39, 37, 3, -38 },
  { 14405, 34, 38, 34, 0, -38 },
  { 14567, 50, 38, 51, 0, -38 },
  { 14805, 32, 38, 33, 0, -38 },
  { 14957, 34, 55, 34, 0, -38 },
  { 15191, 25, 38, 27, 1, -38 },
  { 15310, 23, 62, 25, 1, -50 },
  { 15489, 9, 69, 29, 10, -53 },
  { 15567, 23, 62, 25, 1, -50 },
  { 15746, 31, 13, 35, 2, -31 },
};

const GFXfont NotoSans_ExtraCondensed_Black69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK69PT7B_H_
