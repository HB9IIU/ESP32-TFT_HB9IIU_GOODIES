#ifndef _NOTOSANS_EXTRACONDENSED_BLACK45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7E, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC1, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x38, 0xCF, 0xCE, 0x03, 0xF3, 0x80, 0xFC, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0E, 0xFC, 0x03,
  0x9F, 0x80, 0xE7, 0xF8, 0x3B, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x7C,
  0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0xFC, 0xFC,
  0x1F, 0x80, 0x0F, 0xC7, 0xC1, 0xF0, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x0F,
  0xC7, 0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xC7, 0xE0,
  0x00, 0xFC, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC7, 0xC1, 0xE0, 0x7C, 0xFC,
  0xFC, 0x7F, 0x07, 0xFF, 0xCF, 0x8F, 0xF8, 0x7F, 0xF9, 0xF9, 0xFF, 0xC3,
  0xFF, 0x9F, 0x3F, 0xFE, 0x3F, 0xF3, 0xF3, 0xF7, 0xE0, 0xFE, 0x3F, 0x3E,
  0x3E, 0x03, 0x03, 0xE3, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x3F, 0x00, 0x07,
  0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE3, 0xF0,
  0x00, 0xF8, 0x3E, 0x3F, 0x00, 0x1F, 0x83, 0xE3, 0xE0, 0x01, 0xF0, 0x3F,
  0x3E, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0x3E,
  0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFE, 0x0F, 0xFE, 0x1F, 0xE3,
  0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0x7F,
  0xFF, 0x8F, 0xF3, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x61, 0xF0, 0x47, 0x9F, 0x3E, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x87, 0xF9, 0xFC, 0x3F, 0x1F, 0xC1,
  0xF0, 0xF0, 0x06, 0x0E, 0x00, 0x20, 0x40, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0x8F, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF9, 0xFE, 0xFF,
  0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xE3, 0xF9, 0xFC, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C,
  0xFF, 0x18, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF1, 0xFE, 0x38, 0x1F,
  0xC2, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF1, 0xE1, 0xFF, 0x10, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFB, 0xFC, 0x0F, 0xDF, 0xE0, 0x7C, 0xFF, 0x07, 0xE7, 0xF8, 0x7E,
  0x3F, 0xC3, 0xF1, 0xFE, 0x3F, 0x0F, 0xF1, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x3F, 0x07, 0xF7, 0xF8, 0x7E, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF8, 0xFF, 0x7F, 0x9F,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x8F, 0xE3,
  0xF9, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x9F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF9, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x7F, 0x1F, 0xE7, 0xE0,
  0xFC, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x1F, 0x1F, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0xFF, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0x70, 0x7F, 0x20, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x1F, 0xF9,
  0xF9, 0xF8, 0x7F, 0xF9, 0xF3, 0xE1, 0xFF, 0xF3, 0xEF, 0xC7, 0xFF, 0xE7,
  0xFF, 0x0F, 0xCF, 0xC7, 0xFE, 0x3F, 0x1F, 0x8F, 0xFC, 0x7C, 0x3E, 0x1F,
  0xF8, 0xF8, 0x7C, 0x3F, 0xF1, 0xF0, 0xF8, 0x7F, 0xE3, 0xE1, 0xF0, 0xFF,
  0xC7, 0xC3, 0xE1, 0xFF, 0x8F, 0x87, 0xC3, 0xFF, 0x1F, 0x0F, 0x8F, 0xBE,
  0x3E, 0x3F, 0x1F, 0x7C, 0x7E, 0xFF, 0x7E, 0xF8, 0x7F, 0xFF, 0xF9, 0xF8,
  0xFF, 0xBF, 0xE1, 0xF0, 0xFE, 0x3F, 0x83, 0xF0, 0x78, 0x1E, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x0F, 0xF8,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xF1, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE,
  0x3F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFE, 0x1C, 0x7F, 0xC0, 0x47, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x06, 0x7F, 0xE1, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0x87, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0xBF, 0x83, 0xFC, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFC, 0x1C, 0x7F,
  0xC0, 0x11, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFF, 0x07,
  0xF7, 0xFE, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE,
  0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F,
  0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF8, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F,
  0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0xE1, 0xFB, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0x3F, 0x7F, 0xFF,
  0x7E, 0x7E, 0xFF, 0xFE, 0xFC, 0xFD, 0xFF, 0xFD, 0xFD, 0xFB, 0xFF, 0xF9,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFE,
  0xFE, 0x7F, 0xFE, 0xFE, 0x7F, 0xFE, 0xFF, 0x7F, 0xFE, 0x7F, 0x7F, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F,
  0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x9F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0x7F, 0x81, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE7, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8,
  0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F,
  0x03, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8,
  0x3F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFF, 0x00, 0x70, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0x3E, 0xFF, 0x01, 0xBF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0x7F, 0x01, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xC0, 0xFF,
  0x7F, 0x03, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xFE,
  0x0F, 0xE7, 0xF8, 0x3F, 0xE0, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xE3, 0xF8,
  0x7F, 0xE1, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC,
  0x3F, 0xC7, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xDF,
  0x3F, 0xC1, 0xFC, 0xFD, 0xF3, 0xFC, 0x1F, 0xCF, 0xDF, 0x3F, 0x81, 0xFC,
  0xFD, 0xFB, 0xF8, 0x0F, 0xCF, 0x9F, 0xBF, 0x80, 0xFF, 0xF9, 0xFB, 0xF8,
  0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xF9,
  0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xF9, 0xFE, 0x07,
  0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80,
  0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0x7F, 0xC3, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFD, 0xF9, 0xFF, 0x3F, 0x1F, 0xC3, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE3,
  0xF0, 0xFE, 0x7F, 0x8F, 0xEF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xC7,
  0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF9, 0xFF, 0x0C, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x5F, 0xE0, 0xEF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x7F, 0x0F, 0xF7, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0x7F,
  0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xF3, 0xF0, 0x7E, 0x3F, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xBF, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0x7F, 0x07, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x01, 0x3F, 0xF3, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF8, 0xFF,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0xFF, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x20, 0x0F, 0xF3, 0xF7, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0xFE,
  0xFF, 0x8F, 0xEF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF9, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x87, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xEF, 0xF0,
  0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC,
  0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0xFF,
  0x07, 0xFB, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF9, 0xFF, 0x9F, 0xF3, 0xFB,
  0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F,
  0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0x0F, 0xE0, 0xFF, 0xFE, 0x1F, 0xC1,
  0xFF, 0xFC, 0x3F, 0x83, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xF0, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0x87, 0xF0, 0x7F,
  0xFF, 0x0F, 0xE0, 0xFE, 0xFC, 0x7F, 0x0F, 0xCF, 0xF8, 0xFE, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xDF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0,
  0xFF, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xE3, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xFC, 0x3F, 0x0F, 0xE7, 0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0xCF, 0xE7,
  0xF8, 0xFE, 0x3F, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0xFF, 0x3F,
  0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F,
  0xF7, 0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFC, 0x3F, 0xF8, 0xFB, 0xF3, 0xF7, 0xF7, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFE, 0x0C, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF1, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF3, 0xFF, 0x7F, 0x0F,
  0xE3, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x0F, 0xF8, 0x3F, 0xBF, 0x87, 0xFC, 0x3F, 0xDF, 0xC3, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xC7, 0xF3, 0xF8, 0xFF, 0xE3, 0xF8,
  0xFE, 0x7F, 0xF1, 0xFC, 0x7F, 0x3E, 0xF9, 0xFC, 0x3F, 0x9F, 0x7C, 0xFE,
  0x1F, 0xCF, 0xBE, 0x7F, 0x0F, 0xE7, 0xDF, 0x3F, 0x83, 0xF7, 0xEF, 0xDF,
  0xC1, 0xFB, 0xF7, 0xEF, 0xC0, 0xFD, 0xFB, 0xF7, 0xE0, 0x7F, 0xF8, 0xFB,
  0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFB, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0x7F, 0x9F, 0xC3, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC3,
  0xFD, 0xFE, 0x1F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0xFF, 0x07,
  0xF8, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE0, 0xFE,
  0x7F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xA0, 0x00, 0x1F, 0x80, 0x17, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF8, 0x01, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_Black45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 33, 12, 2, -32 },
  { 34, 18, 11, 22, 2, -32 },
  { 59, 23, 32, 25, 1, -32 },
  { 151, 18, 37, 22, 2, -34 },
  { 235, 36, 33, 38, 1, -33 },
  { 384, 28, 33, 29, 1, -33 },
  { 500, 8, 11, 11, 2, -32 },
  { 511, 13, 40, 15, 2, -33 },
  { 576, 13, 40, 15, 0, -33 },
  { 641, 20, 20, 21, 1, -34 },
  { 691, 19, 22, 23, 2, -27 },
  { 744, 9, 13, 12, 1, -7 },
  { 759, 12, 6, 15, 1, -15 },
  { 768, 8, 9, 12, 2, -8 },
  { 777, 19, 33, 19, 0, -33 },
  { 856, 19, 33, 22, 2, -33 },
  { 935, 16, 32, 22, 2, -32 },
  { 999, 19, 33, 22, 1, -33 },
  { 1078, 19, 33, 22, 1, -33 },
  { 1157, 21, 32, 22, 1, -32 },
  { 1241, 18, 32, 22, 2, -32 },
  { 1313, 20, 33, 22, 1, -33 },
  { 1396, 19, 32, 22, 2, -32 },
  { 1472, 20, 33, 22, 1, -33 },
  { 1555, 20, 33, 22, 1, -33 },
  { 1638, 8, 26, 13, 2, -25 },
  { 1664, 9, 31, 13, 1, -25 },
  { 1699, 20, 22, 23, 1, -27 },
  { 1754, 19, 16, 23, 2, -24 },
  { 1792, 19, 22, 23, 2, -27 },
  { 1845, 17, 34, 18, 0, -33 },
  { 1918, 31, 36, 35, 2, -33 },
  { 2058, 26, 32, 26, 0, -32 },
  { 2162, 20, 32, 25, 3, -32 },
  { 2242, 20, 33, 23, 2, -33 },
  { 2325, 22, 32, 26, 3, -32 },
  { 2413, 15, 32, 20, 3, -32 },
  { 2473, 15, 32, 20, 3, -32 },
  { 2533, 22, 33, 27, 2, -33 },
  { 2624, 22, 32, 27, 3, -32 },
  { 2712, 14, 32, 16, 1, -32 },
  { 2768, 13, 42, 13, -3, -32 },
  { 2837, 22, 32, 25, 3, -32 },
  { 2925, 16, 32, 19, 3, -32 },
  { 2989, 31, 32, 36, 3, -32 },
  { 3113, 24, 32, 30, 3, -32 },
  { 3209, 24, 33, 28, 2, -33 },
  { 3308, 19, 32, 23, 3, -32 },
  { 3384, 24, 41, 28, 2, -33 },
  { 3507, 22, 32, 25, 3, -32 },
  { 3595, 18, 33, 20, 1, -33 },
  { 3670, 19, 32, 21, 1, -32 },
  { 3746, 21, 32, 26, 3, -32 },
  { 3830, 25, 32, 25, 0, -32 },
  { 3930, 36, 32, 36, 0, -32 },
  { 4074, 23, 32, 23, 0, -32 },
  { 4166, 24, 32, 24, 0, -32 },
  { 4262, 19, 32, 21, 1, -32 },
  { 4338, 11, 41, 14, 2, -33 },
  { 4395, 19, 33, 19, 0, -33 },
  { 4474, 11, 41, 14, 1, -33 },
  { 4531, 24, 21, 24, 0, -32 },
  { 4594, 23, 5, 23, 0, 3 },
  { 4609, 12, 7, 15, 2, -34 },
  { 4620, 19, 25, 22, 1, -25 },
  { 4680, 20, 34, 24, 2, -34 },
  { 4765, 17, 25, 19, 1, -25 },
  { 4819, 20, 34, 24, 1, -34 },
  { 4904, 19, 25, 22, 1, -25 },
  { 4964, 16, 34, 15, 0, -34 },
  { 5032, 20, 36, 24, 1, -25 },
  { 5122, 20, 34, 24, 2, -34 },
  { 5207, 8, 35, 12, 2, -35 },
  { 5242, 12, 46, 12, -2, -35 },
  { 5311, 22, 34, 23, 2, -34 },
  { 5405, 8, 34, 12, 2, -34 },
  { 5439, 31, 25, 36, 2, -25 },
  { 5536, 20, 25, 24, 2, -25 },
  { 5599, 21, 25, 23, 1, -25 },
  { 5665, 20, 36, 24, 2, -25 },
  { 5755, 20, 36, 24, 1, -25 },
  { 5845, 15, 25, 17, 2, -25 },
  { 5892, 16, 25, 18, 1, -25 },
  { 5942, 15, 30, 16, 0, -30 },
  { 5999, 20, 25, 24, 2, -25 },
  { 6062, 22, 25, 22, 0, -25 },
  { 6131, 33, 25, 33, 0, -25 },
  { 6235, 21, 25, 21, 0, -25 },
  { 6301, 22, 36, 22, 0, -25 },
  { 6400, 16, 25, 18, 1, -25 },
  { 6450, 15, 41, 17, 1, -33 },
  { 6527, 7, 45, 19, 6, -35 },
  { 6567, 15, 41, 17, 1, -33 },
  { 6644, 20, 8, 23, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Black45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK45PT7B_H_
