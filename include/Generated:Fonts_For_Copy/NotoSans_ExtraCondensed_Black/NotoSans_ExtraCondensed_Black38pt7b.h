#ifndef _NOTOSANS_EXTRACONDENSED_BLACK38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0x1F, 0xBF, 0x7F, 0xFF, 0xF9,
  0xF0, 0xFE, 0x7F, 0x7E, 0x7F, 0x7E, 0x7F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x03, 0xCF, 0x80,
  0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x87, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7F, 0x83, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFB, 0x8D, 0xF7, 0x03, 0xEE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1D, 0xF0, 0x3B, 0xF0, 0x77, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF1, 0xFF, 0xC0, 0x7C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xC0,
  0x1F, 0xF8, 0x1F, 0x00, 0x7F, 0xE0, 0x78, 0x03, 0xE7, 0xC3, 0xE0, 0x0F,
  0x9F, 0x0F, 0x00, 0x3E, 0x7C, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xE7,
  0xC7, 0x80, 0x0F, 0x9F, 0x3E, 0x00, 0x3E, 0x7C, 0xF0, 0xE0, 0xF9, 0xF7,
  0xCF, 0xE1, 0xFF, 0x9F, 0x7F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF3, 0xE7,
  0xFE, 0x1F, 0x8F, 0x3E, 0x7C, 0x10, 0x7C, 0xF9, 0xF0, 0x01, 0xF3, 0xE7,
  0xC0, 0x07, 0x8F, 0x9F, 0x00, 0x3E, 0x3E, 0x7C, 0x00, 0xF0, 0xF9, 0xF0,
  0x07, 0xC3, 0xE7, 0xC0, 0x1E, 0x0F, 0x9F, 0x00, 0xF8, 0x1F, 0xF8, 0x03,
  0xE0, 0x7F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x02, 0x0F, 0xF8,
  0xFC, 0x3F, 0xF8, 0xFC, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF, 0xFC, 0xFE, 0xFF,
  0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F,
  0xF0, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFD, 0xFC, 0x0F, 0xF9, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7C, 0xF8, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x31, 0xE3, 0x1F, 0x7B, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xCF, 0xC1, 0xF3, 0xE0, 0x38, 0x70, 0x06, 0x18,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x31, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7E, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7F, 0x7F, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF1, 0xCF, 0xC2, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0x78, 0xFE, 0x30, 0x7E, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0xF8,
  0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7F, 0x20, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x87, 0xDF, 0xC3, 0xEF, 0xE3, 0xE7, 0xF1, 0xF3, 0xF9,
  0xF1, 0xFC, 0xF8, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0x83, 0xFF, 0xC7, 0xFF,
  0xCF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x3E, 0x0F, 0xBF, 0x8F, 0xDF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFE, 0xFE, 0xFE, 0x3F, 0x7F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7,
  0xE3, 0xFB, 0xF1, 0xF9, 0xFD, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x3F, 0x8F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F,
  0xBF, 0xBF, 0x8F, 0xDF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF9, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF, 0x87,
  0xFF, 0xE3, 0xFF, 0xFB, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xDF, 0x1F,
  0xEF, 0x83, 0xCF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x7D,
  0xFB, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDC, 0x3F, 0x90,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F,
  0x81, 0xC1, 0xF1, 0xF1, 0xFF, 0xBE, 0x7C, 0x7F, 0xF3, 0xCF, 0x8F, 0xFE,
  0x7D, 0xE3, 0xE7, 0xCF, 0xBC, 0x78, 0xF9, 0xFF, 0x9F, 0x1F, 0x1F, 0xF3,
  0xE3, 0xE3, 0xFE, 0x7C, 0x7C, 0xFF, 0xCF, 0x8F, 0x9F, 0xF9, 0xF1, 0xF3,
  0xDF, 0x3E, 0x3C, 0x7B, 0xE7, 0xCF, 0xCF, 0x3C, 0x7F, 0xFF, 0xC7, 0x8F,
  0xF7, 0xF8, 0xF8, 0xFC, 0x7E, 0x0F, 0x03, 0x07, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x04, 0x03, 0xF8, 0x03, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFB, 0xFE,
  0xFE, 0x3F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF,
  0x9F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF,
  0x00, 0x00, 0x20, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0x1C, 0x7F, 0x02, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x04,
  0xFF, 0x1C, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF9, 0xFD, 0xFF, 0x3F, 0x8F, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F,
  0xEF, 0xE3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x08,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xC1, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0x7E, 0x3F, 0xF7, 0xE3, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF8, 0x7F, 0x3F, 0xC7, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xCF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xBF,
  0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xF8, 0x18, 0x00, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F,
  0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xDF, 0xC3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0x1F,
  0xFF, 0xF7, 0xC7, 0xFF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7E, 0xFB, 0xFF, 0xCF,
  0xBE, 0xFF, 0xF3, 0xEF, 0xBF, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F, 0xF3, 0xFF,
  0xC7, 0xFC, 0xFF, 0xF1, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xE3,
  0xFF, 0xC3, 0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC1, 0xF0, 0xFC, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF3,
  0xFF, 0xDF, 0x9F, 0xFE, 0xFE, 0xFF, 0xF3, 0xF7, 0xFF, 0x9F, 0xBF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F,
  0xC3, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F,
  0xC3, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0xFF,
  0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE,
  0x7F, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0x7F, 0x3F, 0x0F, 0xE7, 0xF1,
  0xFC, 0x7E, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB,
  0xF8, 0x3F, 0x80, 0x00, 0x80, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xBF, 0xCF, 0x7F, 0x02, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFE,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC,
  0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0xFC, 0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0x81, 0xF9, 0xF8, 0x3F,
  0x03, 0xF3, 0xF0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC,
  0x3F, 0x9F, 0x87, 0xF8, 0x7F, 0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF1,
  0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F, 0xC7, 0xE1, 0xF9, 0xF7, 0x9F,
  0xC3, 0xF3, 0xEF, 0x3F, 0x03, 0xF7, 0xDF, 0x7E, 0x07, 0xEF, 0xBE, 0xFC,
  0x0F, 0xDF, 0x7D, 0xF8, 0x1F, 0xBC, 0xFB, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01,
  0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x9F, 0x81,
  0xFB, 0xF8, 0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xBF, 0x83, 0xF9, 0xF8, 0x3F, 0x9F, 0xC3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF7, 0xE0, 0x7E,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F,
  0x81, 0xF9, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFD, 0xF0,
  0x0F, 0x9F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3E, 0x07,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7C, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFF, 0x10, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0x7F, 0x9F, 0x3F, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0xF8, 0x7E, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xFC, 0x7E,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0x8F, 0x80, 0x07,
  0xF8, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xE1, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x81, 0x3F, 0x86, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x9F, 0x9F, 0xEF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFD, 0xF8, 0xFE, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFB, 0xF0, 0xF8, 0xF8, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0x7F, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03,
  0xF0, 0x7F, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0xF3, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0x8F, 0x8F, 0xEF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFD,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFE, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFB, 0xF0, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x80, 0x7F, 0x70, 0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0x80, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xDF, 0xEF, 0xE7, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x1F, 0xFF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFC, 0xFE, 0x3F,
  0x3F, 0x0F, 0xDF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xEF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xFC,
  0x7F, 0x3E, 0xFF, 0xBF, 0xEF, 0xBF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0, 0xFC, 0x3F,
  0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xC0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3,
  0xF1, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7F, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0xF8,
  0x7C, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xFC, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xBF, 0x8F, 0xCF, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x0F, 0x8F, 0x8F, 0xEF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xF1, 0xFD, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFE, 0xFC, 0x7F,
  0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFB, 0xF0, 0xF9, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7E, 0x1B,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC,
  0x00, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x11, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0x7F, 0xDF, 0x1F, 0x9F,
  0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x3F, 0x03, 0xE7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x3F, 0xC3, 0xFF, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7,
  0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE7, 0xFC, 0x7E, 0x3E,
  0x7F, 0xE7, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xBE,
  0xFC, 0x3F, 0x79, 0xEF, 0xC1, 0xF7, 0x9E, 0xF8, 0x1F, 0xF9, 0xEF, 0x81,
  0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0x7F, 0x0F, 0xCF, 0xC7, 0xF3, 0xF9, 0xF8,
  0x7E, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x0F, 0xE7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x2F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x08, 0x0F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x1F, 0xF8, 0xFF, 0x87, 0xF0, 0x3F, 0xE1, 0xFF, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x00, 0xBF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Black38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 27, 10, 2, -27 },
  { 25, 16, 10, 18, 1, -27 },
  { 45, 19, 27, 21, 1, -27 },
  { 110, 15, 31, 19, 2, -29 },
  { 169, 30, 28, 32, 1, -28 },
  { 274, 24, 27, 24, 1, -27 },
  { 355, 7, 10, 10, 1, -27 },
  { 364, 10, 34, 12, 2, -28 },
  { 407, 11, 34, 12, 0, -28 },
  { 454, 18, 17, 18, 0, -29 },
  { 493, 17, 19, 19, 1, -23 },
  { 534, 8, 11, 10, 1, -6 },
  { 545, 10, 6, 12, 1, -13 },
  { 553, 7, 7, 10, 2, -7 },
  { 560, 16, 28, 16, 0, -28 },
  { 616, 16, 28, 19, 1, -28 },
  { 672, 14, 27, 19, 1, -27 },
  { 720, 16, 28, 19, 1, -28 },
  { 776, 16, 28, 19, 1, -28 },
  { 832, 17, 27, 19, 1, -27 },
  { 890, 15, 27, 19, 2, -27 },
  { 941, 17, 28, 19, 1, -28 },
  { 1001, 16, 27, 19, 1, -27 },
  { 1055, 17, 28, 19, 1, -28 },
  { 1115, 17, 28, 19, 1, -28 },
  { 1175, 7, 21, 11, 2, -21 },
  { 1194, 8, 26, 11, 1, -21 },
  { 1220, 17, 19, 19, 1, -23 },
  { 1261, 17, 13, 19, 1, -20 },
  { 1289, 17, 19, 19, 1, -23 },
  { 1330, 15, 28, 15, 0, -28 },
  { 1383, 27, 30, 29, 1, -27 },
  { 1485, 22, 27, 22, 0, -27 },
  { 1560, 18, 27, 21, 2, -27 },
  { 1621, 17, 28, 19, 1, -28 },
  { 1681, 19, 27, 22, 2, -27 },
  { 1746, 13, 27, 17, 2, -27 },
  { 1790, 13, 27, 17, 2, -27 },
  { 1834, 20, 28, 23, 1, -28 },
  { 1904, 19, 27, 23, 2, -27 },
  { 1969, 12, 27, 13, 1, -27 },
  { 2010, 11, 36, 11, -2, -27 },
  { 2060, 19, 27, 21, 2, -27 },
  { 2125, 14, 27, 16, 2, -27 },
  { 2173, 26, 27, 31, 2, -27 },
  { 2261, 21, 27, 25, 2, -27 },
  { 2332, 21, 28, 24, 1, -28 },
  { 2406, 17, 27, 20, 2, -27 },
  { 2464, 21, 34, 24, 1, -28 },
  { 2554, 19, 27, 21, 2, -27 },
  { 2619, 15, 28, 17, 1, -28 },
  { 2672, 16, 27, 17, 1, -27 },
  { 2726, 18, 27, 22, 2, -27 },
  { 2787, 21, 27, 21, 0, -27 },
  { 2858, 31, 27, 31, 0, -27 },
  { 2963, 20, 27, 20, 0, -27 },
  { 3031, 20, 27, 20, 0, -27 },
  { 3099, 16, 27, 18, 1, -27 },
  { 3153, 9, 34, 12, 2, -28 },
  { 3192, 16, 28, 16, 0, -28 },
  { 3248, 9, 34, 12, 1, -28 },
  { 3287, 20, 18, 21, 0, -27 },
  { 3332, 19, 5, 19, 0, 2 },
  { 3344, 9, 6, 13, 2, -29 },
  { 3351, 16, 21, 19, 1, -21 },
  { 3393, 17, 29, 20, 2, -29 },
  { 3455, 15, 21, 16, 1, -21 },
  { 3495, 17, 29, 20, 1, -29 },
  { 3557, 16, 21, 18, 1, -21 },
  { 3599, 13, 29, 12, 0, -29 },
  { 3647, 17, 30, 20, 1, -21 },
  { 3711, 16, 29, 20, 2, -29 },
  { 3769, 6, 29, 10, 2, -29 },
  { 3791, 9, 38, 10, -1, -29 },
  { 3834, 18, 29, 20, 2, -29 },
  { 3900, 6, 29, 10, 2, -29 },
  { 3922, 26, 21, 30, 2, -21 },
  { 3991, 16, 21, 20, 2, -21 },
  { 4033, 17, 21, 20, 1, -21 },
  { 4078, 17, 30, 20, 2, -21 },
  { 4142, 17, 30, 20, 1, -21 },
  { 4206, 12, 21, 14, 2, -21 },
  { 4238, 13, 21, 15, 1, -21 },
  { 4273, 13, 25, 13, 0, -25 },
  { 4314, 16, 21, 20, 2, -21 },
  { 4356, 19, 21, 19, 0, -21 },
  { 4406, 28, 21, 28, 0, -21 },
  { 4480, 18, 21, 18, 0, -21 },
  { 4528, 19, 30, 19, 0, -21 },
  { 4600, 13, 21, 15, 1, -21 },
  { 4635, 13, 34, 14, 0, -28 },
  { 4691, 6, 38, 16, 5, -29 },
  { 4720, 12, 34, 14, 1, -28 },
  { 4771, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Black38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK38PT7B_H_
