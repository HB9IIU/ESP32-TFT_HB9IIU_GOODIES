#ifndef _NOTOSANS_EXTRACONDENSED_BLACK13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xED, 0xB6, 0xC0, 0x34, 0x79, 0xFB, 0xF2, 0x9F,
  0xFF, 0xB4, 0x78, 0x23, 0xFD, 0x4E, 0x38, 0xF7, 0xF3, 0x08, 0x73, 0x1A,
  0x43, 0x58, 0x6B, 0x47, 0x5C, 0x1A, 0xC2, 0xD8, 0xCA, 0x19, 0xC0, 0x3C,
  0x6C, 0x6C, 0x38, 0x7B, 0xFF, 0xCE, 0xFE, 0x7F, 0xED, 0x80, 0x6F, 0x6D,
  0xB6, 0xDB, 0x30, 0xC6, 0x66, 0x33, 0x33, 0x66, 0x6C, 0x32, 0xDF, 0xCC,
  0x7D, 0x20, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x6D, 0xE0, 0xFF, 0xF0,
  0x1C, 0x61, 0x0C, 0x31, 0x86, 0x10, 0xC0, 0x79, 0xF6, 0xFB, 0xEF, 0xB6,
  0xDF, 0x38, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0x7B, 0xF1, 0xC6, 0x18,
  0xC6, 0x3F, 0xFC, 0xF9, 0x70, 0xDE, 0x78, 0x70, 0xFF, 0xF8, 0x18, 0xE3,
  0x9E, 0x5B, 0xFF, 0xC6, 0x18, 0xF7, 0xB1, 0xEF, 0x8C, 0x7F, 0xF0, 0x3D,
  0xD6, 0x16, 0xFF, 0xB6, 0xDF, 0x38, 0xFF, 0xF1, 0xC6, 0x18, 0xE3, 0x0C,
  0x70, 0x79, 0xB6, 0xDE, 0x79, 0xBC, 0xDF, 0x78, 0x79, 0xFE, 0xFB, 0x7D,
  0xB0, 0xDE, 0x70, 0xF0, 0x3C, 0x6C, 0x00, 0xDB, 0xC0, 0x04, 0x77, 0xB8,
  0x3C, 0x30, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x83, 0xC7, 0x7B, 0x88,
  0x00, 0xFE, 0xC6, 0x77, 0x30, 0x0C, 0x60, 0x3F, 0x18, 0x64, 0xE9, 0x6A,
  0xD2, 0xF5, 0xA5, 0xF9, 0xA4, 0x31, 0x07, 0xC0, 0x38, 0x78, 0xF3, 0x66,
  0xCF, 0xDF, 0xF3, 0xC6, 0xFB, 0xFD, 0xFE, 0xFB, 0x7D, 0xFE, 0xF8, 0x3D,
  0xF6, 0x18, 0xE1, 0x86, 0x1F, 0x3C, 0xFB, 0xFC, 0xF3, 0xCF, 0x3D, 0xFE,
  0xF0, 0xFF, 0xCF, 0xFC, 0xCF, 0xF0, 0xFF, 0xCC, 0xFC, 0xCC, 0xC0, 0x3E,
  0xE9, 0x83, 0x0E, 0xEC, 0xD9, 0xBF, 0x3E, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCC, 0xF6, 0x66, 0x66, 0x67, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFE, 0xCF, 0x6F, 0xBC, 0xF3, 0xED, 0xB7, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF,
  0xF0, 0xE3, 0xF3, 0xFD, 0xFE, 0xBF, 0xDF, 0xEF, 0x77, 0xB3, 0xD9, 0x80,
  0xE7, 0xCF, 0xDF, 0xBF, 0x7B, 0xF7, 0xE7, 0xCE, 0x3C, 0x7E, 0x66, 0x67,
  0xE7, 0x66, 0x66, 0x7E, 0x3C, 0xFF, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x3C,
  0x7E, 0x66, 0x67, 0xE7, 0x67, 0x66, 0x7E, 0x3C, 0x0C, 0x07, 0xFB, 0xED,
  0xB6, 0xFB, 0xCD, 0xB6, 0xCC, 0x7D, 0xEE, 0x1C, 0x78, 0x79, 0xFE, 0xF8,
  0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x78, 0xC7, 0xCD, 0xBB, 0x66, 0xCD, 0x8F, 0x1C, 0x38, 0xCC, 0xF9,
  0x99, 0xBB, 0x37, 0x67, 0xEC, 0xF7, 0x1E, 0xE3, 0xDC, 0x33, 0x80, 0xEC,
  0xD9, 0xE1, 0xC3, 0x87, 0x1F, 0x36, 0xCE, 0xEE, 0xD9, 0xB1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xFF, 0xF1, 0x8E, 0x31, 0xC6, 0x3F, 0xFC, 0xFE, 0x49,
  0x24, 0x92, 0x70, 0xC3, 0x18, 0x43, 0x18, 0x43, 0x18, 0xFD, 0xB6, 0xDB,
  0x6D, 0xF0, 0x10, 0x70, 0xE3, 0x66, 0xD8, 0xC0, 0xFE, 0xCC, 0x79, 0x73,
  0xDF, 0xCF, 0xF7, 0xC0, 0xC6, 0x31, 0xFD, 0xEF, 0x7B, 0xFF, 0xC0, 0x7B,
  0x79, 0xCE, 0x3D, 0xE0, 0x0C, 0x30, 0xDF, 0x7F, 0xBE, 0xFB, 0x7D, 0xF0,
  0x79, 0xBC, 0xFF, 0xE1, 0xF7, 0xC0, 0x3B, 0x99, 0xEF, 0x31, 0x8C, 0x63,
  0x00, 0x7D, 0xFE, 0xFB, 0xED, 0xF7, 0xC3, 0x7D, 0xE0, 0xC6, 0x31, 0xFF,
  0xEF, 0x7B, 0xDE, 0xC0, 0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xC3, 0x0C, 0x37, 0xDB, 0xCF, 0x3E, 0xDB, 0x70, 0xFF, 0xFF,
  0xF0, 0xBF, 0x7F, 0xF6, 0xFB, 0x3D, 0x9E, 0xCF, 0x66, 0xBF, 0xF7, 0xBD,
  0xEF, 0x60, 0x79, 0xBE, 0xFB, 0x6D, 0xF3, 0x80, 0xFE, 0xF7, 0xBD, 0xFF,
  0xF8, 0xC6, 0x00, 0x7D, 0xFE, 0xFB, 0xED, 0xF7, 0xC3, 0x0C, 0x30, 0xBF,
  0xCC, 0xCC, 0xC0, 0x7E, 0xB8, 0xE1, 0xFF, 0xC0, 0x66, 0xFF, 0x66, 0x67,
  0x70, 0xDE, 0xF7, 0xBD, 0xFF, 0xE0, 0xCD, 0xB6, 0xDE, 0x78, 0xE3, 0x00,
  0xDD, 0xF7, 0x67, 0xD9, 0xFE, 0x77, 0x9D, 0xC7, 0x70, 0xED, 0xE7, 0x8E,
  0x79, 0xEC, 0xC0, 0xCD, 0xB6, 0xDE, 0x78, 0xE3, 0x0C, 0x71, 0x80, 0xFF,
  0xCC, 0xE6, 0x7F, 0xE0, 0x3B, 0x98, 0xC6, 0x71, 0x8C, 0x61, 0xCE, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0x18, 0xC7, 0x1D, 0xCC, 0x67, 0x38, 0x67, 0xF8,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Black13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 6, 3, 6, 0, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 5, 11, 6, 1, -10 },
  { 22, 11, 9, 11, 0, -9 },
  { 35, 8, 9, 8, 0, -9 },
  { 44, 3, 3, 3, 0, -9 },
  { 46, 3, 12, 4, 1, -10 },
  { 51, 4, 12, 4, 0, -10 },
  { 57, 6, 6, 6, 0, -10 },
  { 62, 6, 7, 7, 0, -8 },
  { 68, 3, 4, 4, 0, -2 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 2, 2, 4, 1, -2 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 5, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 6, 9, 6, 0, -9 },
  { 106, 6, 9, 6, 0, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 6, 9, 6, 0, -9 },
  { 133, 6, 9, 6, 0, -9 },
  { 140, 6, 9, 6, 0, -9 },
  { 147, 2, 7, 4, 1, -7 },
  { 149, 3, 9, 4, 0, -7 },
  { 153, 6, 7, 7, 0, -8 },
  { 159, 6, 5, 7, 0, -7 },
  { 163, 6, 7, 7, 0, -8 },
  { 169, 5, 9, 5, 0, -9 },
  { 175, 10, 10, 10, 0, -9 },
  { 188, 7, 9, 7, 0, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 6, 9, 7, 0, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 4, 9, 6, 1, -9 },
  { 222, 4, 9, 6, 1, -9 },
  { 227, 7, 9, 8, 0, -9 },
  { 235, 6, 9, 8, 1, -9 },
  { 242, 4, 9, 5, 0, -9 },
  { 247, 4, 12, 4, -1, -9 },
  { 253, 6, 9, 7, 1, -9 },
  { 260, 4, 9, 6, 1, -9 },
  { 265, 9, 9, 10, 1, -9 },
  { 276, 7, 9, 9, 1, -9 },
  { 284, 8, 9, 8, 0, -9 },
  { 293, 5, 9, 7, 1, -9 },
  { 299, 8, 11, 8, 0, -9 },
  { 310, 6, 9, 7, 1, -9 },
  { 317, 6, 9, 6, 0, -9 },
  { 324, 6, 9, 6, 0, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 11, 9, 11, 0, -9 },
  { 359, 7, 9, 7, 0, -9 },
  { 367, 7, 9, 7, 0, -9 },
  { 375, 6, 9, 6, 0, -9 },
  { 382, 3, 12, 4, 1, -10 },
  { 387, 5, 9, 6, 0, -9 },
  { 393, 3, 12, 4, 0, -10 },
  { 398, 7, 6, 7, 0, -9 },
  { 404, 7, 1, 7, 0, 1 },
  { 405, 3, 2, 4, 1, -10 },
  { 406, 6, 7, 6, 0, -7 },
  { 412, 5, 10, 7, 1, -10 },
  { 419, 5, 7, 6, 0, -7 },
  { 424, 6, 10, 7, 0, -10 },
  { 432, 6, 7, 6, 0, -7 },
  { 438, 5, 10, 4, 0, -10 },
  { 445, 6, 10, 7, 0, -7 },
  { 453, 5, 10, 7, 1, -10 },
  { 460, 2, 10, 3, 1, -10 },
  { 463, 4, 13, 3, -1, -10 },
  { 470, 6, 10, 7, 1, -10 },
  { 478, 2, 10, 3, 1, -10 },
  { 481, 9, 7, 10, 1, -7 },
  { 489, 5, 7, 7, 1, -7 },
  { 494, 6, 7, 7, 0, -7 },
  { 500, 5, 10, 7, 1, -7 },
  { 507, 6, 10, 7, 0, -7 },
  { 515, 4, 7, 5, 1, -7 },
  { 519, 5, 7, 5, 0, -7 },
  { 524, 4, 9, 5, 0, -9 },
  { 529, 5, 7, 7, 1, -7 },
  { 534, 6, 7, 6, 0, -7 },
  { 540, 10, 7, 10, 0, -7 },
  { 549, 6, 7, 6, 0, -7 },
  { 555, 6, 10, 6, 0, -7 },
  { 563, 5, 7, 5, 0, -7 },
  { 568, 5, 11, 5, 0, -9 },
  { 575, 2, 13, 5, 2, -10 },
  { 579, 5, 11, 5, 0, -9 },
  { 586, 6, 3, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Black13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK13PT7B_H_
