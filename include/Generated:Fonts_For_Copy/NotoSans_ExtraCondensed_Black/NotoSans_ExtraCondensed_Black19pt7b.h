#ifndef _NOTOSANS_EXTRACONDENSED_BLACK19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0,
  0x1D, 0x86, 0x61, 0xB8, 0x6E, 0x7F, 0xDF, 0xF1, 0xB0, 0xEC, 0xFF, 0xFF,
  0xF3, 0x70, 0xD8, 0x36, 0x1D, 0x80, 0x10, 0x7E, 0xFE, 0xF6, 0xD0, 0xF0,
  0x7C, 0x3E, 0x1E, 0x17, 0x96, 0xFE, 0xFC, 0x10, 0x10, 0x38, 0x30, 0xF8,
  0xC1, 0xB1, 0x83, 0x67, 0x0E, 0xCC, 0x0D, 0x98, 0x1B, 0x6F, 0x3E, 0xDF,
  0x3B, 0xB6, 0x06, 0xEC, 0x1C, 0xD8, 0x31, 0xB0, 0x63, 0xE1, 0xC3, 0x80,
  0x0E, 0x03, 0xF0, 0x3F, 0x83, 0x38, 0x3B, 0x83, 0xF0, 0x1E, 0xF7, 0xEF,
  0x7F, 0xEF, 0x7E, 0xF3, 0xC7, 0xFC, 0x7F, 0xE3, 0xEF, 0xFF, 0xFE, 0x3B,
  0x9C, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xCE, 0x38, 0xE3, 0x9C,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9D, 0xCE, 0xE0, 0x1C, 0x0E, 0x17,
  0x4F, 0xEF, 0xF8, 0xE0, 0xF8, 0xEE, 0x22, 0x00, 0x38, 0x38, 0x38, 0xFF,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xFF, 0x80,
  0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0x38, 0x7C, 0xFE, 0xEE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xEE, 0xFE, 0x7E, 0x3C, 0x0E, 0x3C, 0xFB, 0xFF, 0xEF, 0xD7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x1C, 0x7E, 0xFF, 0x67, 0x07, 0x07, 0x0F,
  0x0E, 0x1C, 0x3C, 0x78, 0x7F, 0xFF, 0xFF, 0x38, 0xFE, 0xFE, 0x8E, 0x0E,
  0x1E, 0x7C, 0x7C, 0x1E, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0x07, 0x07, 0x83,
  0xC3, 0xE1, 0xF1, 0xF8, 0xDC, 0xEE, 0xE7, 0x7F, 0xFF, 0xE0, 0xE0, 0x70,
  0x38, 0x7E, 0xFE, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0xFE, 0x0F, 0x0F, 0x0F,
  0xFE, 0xFE, 0xFC, 0x1E, 0x3E, 0x7E, 0xF0, 0xE0, 0xFC, 0xFE, 0xFF, 0xE7,
  0xE7, 0xE7, 0xFE, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x38, 0x7E, 0xFE, 0xEE, 0xEE,
  0xFE, 0x7C, 0x7C, 0xFE, 0xE7, 0xE7, 0xEF, 0xFE, 0x7C, 0x38, 0x7C, 0xFE,
  0xEE, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x06, 0x0E, 0xBE, 0xFC, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0x03,
  0x1F, 0x7E, 0xF8, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0xFC, 0x1F, 0x1F, 0x7E, 0xF8, 0xE0,
  0x80, 0x39, 0xFF, 0xFA, 0x70, 0xE3, 0xC7, 0x1C, 0x38, 0x00, 0x01, 0xC3,
  0x87, 0x00, 0x07, 0x00, 0xFE, 0x0E, 0x1C, 0xC0, 0x6E, 0xFB, 0xE6, 0xCF,
  0x76, 0x7B, 0x33, 0xD9, 0x9E, 0xED, 0xF3, 0xFD, 0xDC, 0xC6, 0x00, 0x3C,
  0x60, 0x7F, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xB8, 0x77, 0x0E,
  0xE1, 0xDC, 0x73, 0xCF, 0xF9, 0xFF, 0x38, 0xEF, 0x1F, 0xE3, 0xC0, 0xF8,
  0x7F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3B, 0xF9, 0xFE, 0xE7, 0xF3, 0xF9, 0xFF,
  0xFF, 0xF7, 0xF0, 0x1E, 0x3F, 0x7F, 0xF1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0xFF, 0x7F, 0x3F, 0xF8, 0x7F, 0x3F, 0xDC, 0xFE, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFF, 0xEF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x3F, 0x7E, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1C, 0x3F, 0x7E, 0xFD, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x0F,
  0x1F, 0xDF, 0xFE, 0x1F, 0x07, 0x03, 0x9F, 0xCF, 0xE7, 0xF1, 0xFC, 0xEF,
  0xF7, 0xF9, 0xFC, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0xFF, 0xF7, 0xCE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0xFF, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xFF, 0xFF, 0x80, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xEF,
  0x3B, 0x8F, 0xC3, 0xF8, 0xFE, 0x3B, 0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF,
  0xC0, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xF7,
  0xFD, 0xB7, 0xEF, 0xBF, 0x7D, 0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C,
  0xF1, 0xFC, 0x7F, 0x9F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xBF, 0xEF, 0xF9,
  0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xF0, 0x1E, 0x0F, 0xC7, 0xFB, 0xCF, 0xE3,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x7F, 0x8F, 0xC0,
  0xF8, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFE, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x1E, 0x0F, 0xC7, 0xFB, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x7F, 0x8F, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0xF8, 0x7F, 0x3F, 0xDC, 0xEE, 0x77, 0x3B, 0xFD, 0xFC, 0xFE, 0x77, 0x3B,
  0xDC, 0xEE, 0x7F, 0x1C, 0x38, 0xFF, 0xFF, 0x2E, 0x1E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x3F, 0xFF, 0xDF, 0x00, 0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xF7, 0xF1, 0xF0, 0xE1,
  0xFE, 0x39, 0xC7, 0x38, 0xE7, 0x3C, 0xE7, 0x0E, 0xE1, 0xDC, 0x3B, 0x87,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x3B, 0x9E, 0x77, 0x3D, 0xEE, 0xFB, 0x9D, 0xF7, 0x3B, 0x6E, 0x36, 0xDC,
  0x7D, 0xF8, 0xFB, 0xE1, 0xF3, 0xC3, 0xE7, 0x83, 0x8F, 0x00, 0xF3, 0x9C,
  0xE7, 0x79, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0xC3, 0xF1,
  0xDE, 0x73, 0xBC, 0xF0, 0xE1, 0xFC, 0xF7, 0x39, 0xCE, 0x3F, 0x0F, 0xC3,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xFF, 0x7F,
  0xBF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x06,
  0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8,
  0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0E, 0xC7, 0x39, 0xC6, 0xE1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x9E, 0x1C, 0x7F, 0x3F, 0x27, 0x1F, 0x7F,
  0x77, 0xF7, 0x77, 0x7F, 0x7B, 0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0xFE, 0x38, 0xFF, 0xF7, 0x2E, 0x1C,
  0x38, 0x70, 0xF7, 0xFD, 0xF0, 0x07, 0x07, 0x07, 0x37, 0x7F, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x38, 0x7E, 0xFE, 0xE6, 0xE7,
  0xFF, 0xFF, 0xE0, 0xE2, 0xFE, 0x7E, 0x08, 0x7D, 0xF3, 0x87, 0xDF, 0xBF,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x37, 0x7F, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x77, 0x07, 0x8F, 0xFE, 0xFE, 0x30,
  0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x03, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFC, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x7E, 0x77, 0x7B, 0xB9, 0xF8, 0xFC, 0x7F, 0x3F, 0x9C, 0xEE, 0x77,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCE, 0x67, 0xFF, 0xFF, 0xFF,
  0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9,
  0xCE, 0xCC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0x38, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C, 0xCC,
  0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xEE, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x37, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0x07, 0xCF, 0xFF, 0xFF, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x00, 0x38, 0xFD, 0xF7, 0x17, 0x8F, 0x8F, 0x87, 0xEF,
  0xFF, 0xF0, 0x30, 0xC7, 0xFF, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0xDF, 0x3C,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7B, 0xE3,
  0xF1, 0xDC, 0xEE, 0xE7, 0x73, 0xB8, 0xDC, 0x7C, 0x3E, 0x0F, 0x07, 0x00,
  0xE7, 0x9F, 0x9E, 0x76, 0x79, 0x9D, 0xEE, 0x77, 0xB9, 0xFF, 0xE7, 0xFF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x00, 0xF7, 0xBB, 0x9D, 0xC7,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x77, 0x3B, 0xBD, 0xE0, 0xE3, 0xF9, 0xDC,
  0xEE, 0xE7, 0x71, 0xB8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x03, 0x81, 0xC3,
  0xC1, 0xE0, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xC7, 0x0E, 0x38, 0x7F, 0xFF,
  0xF8, 0x0E, 0x3C, 0xF9, 0xC3, 0x87, 0x0E, 0x7C, 0xF1, 0xF0, 0xE1, 0xC3,
  0x87, 0x0E, 0x1F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xE3, 0xE1,
  0xC3, 0x87, 0x0E, 0x1F, 0x1E, 0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x7C, 0xF0,
  0x41, 0xF9, 0xFF, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_Black19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 8, 15, 9, 1, -14 },
  { 45, 15, 14, 16, 0, -14 },
  { 72, 12, 14, 12, 0, -14 },
  { 93, 3, 5, 5, 1, -14 },
  { 95, 5, 17, 6, 1, -14 },
  { 106, 5, 17, 6, 0, -14 },
  { 117, 9, 9, 9, 0, -15 },
  { 128, 8, 9, 10, 1, -11 },
  { 137, 3, 6, 5, 1, -3 },
  { 140, 5, 3, 6, 1, -7 },
  { 142, 3, 3, 5, 1, -3 },
  { 144, 8, 14, 8, 0, -14 },
  { 158, 8, 14, 9, 1, -14 },
  { 172, 7, 14, 9, 1, -14 },
  { 185, 8, 14, 9, 0, -14 },
  { 199, 8, 14, 9, 1, -14 },
  { 213, 9, 14, 9, 0, -14 },
  { 229, 8, 14, 9, 1, -14 },
  { 243, 8, 14, 9, 1, -14 },
  { 257, 8, 14, 9, 1, -14 },
  { 271, 8, 14, 9, 1, -14 },
  { 285, 8, 14, 9, 1, -14 },
  { 299, 3, 11, 5, 1, -11 },
  { 304, 3, 14, 5, 1, -11 },
  { 310, 8, 10, 10, 1, -12 },
  { 320, 8, 7, 10, 1, -10 },
  { 327, 8, 10, 10, 1, -12 },
  { 337, 7, 14, 8, 0, -14 },
  { 350, 13, 15, 15, 1, -14 },
  { 375, 11, 14, 11, 0, -14 },
  { 395, 9, 14, 11, 1, -14 },
  { 411, 8, 14, 10, 1, -14 },
  { 425, 9, 14, 11, 1, -14 },
  { 441, 7, 14, 8, 1, -14 },
  { 454, 7, 14, 8, 1, -14 },
  { 467, 9, 14, 11, 1, -14 },
  { 483, 9, 14, 12, 1, -14 },
  { 499, 6, 14, 7, 0, -14 },
  { 510, 5, 18, 6, -1, -14 },
  { 522, 10, 14, 10, 1, -14 },
  { 540, 7, 14, 8, 1, -14 },
  { 553, 13, 14, 15, 1, -14 },
  { 576, 10, 14, 12, 1, -14 },
  { 594, 10, 14, 12, 1, -14 },
  { 612, 8, 14, 10, 1, -14 },
  { 626, 10, 17, 12, 1, -14 },
  { 648, 9, 14, 10, 1, -14 },
  { 664, 7, 14, 9, 1, -14 },
  { 677, 8, 14, 9, 0, -14 },
  { 691, 9, 14, 11, 1, -14 },
  { 707, 11, 14, 11, 0, -14 },
  { 727, 15, 14, 15, 0, -14 },
  { 754, 10, 14, 10, 0, -14 },
  { 772, 10, 14, 10, 0, -14 },
  { 790, 9, 14, 9, 0, -14 },
  { 806, 4, 17, 6, 1, -14 },
  { 815, 8, 14, 8, 0, -14 },
  { 829, 5, 17, 6, 0, -14 },
  { 840, 10, 9, 10, 0, -14 },
  { 852, 10, 3, 10, 0, 1 },
  { 856, 5, 3, 6, 1, -15 },
  { 858, 8, 11, 9, 0, -11 },
  { 869, 8, 14, 10, 1, -14 },
  { 883, 7, 11, 8, 1, -11 },
  { 893, 8, 14, 10, 1, -14 },
  { 907, 8, 11, 9, 1, -11 },
  { 918, 7, 15, 6, 0, -15 },
  { 932, 8, 16, 10, 1, -11 },
  { 948, 8, 14, 10, 1, -14 },
  { 962, 3, 15, 5, 1, -15 },
  { 968, 5, 20, 5, -1, -15 },
  { 981, 9, 14, 10, 1, -14 },
  { 997, 3, 14, 5, 1, -14 },
  { 1003, 13, 11, 15, 1, -11 },
  { 1021, 8, 11, 10, 1, -11 },
  { 1032, 8, 11, 10, 1, -11 },
  { 1043, 8, 16, 10, 1, -11 },
  { 1059, 8, 16, 10, 1, -11 },
  { 1075, 6, 11, 7, 1, -11 },
  { 1084, 7, 11, 8, 0, -11 },
  { 1094, 6, 13, 7, 0, -13 },
  { 1104, 8, 11, 10, 1, -11 },
  { 1115, 9, 11, 9, 0, -11 },
  { 1128, 14, 11, 14, 0, -11 },
  { 1148, 9, 11, 9, 0, -11 },
  { 1161, 9, 16, 9, 0, -11 },
  { 1179, 7, 11, 8, 0, -11 },
  { 1189, 7, 17, 7, 0, -14 },
  { 1204, 2, 19, 8, 3, -15 },
  { 1209, 7, 17, 7, 0, -14 },
  { 1224, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Black19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK19PT7B_H_
