#ifndef _NOTOSANS_EXTRACONDENSED_BLACK11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black11pt7bBitmaps[] PROGMEM = {
  0x00, 0xE9, 0x24, 0x16, 0xDA, 0xD6, 0x28, 0xAF, 0xFF, 0x7B, 0xF5, 0x14,
  0x33, 0xF8, 0xE3, 0x95, 0xE6, 0x20, 0x66, 0x7A, 0x3D, 0x1F, 0x66, 0xB8,
  0xF4, 0x4A, 0x66, 0x30, 0xF1, 0xE3, 0x87, 0x7B, 0xBF, 0x3F, 0xD4, 0x36,
  0x44, 0xCC, 0x46, 0x63, 0xC9, 0xB6, 0xDB, 0x58, 0x27, 0xCD, 0xB5, 0x00,
  0x21, 0x3F, 0xF2, 0x10, 0x69, 0x60, 0xFC, 0x5C, 0x18, 0x8C, 0x46, 0x31,
  0x18, 0x73, 0xF7, 0xBD, 0xED, 0xEE, 0x37, 0xF5, 0x11, 0x11, 0x77, 0xC6,
  0x33, 0x33, 0xFF, 0xF3, 0xC6, 0xE7, 0x8F, 0xFE, 0x19, 0xCE, 0xBD, 0xFC,
  0x63, 0xFF, 0x8E, 0xB3, 0xFE, 0x3B, 0xD1, 0xFD, 0xED, 0xEE, 0xFF, 0xC6,
  0x23, 0x19, 0x8C, 0x73, 0xD6, 0xE7, 0xEF, 0x6F, 0x73, 0xF7, 0xB7, 0x8E,
  0xEE, 0xE0, 0xB0, 0x68, 0x06, 0xB6, 0x08, 0xFD, 0xE3, 0x84, 0xFF, 0xC1,
  0xF0, 0x87, 0x0E, 0x7E, 0x40, 0xFF, 0x33, 0x60, 0x66, 0x3C, 0x62, 0x5D,
  0xF5, 0xF5, 0xFD, 0x5A, 0x62, 0x1C, 0x30, 0xE7, 0x9E, 0x69, 0xFC, 0xF3,
  0xF7, 0xB7, 0xEF, 0x6F, 0xFE, 0x3B, 0xD9, 0x8C, 0x31, 0xE7, 0xE7, 0xB7,
  0xBD, 0xEF, 0xDE, 0xFF, 0x7F, 0xBF, 0xFF, 0x7F, 0xB6, 0x3D, 0xF6, 0x37,
  0xDD, 0xB7, 0xCF, 0xDE, 0xF7, 0xFF, 0xEF, 0x7B, 0xF6, 0x66, 0x66, 0x6F,
  0x33, 0x33, 0x33, 0x33, 0x2E, 0xDF, 0xBD, 0xCF, 0x7B, 0x7B, 0xCC, 0xCC,
  0xCC, 0xFF, 0xC7, 0xDF, 0xBD, 0x7A, 0xF7, 0xED, 0xCB, 0xCF, 0x3E, 0xEB,
  0xBE, 0xF9, 0xE7, 0x39, 0xF6, 0xF3, 0xCD, 0xB7, 0xCE, 0xEF, 0xDF, 0xFC,
  0xCC, 0x39, 0xF6, 0xF3, 0xCD, 0xB7, 0xCE, 0x0C, 0x30, 0xE7, 0xB5, 0xEF,
  0x7B, 0xDB, 0x7F, 0xB0, 0xC3, 0x0F, 0xFE, 0xFF, 0xC8, 0x42, 0x10, 0x84,
  0x9C, 0xE7, 0x39, 0xCF, 0xFE, 0xCF, 0x34, 0xDA, 0x79, 0xE3, 0x8C, 0xC9,
  0xEC, 0xF7, 0x4A, 0xE7, 0x73, 0xB9, 0xDC, 0xEE, 0xD9, 0xE7, 0x0C, 0x31,
  0xE7, 0xB3, 0xCD, 0x67, 0x9C, 0x30, 0xC3, 0x0C, 0xFF, 0xCC, 0x66, 0x33,
  0xFF, 0xFB, 0x6D, 0xB6, 0xFC, 0xC2, 0x18, 0xC2, 0x18, 0xC3, 0xED, 0xB6,
  0xDB, 0xFC, 0x30, 0xC7, 0x9E, 0xCC, 0xFC, 0xE0, 0x72, 0xDF, 0xBD, 0xBC,
  0x88, 0xFF, 0x99, 0xFF, 0x7B, 0xB1, 0x87, 0x38, 0x18, 0xDE, 0xBD, 0xED,
  0x6D, 0x72, 0xFF, 0xF4, 0xBC, 0x76, 0xF6, 0x66, 0x66, 0x6A, 0xF7, 0xB7,
  0xBC, 0x6F, 0x60, 0x88, 0xFF, 0xBB, 0xBB, 0x71, 0x55, 0x40, 0x71, 0x55,
  0x5E, 0x84, 0x2F, 0x6E, 0x7A, 0xD3, 0xFF, 0xFF, 0xFE, 0xDD, 0xBB, 0x76,
  0xC0, 0xFF, 0xBB, 0xBB, 0x7A, 0xF3, 0xB7, 0xB8, 0xFF, 0x99, 0xFB, 0x88,
  0x80, 0x6A, 0xF7, 0xB7, 0xBC, 0x63, 0x18, 0xFE, 0x49, 0x00, 0x7D, 0xE7,
  0xBF, 0x4F, 0x44, 0x47, 0x70, 0xBB, 0xBB, 0xFD, 0xDE, 0xD6, 0xE7, 0x18,
  0xDB, 0xDB, 0x5F, 0x7E, 0x7E, 0x66, 0xDB, 0x9C, 0xE5, 0x6C, 0xDA, 0xDE,
  0xE7, 0x18, 0xCC, 0x40, 0xF3, 0x66, 0xCF, 0x36, 0x66, 0xEE, 0x66, 0x73,
  0xFF, 0xE0, 0xC6, 0x66, 0x77, 0x66, 0xEC, 0xEF, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 5, 3, 5, 0, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 9, 8, 9, 0, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 2, 3, 3, 0, -8 },
  { 35, 4, 10, 4, 0, -8 },
  { 40, 3, 10, 4, 0, -8 },
  { 44, 5, 5, 5, 0, -8 },
  { 48, 5, 6, 6, 0, -7 },
  { 52, 3, 4, 3, 0, -2 },
  { 54, 3, 2, 4, 0, -4 },
  { 55, 3, 2, 3, 0, -2 },
  { 56, 5, 8, 5, 0, -8 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 4, 8, 5, 0, -8 },
  { 70, 5, 8, 5, 0, -8 },
  { 75, 5, 8, 5, 0, -8 },
  { 80, 5, 8, 5, 0, -8 },
  { 85, 4, 8, 5, 1, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 5, 8, 5, 0, -8 },
  { 99, 5, 8, 5, 0, -8 },
  { 104, 5, 8, 5, 0, -8 },
  { 109, 2, 6, 3, 1, -6 },
  { 111, 3, 8, 3, 0, -6 },
  { 114, 5, 6, 6, 0, -7 },
  { 118, 5, 4, 6, 0, -6 },
  { 121, 5, 6, 6, 0, -7 },
  { 125, 4, 8, 4, 0, -8 },
  { 129, 8, 9, 8, 0, -8 },
  { 138, 6, 8, 6, 0, -8 },
  { 144, 5, 8, 6, 1, -8 },
  { 149, 5, 8, 6, 0, -8 },
  { 154, 5, 8, 6, 1, -8 },
  { 159, 3, 8, 5, 1, -8 },
  { 162, 3, 8, 5, 1, -8 },
  { 165, 6, 8, 7, 0, -8 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 4, 8, 4, 0, -8 },
  { 180, 4, 10, 3, -1, -8 },
  { 185, 5, 8, 6, 1, -8 },
  { 190, 4, 8, 5, 1, -8 },
  { 194, 7, 8, 9, 1, -8 },
  { 201, 6, 8, 7, 1, -8 },
  { 207, 6, 8, 7, 0, -8 },
  { 213, 4, 8, 6, 1, -8 },
  { 217, 6, 10, 7, 0, -8 },
  { 225, 5, 8, 6, 1, -8 },
  { 230, 5, 8, 5, 0, -8 },
  { 235, 5, 8, 5, 0, -8 },
  { 240, 5, 8, 6, 1, -8 },
  { 245, 6, 8, 6, 0, -8 },
  { 251, 9, 8, 9, 0, -8 },
  { 260, 6, 8, 6, 0, -8 },
  { 266, 6, 8, 6, 0, -8 },
  { 272, 5, 8, 5, 0, -8 },
  { 277, 3, 10, 3, 0, -8 },
  { 281, 5, 8, 5, 0, -8 },
  { 286, 3, 10, 3, 0, -8 },
  { 290, 6, 5, 6, 0, -8 },
  { 294, 6, 1, 6, 0, 1 },
  { 295, 3, 1, 4, 0, -8 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 4, 8, 6, 1, -8 },
  { 304, 5, 6, 5, 0, -6 },
  { 308, 5, 8, 6, 0, -8 },
  { 313, 5, 6, 5, 0, -6 },
  { 317, 4, 8, 4, 0, -8 },
  { 321, 5, 9, 6, 0, -6 },
  { 327, 4, 8, 6, 1, -8 },
  { 331, 2, 9, 3, 0, -9 },
  { 334, 2, 12, 3, 0, -9 },
  { 337, 5, 8, 6, 1, -8 },
  { 342, 1, 8, 3, 1, -8 },
  { 343, 7, 6, 9, 1, -6 },
  { 349, 4, 6, 6, 1, -6 },
  { 352, 5, 6, 6, 0, -6 },
  { 356, 4, 9, 6, 1, -6 },
  { 361, 5, 9, 6, 0, -6 },
  { 367, 3, 6, 4, 1, -6 },
  { 370, 4, 6, 4, 0, -6 },
  { 373, 4, 7, 4, 0, -7 },
  { 377, 4, 6, 6, 1, -6 },
  { 380, 5, 6, 5, 0, -6 },
  { 384, 8, 6, 8, 0, -6 },
  { 390, 5, 6, 5, 0, -6 },
  { 394, 5, 9, 5, 0, -6 },
  { 400, 4, 6, 4, 0, -6 },
  { 403, 4, 10, 4, 0, -8 },
  { 408, 1, 11, 5, 2, -8 },
  { 410, 4, 10, 4, 0, -8 },
  { 415, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Black11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK11PT7B_H_
