#ifndef _NOTOSANS_EXTRACONDENSED_BLACK15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xFC, 0xDF, 0x7D, 0xF6, 0x16, 0x16, 0x36, 0x7F, 0x7F,
  0x34, 0xFF, 0xFF, 0x2C, 0x6C, 0x6C, 0x23, 0xFF, 0xB8, 0xE1, 0xE3, 0xCB,
  0xBF, 0xE2, 0x08, 0x71, 0x87, 0x98, 0xD9, 0x0D, 0xB0, 0xDB, 0x67, 0xEF,
  0x36, 0xB0, 0x5B, 0x0C, 0xB0, 0xCF, 0x18, 0xE0, 0x1C, 0x0F, 0x87, 0x61,
  0xF8, 0x3C, 0x0E, 0x67, 0xFB, 0xBE, 0xE7, 0x1F, 0xE7, 0xFC, 0xFF, 0x76,
  0xEC, 0xCC, 0xCC, 0xCC, 0xE6, 0x70, 0xE6, 0x73, 0x33, 0x33, 0x33, 0x76,
  0xE0, 0x38, 0xAF, 0xF9, 0xC6, 0xCD, 0x80, 0x30, 0xC3, 0x3F, 0xFC, 0xC3,
  0x00, 0x6D, 0xF0, 0xFF, 0xFC, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x1C, 0x61,
  0x8C, 0x00, 0x73, 0xED, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0xE7, 0x80, 0x19,
  0xDF, 0xFD, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xF9, 0xB0, 0x60, 0xC3, 0x8E,
  0x18, 0x71, 0xFF, 0xF8, 0x39, 0xF9, 0x38, 0x63, 0xC7, 0x0F, 0x07, 0x8F,
  0xFB, 0xF0, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0xB3, 0x7F, 0xFE, 0x18, 0x30,
  0xFB, 0xEF, 0xB0, 0xFB, 0xE1, 0xC7, 0x9F, 0xEF, 0x80, 0x1C, 0x79, 0xC3,
  0x07, 0xCF, 0xFB, 0xB7, 0x6E, 0xFC, 0xF0, 0xFF, 0xFF, 0xC6, 0x18, 0xE3,
  0x0C, 0x71, 0x8E, 0x00, 0x38, 0xF9, 0xBB, 0x77, 0xC7, 0x1F, 0x37, 0xE6,
  0xFD, 0xF0, 0x38, 0xF9, 0xBF, 0x7E, 0xEF, 0xDD, 0x87, 0x0C, 0xF9, 0xE0,
  0xF0, 0x3F, 0x6C, 0x00, 0x1B, 0x7C, 0x02, 0x1D, 0xF7, 0x07, 0x83, 0xC1,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x7B, 0x88, 0x00, 0x7B,
  0xF5, 0xC7, 0x18, 0xC3, 0x00, 0x21, 0xC7, 0x00, 0x1E, 0x1F, 0xC6, 0x1B,
  0x7B, 0x9E, 0xED, 0xBB, 0x6E, 0xDB, 0xDF, 0xB0, 0x07, 0x30, 0xFC, 0x1C,
  0x1E, 0x0F, 0x86, 0xC3, 0x63, 0xB1, 0xD8, 0xFE, 0x7F, 0x71, 0xB8, 0xE0,
  0xF9, 0xFB, 0x3E, 0x7F, 0xDF, 0x37, 0x67, 0xCF, 0xFB, 0xE0, 0x39, 0xFE,
  0x78, 0xC3, 0x0C, 0x30, 0xE7, 0xF7, 0xC0, 0xF1, 0xFB, 0xFE, 0x7C, 0x78,
  0xF1, 0xE7, 0xCF, 0xFB, 0xE0, 0xFF, 0xF1, 0x8F, 0xFF, 0xF8, 0xC7, 0xFE,
  0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x30, 0x3C, 0xFF, 0x97, 0x0C, 0x1B,
  0xF7, 0xE3, 0xE6, 0xFD, 0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3,
  0xC7, 0x8F, 0x18, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xFE, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0xC7, 0x9F, 0x36, 0xED, 0x9F, 0x3E, 0x6E,
  0xCD, 0x9F, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE1, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF3, 0x3C, 0xCC,
  0xE3, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF, 0xC7, 0x38,
  0x7E, 0xEE, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C, 0xF3, 0xFD,
  0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x0C, 0x00, 0x38, 0x7E, 0xEE, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C, 0x0C, 0x0E, 0x07, 0xF1, 0xFB, 0x76,
  0x6C, 0xDF, 0xBE, 0x6E, 0xDD, 0x9F, 0x38, 0x3D, 0xF6, 0xF8, 0x71, 0xF1,
  0xC3, 0xCF, 0xFF, 0x80, 0xFF, 0xFF, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xEF, 0xFD, 0xF0,
  0xE3, 0xE7, 0x67, 0x67, 0x76, 0x76, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0xE6,
  0x3E, 0x67, 0xE7, 0x76, 0xF7, 0x6F, 0x66, 0xF6, 0x6F, 0x67, 0xDE, 0x39,
  0xE3, 0x9C, 0x39, 0xC0, 0xE6, 0x6E, 0x7E, 0x3C, 0x3C, 0x38, 0x3C, 0x3C,
  0x7E, 0x66, 0xE7, 0xE7, 0xE6, 0x66, 0x7E, 0x3C, 0x3C, 0x38, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xFF, 0xF8,
  0xFF, 0x6D, 0xB6, 0xDB, 0x6F, 0xC0, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x86,
  0x18, 0x30, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x18,
  0x3C, 0x3C, 0x7E, 0x66, 0xE7, 0xFF, 0xFF, 0xE7, 0x7C, 0xDC, 0x3B, 0xFE,
  0xFD, 0xFF, 0xBB, 0xC3, 0x0C, 0x3F, 0xFF, 0x3C, 0xF3, 0xCF, 0xFF, 0x80,
  0x3D, 0xF6, 0x38, 0x61, 0x97, 0xCF, 0x06, 0x0C, 0x1B, 0xF7, 0xEC, 0xF9,
  0xB3, 0x66, 0xFD, 0xD8, 0x7C, 0xDD, 0x9F, 0xF7, 0xEC, 0x1F, 0x1E, 0x7B,
  0xD9, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0x7E, 0xFD, 0x9F, 0x3E, 0x6C, 0xDF,
  0xBB, 0x06, 0xDD, 0xF1, 0x80, 0xC3, 0x0C, 0x3F, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xC0, 0xFC, 0xFF, 0xFF, 0x33, 0x30, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xF4, 0xC1, 0x83, 0x0E, 0x6D, 0xDB, 0x3E, 0x7C, 0xDD, 0x9B, 0x38, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33,
  0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x3C, 0xFD, 0x9F, 0x36, 0x6C, 0xDF,
  0x9E, 0xFF, 0xFC, 0xF3, 0xCF, 0x3F, 0xF6, 0xC3, 0x0C, 0x30, 0x7E, 0xFD,
  0x9F, 0x3E, 0x6C, 0xDF, 0xBB, 0x06, 0x0C, 0x18, 0x30, 0xFF, 0xB9, 0x8C,
  0x63, 0x18, 0x7B, 0xEE, 0x1E, 0x3A, 0x7F, 0xBE, 0x23, 0x3F, 0xF6, 0x31,
  0x8C, 0x79, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xE6, 0xDD, 0xBB,
  0x67, 0xC7, 0x8E, 0x1C, 0xEE, 0xFD, 0xDD, 0xAB, 0x3D, 0xE7, 0xBC, 0xF7,
  0x9E, 0xF1, 0xDC, 0xEE, 0xD9, 0xF1, 0xC3, 0x8F, 0x9B, 0x77, 0xE6, 0xDD,
  0xBB, 0x67, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x00, 0xFF, 0xE3, 0x8C,
  0x71, 0x8F, 0xFF, 0x19, 0xCC, 0x63, 0x3B, 0x9E, 0x31, 0x8C, 0x73, 0x84,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x9C, 0xE7, 0x18, 0xE7, 0x33, 0x9C, 0xEE,
  0x40, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_Black15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 6, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 12, 7, 1, -11 },
  { 27, 12, 11, 13, 0, -11 },
  { 44, 10, 11, 10, 0, -11 },
  { 58, 2, 4, 4, 1, -11 },
  { 59, 4, 13, 5, 1, -11 },
  { 66, 4, 13, 5, 0, -11 },
  { 73, 7, 6, 7, 0, -11 },
  { 79, 6, 7, 8, 1, -9 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 4, 2, 5, 0, -5 },
  { 88, 2, 3, 4, 1, -3 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 6, 11, 7, 1, -11 },
  { 107, 5, 11, 7, 1, -11 },
  { 114, 7, 11, 7, 0, -11 },
  { 124, 7, 11, 7, 0, -11 },
  { 134, 7, 11, 7, 0, -11 },
  { 144, 6, 11, 7, 1, -11 },
  { 153, 7, 11, 7, 0, -11 },
  { 163, 6, 11, 7, 1, -11 },
  { 172, 7, 11, 7, 0, -11 },
  { 182, 7, 11, 7, 0, -11 },
  { 192, 2, 8, 4, 1, -8 },
  { 194, 3, 10, 4, 0, -8 },
  { 198, 7, 7, 8, 0, -9 },
  { 205, 6, 5, 8, 1, -8 },
  { 209, 6, 7, 8, 1, -9 },
  { 215, 6, 11, 6, 0, -11 },
  { 224, 10, 12, 12, 1, -11 },
  { 239, 9, 11, 9, 0, -11 },
  { 252, 7, 11, 8, 1, -11 },
  { 262, 6, 11, 8, 1, -11 },
  { 271, 7, 11, 9, 1, -11 },
  { 281, 5, 11, 7, 1, -11 },
  { 288, 5, 11, 7, 1, -11 },
  { 295, 7, 11, 9, 1, -11 },
  { 305, 7, 11, 9, 1, -11 },
  { 315, 5, 11, 5, 0, -11 },
  { 322, 4, 14, 4, -1, -11 },
  { 329, 7, 11, 8, 1, -11 },
  { 339, 5, 11, 6, 1, -11 },
  { 346, 10, 11, 12, 1, -11 },
  { 360, 8, 11, 10, 1, -11 },
  { 371, 8, 11, 9, 1, -11 },
  { 382, 6, 11, 8, 1, -11 },
  { 391, 8, 14, 9, 1, -11 },
  { 405, 7, 11, 8, 1, -11 },
  { 415, 6, 11, 7, 0, -11 },
  { 424, 7, 11, 7, 0, -11 },
  { 434, 7, 11, 9, 1, -11 },
  { 444, 8, 11, 8, 0, -11 },
  { 455, 12, 11, 12, 0, -11 },
  { 472, 8, 11, 8, 0, -11 },
  { 483, 8, 11, 8, 0, -11 },
  { 494, 7, 11, 7, 0, -11 },
  { 504, 3, 14, 5, 1, -11 },
  { 510, 6, 11, 6, 0, -11 },
  { 519, 4, 14, 5, 0, -11 },
  { 526, 8, 7, 8, 0, -11 },
  { 533, 8, 2, 8, 0, 1 },
  { 535, 4, 2, 5, 1, -11 },
  { 536, 7, 8, 7, 0, -8 },
  { 543, 6, 11, 8, 1, -11 },
  { 552, 6, 8, 7, 0, -8 },
  { 558, 7, 11, 8, 0, -11 },
  { 568, 7, 8, 7, 0, -8 },
  { 575, 5, 11, 5, 0, -11 },
  { 582, 7, 12, 8, 0, -8 },
  { 593, 6, 11, 8, 1, -11 },
  { 602, 2, 12, 4, 1, -12 },
  { 605, 4, 16, 4, -1, -12 },
  { 613, 7, 11, 8, 1, -11 },
  { 623, 2, 11, 4, 1, -11 },
  { 626, 10, 8, 12, 1, -8 },
  { 636, 6, 8, 8, 1, -8 },
  { 642, 7, 8, 8, 0, -8 },
  { 649, 6, 12, 8, 1, -8 },
  { 658, 7, 12, 8, 0, -8 },
  { 669, 5, 8, 6, 1, -8 },
  { 674, 6, 8, 6, 0, -8 },
  { 680, 5, 10, 5, 0, -10 },
  { 687, 6, 8, 8, 1, -8 },
  { 693, 7, 8, 7, 0, -8 },
  { 700, 11, 8, 11, 0, -8 },
  { 711, 7, 8, 7, 0, -8 },
  { 718, 7, 12, 7, 0, -8 },
  { 729, 6, 8, 6, 0, -8 },
  { 735, 5, 14, 6, 0, -11 },
  { 744, 2, 15, 6, 2, -12 },
  { 748, 5, 14, 6, 0, -11 },
  { 757, 7, 3, 8, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Black15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK15PT7B_H_
