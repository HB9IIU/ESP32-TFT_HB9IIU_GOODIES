#ifndef _NOTOSANS_EXTRACONDENSED_BLACK10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black10pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x1C, 0xD5, 0x39, 0xBE, 0xAF, 0xA9, 0x40, 0x23, 0xBC, 0xC7,
  0x1D, 0xCC, 0x20, 0x64, 0xEC, 0xE8, 0x6F, 0x15, 0x15, 0x37, 0x71, 0x67,
  0x1F, 0xDF, 0x67, 0xC0, 0xD0, 0x69, 0x6C, 0x93, 0x20, 0xC9, 0xB6, 0xD2,
  0xC0, 0x25, 0x7E, 0xED, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0x70,
  0x13, 0x26, 0x44, 0xC0, 0x72, 0xB7, 0xBD, 0xA9, 0xC0, 0x37, 0xF3, 0x33,
  0x30, 0xF5, 0x13, 0x6C, 0xF0, 0xF4, 0x8C, 0xE1, 0xDB, 0xC0, 0x31, 0x94,
  0xEF, 0xFC, 0xC0, 0x72, 0x1C, 0xE1, 0xDB, 0xC0, 0x72, 0x3D, 0xFD, 0xAD,
  0xC0, 0xF8, 0x8C, 0x62, 0x31, 0x80, 0x76, 0x9C, 0xED, 0xED, 0xC0, 0x76,
  0xB7, 0xF5, 0x19, 0x80, 0x70, 0x70, 0x70, 0x1C, 0x1B, 0xB0, 0x70, 0x80,
  0xF8, 0x3E, 0xC3, 0x87, 0xC8, 0x00, 0xFB, 0x36, 0x04, 0x60, 0x3C, 0x85,
  0xEF, 0x5E, 0xAA, 0xD9, 0x1E, 0x31, 0xC7, 0x96, 0x7B, 0xEC, 0xC0, 0xFB,
  0xBF, 0xBB, 0xE0, 0x7B, 0x71, 0x8C, 0x35, 0xE0, 0xEB, 0x99, 0x9B, 0xE0,
  0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x7B, 0x71, 0xBC, 0xB5, 0xE0, 0x9C,
  0xE7, 0xF9, 0xCE, 0x60, 0xED, 0xB6, 0xF8, 0x24, 0x92, 0x4B, 0xE0, 0xBD,
  0xB9, 0xCB, 0x5A, 0x60, 0x92, 0x49, 0x38, 0xCF, 0x3F, 0xFF, 0xB6, 0xDB,
  0x40, 0xDE, 0xFF, 0x7B, 0xDE, 0x60, 0x79, 0xBC, 0xF3, 0xCD, 0xE7, 0x80,
  0xEB, 0xBF, 0xC8, 0x80, 0x79, 0xBC, 0xF3, 0xCD, 0xE7, 0x86, 0x0C, 0xE5,
  0xAD, 0xCA, 0x5A, 0xE0, 0x7D, 0xE7, 0x3F, 0xF0, 0xF6, 0x66, 0x66, 0x60,
  0x99, 0x99, 0x9F, 0xF0, 0xCF, 0x65, 0x9E, 0x71, 0xC3, 0x00, 0xDB, 0xDB,
  0x5B, 0x5A, 0x7E, 0x76, 0x66, 0xDA, 0x9C, 0x67, 0x2F, 0x60, 0xDA, 0xDC,
  0xE2, 0x10, 0x80, 0xF1, 0x8C, 0xC6, 0x63, 0xE0, 0xFB, 0x6D, 0xB7, 0xE0,
  0xC4, 0x46, 0x23, 0x10, 0xED, 0xB6, 0xDF, 0xE0, 0x21, 0x94, 0xBC, 0x80,
  0xF8, 0xCC, 0x27, 0x3F, 0xD7, 0xC6, 0x35, 0xFD, 0xEF, 0x7E, 0x27, 0xCC,
  0xD7, 0x18, 0xD6, 0xFD, 0xEF, 0x6F, 0x23, 0xB7, 0xFC, 0xB8, 0x6D, 0xF4,
  0x92, 0x7B, 0xF7, 0xBD, 0xBC, 0x6E, 0xC6, 0x35, 0xFD, 0xEF, 0x7B, 0x75,
  0x55, 0x75, 0x55, 0x70, 0xC6, 0x37, 0xBF, 0x7B, 0x7B, 0xFF, 0xFF, 0xD7,
  0xFF, 0x6E, 0xDD, 0xBB, 0x40, 0xD7, 0xF7, 0xBD, 0xEC, 0x23, 0xB7, 0xB5,
  0xB8, 0xD7, 0xF7, 0xBD, 0xFB, 0x18, 0x7B, 0xF7, 0xBD, 0xBC, 0x63, 0xBE,
  0x49, 0x00, 0x6F, 0xC7, 0xBE, 0x4F, 0xA4, 0x98, 0xDE, 0xF7, 0xB5, 0xBC,
  0xDE, 0xD4, 0xA7, 0x30, 0xDB, 0xB7, 0xFB, 0x76, 0xCD, 0x80, 0xDA, 0x9C,
  0xE7, 0x6C, 0xDE, 0xD4, 0xA7, 0x10, 0x8C, 0xFF, 0x26, 0xCF, 0x6D, 0xBC,
  0xDB, 0x20, 0xFF, 0xFF, 0xF0, 0xC6, 0x66, 0x76, 0x6C, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Black10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 4, 2, 5, 0, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 7, 8, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 2, 3, 0, -7 },
  { 29, 3, 9, 3, 0, -7 },
  { 33, 3, 9, 3, 0, -7 },
  { 37, 5, 5, 5, 0, -8 },
  { 41, 5, 5, 5, 0, -6 },
  { 45, 2, 2, 3, 0, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 2, 2, 3, 0, -2 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 4, 7, 5, 0, -7 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 5, 7, 5, 0, -7 },
  { 100, 2, 6, 3, 0, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 5, 5, 0, -6 },
  { 108, 5, 3, 5, 0, -5 },
  { 110, 5, 5, 5, 0, -6 },
  { 114, 4, 7, 4, 0, -7 },
  { 118, 7, 8, 8, 0, -7 },
  { 125, 6, 7, 6, 0, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 3, 7, 4, 1, -7 },
  { 147, 3, 7, 4, 1, -7 },
  { 150, 5, 7, 6, 0, -7 },
  { 155, 5, 7, 6, 1, -7 },
  { 160, 3, 7, 4, 0, -7 },
  { 163, 3, 9, 3, -1, -7 },
  { 167, 5, 7, 6, 1, -7 },
  { 172, 3, 7, 4, 1, -7 },
  { 175, 6, 7, 8, 1, -7 },
  { 181, 5, 7, 7, 1, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 4, 7, 5, 1, -7 },
  { 196, 6, 9, 6, 0, -7 },
  { 203, 5, 7, 5, 1, -7 },
  { 208, 4, 7, 5, 0, -7 },
  { 212, 4, 7, 5, 0, -7 },
  { 216, 4, 7, 6, 1, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 8, 7, 8, 0, -7 },
  { 233, 5, 7, 5, 0, -7 },
  { 238, 5, 7, 5, 0, -7 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 3, 9, 3, 0, -7 },
  { 252, 4, 7, 4, 0, -7 },
  { 256, 3, 9, 3, 0, -7 },
  { 260, 5, 5, 5, 0, -7 },
  { 264, 5, 1, 5, 0, 1 },
  { 265, 3, 2, 3, 0, -8 },
  { 266, 4, 6, 5, 0, -6 },
  { 269, 5, 8, 5, 0, -8 },
  { 274, 4, 6, 4, 0, -6 },
  { 277, 5, 8, 5, 0, -8 },
  { 282, 5, 6, 5, 0, -6 },
  { 286, 3, 8, 3, 0, -8 },
  { 289, 5, 8, 5, 0, -6 },
  { 294, 5, 8, 5, 0, -8 },
  { 299, 2, 8, 3, 0, -8 },
  { 301, 2, 10, 3, 0, -8 },
  { 304, 5, 8, 5, 0, -8 },
  { 309, 2, 8, 3, 0, -8 },
  { 311, 7, 6, 8, 0, -6 },
  { 317, 5, 6, 5, 0, -6 },
  { 321, 5, 6, 5, 0, -6 },
  { 325, 5, 8, 5, 0, -6 },
  { 330, 5, 8, 5, 0, -6 },
  { 335, 3, 6, 4, 1, -6 },
  { 338, 4, 6, 4, 0, -6 },
  { 341, 3, 7, 4, 0, -7 },
  { 344, 5, 6, 5, 0, -6 },
  { 348, 5, 6, 5, 0, -6 },
  { 352, 7, 6, 7, 0, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 5, 8, 5, 0, -6 },
  { 367, 4, 6, 4, 0, -6 },
  { 370, 3, 9, 4, 0, -7 },
  { 374, 2, 10, 4, 1, -8 },
  { 377, 4, 9, 4, 0, -7 },
  { 382, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Black10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK10PT7B_H_
