#ifndef _NOTOSANS_EXTRACONDENSED_BLACK32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xC0, 0x00, 0xC7, 0xFF, 0xFD, 0xF7, 0xC0, 0xFC, 0xFF, 0xE7, 0xFF, 0x3E,
  0xF9, 0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x39, 0xE0, 0x79, 0xE0, 0x03, 0x00, 0x18, 0x03, 0xF8, 0x7F,
  0xF7, 0xFF, 0xBF, 0xFB, 0xEC, 0xDF, 0x60, 0xFB, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x6F, 0x03, 0x7A, 0x1B, 0xDC,
  0xDE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x3E, 0x01, 0xE0, 0x3F, 0x80, 0xE0, 0x1F, 0xE0, 0xF0, 0x1F, 0xF0,
  0x78, 0x0F, 0x3C, 0x78, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1C, 0x01, 0xE7,
  0x9E, 0x00, 0xF3, 0xCF, 0x00, 0x79, 0xEF, 0x1E, 0x3F, 0xE7, 0xBF, 0x8F,
  0xF7, 0x9F, 0xE7, 0xF3, 0xDF, 0xF9, 0xF1, 0xEF, 0x3C, 0x01, 0xE7, 0x9E,
  0x00, 0xF3, 0xCF, 0x00, 0xF1, 0xE7, 0x80, 0x78, 0xF3, 0xC0, 0x38, 0x79,
  0xE0, 0x3C, 0x3E, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x0F, 0x01,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE7, 0xE3, 0xFE, 0x7E, 0x7F, 0xE7, 0xCF, 0xFF, 0xFC,
  0xF9, 0xFF, 0xCF, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x87, 0xF0, 0xFC, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF,
  0xFF, 0xDF, 0x79, 0xE7, 0x9E, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x03, 0x9C, 0x67, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x8F, 0xF8,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xF3, 0xE1, 0xC7, 0x00, 0x84, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xEF, 0xBE, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x11, 0xF7, 0xFF, 0x7D, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xEF,
  0xCF, 0xBF, 0x3E, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xF9, 0xF3, 0xE7, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7B, 0xF3, 0x3F, 0x13, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0xB8, 0xFC, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x7B, 0xF8, 0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xFE, 0x03, 0xEE, 0x3F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0xC3, 0xDF, 0x1E, 0x7C, 0xF9, 0xF3, 0xC7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F,
  0x89, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFB, 0xE3, 0xEF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3, 0xF7,
  0xEF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xEF, 0xCF, 0xBE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0xFF, 0xFB, 0xF3, 0xEF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFD, 0xF3, 0xF7, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x00,
  0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x02, 0x7F, 0xFF, 0xFF, 0xC0,
  0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDF,
  0x7D, 0xF7, 0xBE, 0xFB, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF,
  0x1F, 0xF9, 0xFF, 0x8F, 0xF0, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0x07, 0xFC, 0x7F, 0xE7, 0xFC, 0x3F,
  0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xF7,
  0xFF, 0x7B, 0xF6, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xE0, 0x7C, 0x1E, 0x00, 0xF8, 0xF0, 0x01, 0xE7, 0x87,
  0xF3, 0xDE, 0x3F, 0xEF, 0x71, 0xFF, 0x9F, 0xCF, 0x1C, 0x7F, 0x3C, 0x71,
  0xFC, 0xF1, 0xC7, 0xF3, 0xC7, 0x1F, 0xCF, 0x3C, 0x7F, 0x3C, 0xF1, 0xFC,
  0xF3, 0xCF, 0xF3, 0xFF, 0xF9, 0xC7, 0xFF, 0xE7, 0x8F, 0x9F, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x03, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xF8, 0x3F,
  0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x1F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x9F, 0x3F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7F, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF9,
  0xF8, 0x27, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x17, 0xFB,
  0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x7E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0xBE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBE, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x02, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7F, 0xBF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xDF, 0xFF, 0xFF, 0xEF, 0xE7, 0xE0, 0xF8, 0x3F, 0xF8,
  0x7E, 0xF8, 0x7E, 0xF8, 0xFC, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF8, 0xFB,
  0xF0, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xF9, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8,
  0x7C, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF3, 0xDF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9,
  0xFE, 0x7F, 0xE7, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xF8,
  0x7F, 0xE3, 0xE1, 0xFF, 0x87, 0x87, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFE, 0xFB, 0xFF, 0x7D, 0xFF, 0xBE, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7E, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFB, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x9F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC,
  0xF8, 0xFC, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFB, 0xF0, 0xFB, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xDF, 0xFC, 0xFF,
  0xEF, 0xFF, 0x7E, 0x1B, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xFF,
  0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xFB, 0xFB, 0xFF, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3F, 0x0F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xDF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1E,
  0x0F, 0xFF, 0x07, 0x83, 0xFF, 0xC3, 0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C,
  0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7, 0xC7, 0xF1, 0xF9, 0xF9, 0xFE, 0x7E,
  0x3E, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xF9, 0xFE,
  0x7C, 0x3E, 0xF7, 0xBF, 0x07, 0xBC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F,
  0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0xFC, 0x3F, 0x3E, 0x1F, 0x1F, 0x9F, 0x87, 0xCF, 0xC3, 0xE7, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x87, 0xCF, 0xC7, 0xE3, 0xF3, 0xE1, 0xFB,
  0xF0, 0x7E, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF3, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F, 0x9E,
  0x0F, 0x8F, 0x87, 0xC3, 0xC7, 0xC1, 0xF3, 0xE0, 0x7B, 0xE0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0xC3, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0x9F, 0x80, 0x7C,
  0x03, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xEF, 0xFF, 0xBE, 0x3E, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xBF, 0x3E, 0xFF, 0xFB, 0xFF, 0xEF, 0x7F,
  0x3C, 0xF8, 0x0F, 0xC1, 0xFF, 0x3F, 0xF7, 0xFE, 0x7E, 0xEF, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x17, 0xE3, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF1, 0xE7, 0xCF, 0xDF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xCF, 0x0F,
  0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xEF, 0x87, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x67,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x7F, 0x9F,
  0xE3, 0xF0, 0x7C, 0x0F, 0xF3, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x3C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F,
  0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0,
  0x07, 0xC0, 0x1F, 0x40, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0,
  0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xEF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x39, 0xFF, 0xFF, 0x7C, 0x40, 0x1F, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C,
  0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x04, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0xFC, 0x7E,
  0xF8, 0xF9, 0xF3, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0xCF, 0x8F,
  0x9F, 0x1F, 0xBE, 0x3F, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE1, 0xE3,
  0xDF, 0xCF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3,
  0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3, 0xFF,
  0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3, 0xF0, 0xF3,
  0xE7, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7E, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xFC, 0x7D, 0xF3, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F,
  0x80, 0xF3, 0xE3, 0xDF, 0xCF, 0x7F, 0x3F, 0xFE, 0xFD, 0xFB, 0xE3, 0xEF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFB,
  0xF3, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xEF, 0x8F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E,
  0x3C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xF1, 0xFF, 0x87, 0xFF,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7F, 0xF3, 0xF7,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF1, 0xFC, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xEF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x1F, 0x8F, 0xFF, 0xFF,
  0x7F, 0xEF, 0x8D, 0xF0, 0x3F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x83,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x27, 0xFC, 0xFF, 0x8F,
  0xF0, 0xFC, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0xF8, 0x3F, 0xFC, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x3F, 0xF8,
  0xFC, 0x7D, 0xF3, 0xF8, 0xFB, 0xE7, 0xF1, 0xF7, 0xCF, 0xE3, 0xEF, 0x9F,
  0xEF, 0x9F, 0x3F, 0xDF, 0x1E, 0x77, 0xBE, 0x3F, 0xEF, 0x7C, 0x7F, 0xDE,
  0xF0, 0xFF, 0x9D, 0xE1, 0xFF, 0x3B, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFF,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xE0,
  0xFC, 0x7E, 0xF8, 0xF9, 0xFB, 0xF1, 0xF7, 0xC3, 0xEF, 0x83, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x87, 0xDF, 0x0F, 0xBE, 0x3F, 0x7E, 0x7C, 0x7D, 0xF8, 0xFC, 0xFC, 0x3F,
  0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFC, 0x7F, 0x3F, 0x8F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 23, 9, 1, -23 },
  { 19, 13, 8, 15, 1, -23 },
  { 32, 16, 23, 17, 1, -23 },
  { 78, 13, 26, 16, 1, -24 },
  { 121, 25, 23, 27, 1, -23 },
  { 193, 20, 23, 21, 1, -23 },
  { 251, 6, 8, 8, 1, -23 },
  { 257, 9, 28, 10, 1, -23 },
  { 289, 9, 28, 10, 0, -23 },
  { 321, 15, 14, 15, 0, -24 },
  { 348, 14, 15, 16, 1, -19 },
  { 375, 6, 9, 9, 1, -5 },
  { 382, 8, 5, 10, 1, -11 },
  { 387, 6, 6, 9, 1, -6 },
  { 392, 14, 23, 14, 0, -23 },
  { 433, 14, 23, 16, 1, -23 },
  { 474, 12, 23, 16, 1, -23 },
  { 509, 13, 23, 16, 1, -23 },
  { 547, 14, 23, 16, 1, -23 },
  { 588, 14, 23, 16, 1, -23 },
  { 629, 12, 23, 16, 2, -23 },
  { 664, 14, 23, 16, 1, -23 },
  { 705, 14, 23, 16, 1, -23 },
  { 746, 14, 23, 16, 1, -23 },
  { 787, 14, 23, 16, 1, -23 },
  { 828, 5, 18, 9, 2, -18 },
  { 840, 6, 22, 9, 1, -18 },
  { 857, 14, 15, 16, 1, -19 },
  { 884, 14, 11, 16, 1, -17 },
  { 904, 14, 15, 16, 1, -19 },
  { 931, 12, 23, 13, 0, -23 },
  { 966, 22, 25, 25, 1, -23 },
  { 1035, 18, 23, 18, 0, -23 },
  { 1087, 15, 23, 18, 2, -23 },
  { 1131, 14, 23, 16, 1, -23 },
  { 1172, 16, 23, 19, 2, -23 },
  { 1218, 11, 23, 14, 2, -23 },
  { 1250, 11, 23, 14, 2, -23 },
  { 1282, 16, 23, 19, 1, -23 },
  { 1328, 16, 23, 19, 2, -23 },
  { 1374, 10, 23, 11, 1, -23 },
  { 1403, 9, 30, 9, -2, -23 },
  { 1437, 16, 23, 18, 2, -23 },
  { 1483, 11, 23, 14, 2, -23 },
  { 1515, 22, 23, 26, 2, -23 },
  { 1579, 17, 23, 21, 2, -23 },
  { 1628, 18, 23, 20, 1, -23 },
  { 1680, 14, 23, 17, 2, -23 },
  { 1721, 18, 28, 20, 1, -23 },
  { 1784, 16, 23, 17, 2, -23 },
  { 1830, 13, 23, 15, 1, -23 },
  { 1868, 13, 23, 15, 1, -23 },
  { 1906, 15, 23, 19, 2, -23 },
  { 1950, 18, 23, 18, 0, -23 },
  { 2002, 26, 23, 26, 0, -23 },
  { 2077, 17, 23, 17, 0, -23 },
  { 2126, 17, 23, 17, 0, -23 },
  { 2175, 13, 23, 15, 1, -23 },
  { 2213, 8, 28, 10, 1, -23 },
  { 2241, 14, 23, 14, 0, -23 },
  { 2282, 7, 28, 10, 1, -23 },
  { 2307, 17, 15, 17, 0, -23 },
  { 2339, 16, 4, 16, 0, 2 },
  { 2347, 9, 6, 11, 1, -25 },
  { 2354, 13, 18, 16, 1, -18 },
  { 2384, 14, 24, 17, 2, -24 },
  { 2426, 12, 18, 14, 1, -18 },
  { 2453, 14, 24, 17, 1, -24 },
  { 2495, 14, 18, 15, 1, -18 },
  { 2527, 11, 24, 10, 0, -24 },
  { 2560, 14, 26, 17, 1, -18 },
  { 2606, 13, 24, 17, 2, -24 },
  { 2645, 6, 25, 8, 1, -25 },
  { 2664, 8, 33, 8, -1, -25 },
  { 2697, 15, 24, 17, 2, -24 },
  { 2742, 5, 24, 8, 2, -24 },
  { 2757, 22, 18, 25, 2, -18 },
  { 2807, 13, 18, 17, 2, -18 },
  { 2837, 14, 18, 17, 1, -18 },
  { 2869, 14, 26, 17, 2, -18 },
  { 2915, 14, 26, 17, 1, -18 },
  { 2961, 10, 18, 12, 2, -18 },
  { 2984, 11, 18, 13, 1, -18 },
  { 3009, 11, 21, 11, 0, -21 },
  { 3038, 13, 18, 17, 2, -18 },
  { 3068, 16, 18, 16, 0, -18 },
  { 3104, 23, 18, 24, 0, -18 },
  { 3156, 15, 18, 15, 0, -18 },
  { 3190, 16, 26, 16, 0, -18 },
  { 3242, 11, 18, 13, 1, -18 },
  { 3267, 11, 28, 12, 0, -23 },
  { 3306, 5, 32, 13, 4, -25 },
  { 3326, 10, 28, 12, 1, -23 },
  { 3361, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Black32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK32PT7B_H_
