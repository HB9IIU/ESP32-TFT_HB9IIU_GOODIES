#ifndef _NOTOSANS_EXTRACONDENSED_BLACK36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFC,
  0xFD, 0xF9, 0xFB, 0xE3, 0xF7, 0xC7, 0xEF, 0x8F, 0xDF, 0x1F, 0xBE, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF8, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xF3, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79,
  0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBE, 0xC6, 0xF3, 0x03, 0xCC, 0x0F, 0xB0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x0D, 0xF0, 0x33,
  0xE0, 0xCF, 0xC3, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x3E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x07,
  0x80, 0x7F, 0xC0, 0xF8, 0x07, 0xFC, 0x0F, 0x00, 0xFB, 0xE1, 0xF0, 0x0F,
  0x9E, 0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3E, 0x00, 0xF1, 0xE3,
  0xC0, 0x0F, 0x1E, 0x7C, 0x00, 0xF1, 0xE7, 0x87, 0x8F, 0xBE, 0x79, 0xFC,
  0x7F, 0xEF, 0xBF, 0xE7, 0xFC, 0xF3, 0xFE, 0x3F, 0x9F, 0x7D, 0xF1, 0xF1,
  0xE7, 0xCF, 0x00, 0x1E, 0x7C, 0xF0, 0x03, 0xC7, 0xCF, 0x00, 0x3C, 0x78,
  0xF0, 0x07, 0xC7, 0x8F, 0x00, 0x78, 0x7C, 0xF0, 0x0F, 0x87, 0xDF, 0x00,
  0xF0, 0x3F, 0xF0, 0x0F, 0x03, 0xFE, 0x01, 0xF0, 0x1F, 0xE0, 0x1E, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F,
  0x7E, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF1,
  0xF8, 0xFF, 0xC7, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFC, 0xFC, 0xFF, 0xF3,
  0xF3, 0xFF, 0xCF, 0xC7, 0xFE, 0x3F, 0x0F, 0xF8, 0xFE, 0x3F, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xCF,
  0xF0, 0xFF, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x0F, 0xC7,
  0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC0,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x04, 0x7C, 0x67, 0xDE, 0xF3, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0xF7, 0xE0, 0xF1, 0xE0,
  0x38, 0xE0, 0x08, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0xF9, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E,
  0x7C, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xEF, 0xCE, 0x7E, 0x23, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0x1F, 0x8C, 0x3F,
  0x90, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC7, 0x1F, 0xC8,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0xFF,
  0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1E, 0xFC, 0x3E,
  0xFC, 0x3C, 0xFC, 0x7C, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xFF, 0xE7, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF2, 0x3F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF1, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0xFD,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C,
  0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xBE, 0x1F,
  0xBE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDF, 0x3C, 0xFD,
  0xFB, 0xF7, 0xE7, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0xBF, 0x7C, 0xF8, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC1,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xE3, 0xF2, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xF8, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0xF8, 0x10, 0x3C, 0x78, 0x7F, 0xDF, 0x7C, 0x7F, 0xE7,
  0xBC, 0x7F, 0xF3, 0xDE, 0x7C, 0xF9, 0xFF, 0x3E, 0x7C, 0xFF, 0x9E, 0x3E,
  0x7F, 0x8F, 0x1F, 0x3F, 0xC7, 0x8F, 0x9F, 0xE3, 0xC7, 0x8F, 0xF1, 0xE3,
  0xC7, 0xFC, 0xF1, 0xE3, 0xFE, 0x7D, 0xFF, 0xCF, 0x1F, 0xFF, 0xE7, 0x8F,
  0xEF, 0xE3, 0xE1, 0xE1, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x38, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x01, 0xF8,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x83,
  0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE3,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0xFE, 0xFC, 0x3F,
  0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x8E, 0x7F, 0x02, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0x3F, 0x87, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFD, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x87, 0x1F,
  0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xF3, 0xF8, 0x7E, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xFF, 0xFF,
  0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB,
  0xF0, 0xFE, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD,
  0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC,
  0x1F, 0xFF, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7B,
  0xFF, 0xDF, 0x7D, 0xFF, 0xEF, 0xBE, 0xFF, 0xF7, 0xDF, 0x7F, 0xFB, 0xEF,
  0x3F, 0xFC, 0xFF, 0x9F, 0xFE, 0x7F, 0xCF, 0xFF, 0x3F, 0xE7, 0xFF, 0x9F,
  0xE3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8,
  0xFC, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xC0, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xDF, 0x3F, 0xFB, 0xF7, 0xFF, 0x3E, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0,
  0x7E, 0x3F, 0x8F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFD, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF9, 0xFE, 0x7F,
  0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0x8F,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0x7F, 0xCF, 0xC7, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3F, 0x1F, 0xCF, 0xC7, 0xF3, 0xF7, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFE, 0xFC, 0x3F,
  0xBF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xC0, 0xBF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x0F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80,
  0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03,
  0xE0, 0x7E, 0xF8, 0x3F, 0x87, 0xF7, 0xE1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E, 0x3E, 0x3F, 0xE3, 0xF1,
  0xF1, 0xFF, 0x3F, 0x0F, 0xCF, 0x79, 0xF8, 0x7E, 0x7B, 0xCF, 0xC3, 0xF3,
  0xDE, 0x7E, 0x0F, 0xBE, 0xF3, 0xF0, 0x7D, 0xF7, 0xDF, 0x03, 0xEF, 0xBE,
  0xF8, 0x1F, 0x7C, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3,
  0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xDF, 0x83, 0xFB, 0xF0, 0x7E, 0x7F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFE, 0x7E,
  0x0F, 0xDF, 0xC1, 0xFC, 0xFC, 0x07, 0xFF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE1, 0xEF, 0xE2, 0x0F, 0xC0, 0x1F, 0x81, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFD, 0xFE, 0xF9, 0xF8, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0xFF,
  0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9,
  0xF8, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9, 0xF8, 0x47,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x9F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x1F, 0x3F, 0x3F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xE7, 0xEF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xBF, 0x8E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x00, 0x80, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xF9, 0x3F, 0x03, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x40, 0x3F,
  0x78, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0xFC, 0xFB, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xF8, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x7F,
  0xFF, 0x7F, 0xBF, 0x9F, 0x87, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x7F, 0xFC,
  0x3F, 0x7E, 0x3F, 0x3F, 0x3F, 0x9F, 0x9F, 0x8F, 0xDF, 0x87, 0xEF, 0xC3,
  0xFF, 0xC1, 0xF7, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7F, 0x7E,
  0x1F, 0xBF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF1, 0xF8, 0x7C, 0x7D, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xF3, 0xF9, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8,
  0xFC, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0x1F, 0x87, 0xFF,
  0x8F, 0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xF0, 0xFF, 0xF1, 0xF8, 0x7F,
  0xF8, 0xFC, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0x1F, 0x87,
  0xFF, 0x8F, 0xC3, 0xF0, 0xF1, 0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xF9, 0xF0,
  0xFB, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xFF, 0xFC,
  0xFD, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x9F, 0x3F, 0xDF,
  0x3F, 0xDF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x1F, 0xC7,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFD, 0xEF, 0xC2, 0xFC, 0x0F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFD, 0xFE, 0xF9, 0xF8, 0xF0, 0xFC, 0x1F, 0xFF, 0x07, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xFF, 0x0F, 0xE3, 0xF7, 0xC7, 0xF8,
  0xFD, 0xF9, 0xFE, 0x3F, 0x7E, 0x7F, 0x8F, 0x9F, 0x9F, 0xF3, 0xE3, 0xE7,
  0xFD, 0xF8, 0xF9, 0xFF, 0x7E, 0x3E, 0xFB, 0xDF, 0x8F, 0xBE, 0xF7, 0xC3,
  0xFF, 0xBD, 0xF0, 0x7F, 0xCF, 0x7C, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF,
  0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xF8,
  0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xBF, 0x1F,
  0x9F, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F,
  0xDF, 0xC7, 0xF0, 0xFC, 0x1F, 0xDF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x0F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07,
  0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF1, 0xFF, 0x1F, 0xE1, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Black36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 15, 10, 17, 1, -26 },
  { 40, 18, 26, 20, 1, -26 },
  { 99, 14, 29, 18, 2, -27 },
  { 150, 28, 26, 30, 1, -26 },
  { 241, 22, 26, 23, 1, -26 },
  { 313, 7, 10, 9, 1, -26 },
  { 322, 10, 32, 12, 2, -26 },
  { 362, 10, 32, 12, 0, -26 },
  { 402, 17, 16, 17, 0, -27 },
  { 436, 16, 17, 18, 1, -21 },
  { 470, 7, 10, 10, 1, -5 },
  { 479, 10, 5, 12, 1, -12 },
  { 486, 6, 6, 10, 2, -6 },
  { 491, 15, 26, 15, 0, -26 },
  { 540, 16, 26, 18, 1, -26 },
  { 592, 13, 26, 18, 1, -26 },
  { 635, 15, 26, 18, 1, -26 },
  { 684, 15, 26, 18, 1, -26 },
  { 733, 16, 26, 18, 1, -26 },
  { 785, 14, 26, 18, 2, -26 },
  { 831, 16, 26, 18, 1, -26 },
  { 883, 16, 26, 18, 1, -26 },
  { 935, 16, 26, 18, 1, -26 },
  { 987, 16, 26, 18, 1, -26 },
  { 1039, 6, 20, 10, 2, -20 },
  { 1054, 7, 25, 10, 1, -20 },
  { 1076, 16, 18, 18, 1, -22 },
  { 1112, 16, 13, 18, 1, -19 },
  { 1138, 16, 18, 18, 1, -22 },
  { 1174, 14, 26, 14, 0, -26 },
  { 1220, 25, 29, 28, 1, -26 },
  { 1311, 21, 26, 21, 0, -26 },
  { 1380, 17, 26, 20, 2, -26 },
  { 1436, 16, 26, 18, 1, -26 },
  { 1488, 18, 26, 21, 2, -26 },
  { 1547, 13, 26, 16, 2, -26 },
  { 1590, 12, 26, 16, 2, -26 },
  { 1629, 19, 26, 21, 1, -26 },
  { 1691, 18, 26, 22, 2, -26 },
  { 1750, 11, 26, 13, 1, -26 },
  { 1786, 10, 34, 10, -2, -26 },
  { 1829, 18, 26, 20, 2, -26 },
  { 1888, 13, 26, 15, 2, -26 },
  { 1931, 25, 26, 29, 2, -26 },
  { 2013, 19, 26, 24, 2, -26 },
  { 2075, 20, 26, 22, 1, -26 },
  { 2140, 16, 26, 19, 2, -26 },
  { 2192, 20, 32, 22, 1, -26 },
  { 2272, 18, 26, 20, 2, -26 },
  { 2331, 14, 26, 16, 1, -26 },
  { 2377, 15, 26, 17, 1, -26 },
  { 2426, 17, 26, 21, 2, -26 },
  { 2482, 20, 26, 20, 0, -26 },
  { 2547, 29, 26, 29, 0, -26 },
  { 2642, 19, 26, 19, 0, -26 },
  { 2704, 19, 26, 19, 0, -26 },
  { 2766, 15, 26, 17, 1, -26 },
  { 2815, 9, 32, 11, 1, -26 },
  { 2851, 15, 26, 15, 0, -26 },
  { 2900, 8, 32, 11, 1, -26 },
  { 2932, 19, 17, 19, 0, -26 },
  { 2973, 18, 5, 18, 0, 2 },
  { 2985, 10, 6, 12, 1, -28 },
  { 2993, 15, 20, 18, 1, -20 },
  { 3031, 16, 27, 19, 2, -27 },
  { 3085, 14, 20, 16, 1, -20 },
  { 3120, 16, 27, 19, 1, -27 },
  { 3174, 15, 20, 17, 1, -20 },
  { 3212, 12, 28, 12, 0, -28 },
  { 3254, 16, 29, 19, 1, -20 },
  { 3312, 15, 27, 19, 2, -27 },
  { 3363, 6, 28, 10, 2, -28 },
  { 3384, 9, 37, 10, -1, -28 },
  { 3426, 17, 27, 19, 2, -27 },
  { 3484, 6, 27, 9, 2, -27 },
  { 3505, 25, 20, 28, 2, -20 },
  { 3568, 15, 20, 19, 2, -20 },
  { 3606, 16, 20, 19, 1, -20 },
  { 3646, 16, 29, 19, 2, -20 },
  { 3704, 16, 29, 19, 1, -20 },
  { 3762, 11, 20, 14, 2, -20 },
  { 3790, 12, 20, 14, 1, -20 },
  { 3820, 12, 24, 13, 0, -24 },
  { 3856, 15, 20, 19, 2, -20 },
  { 3894, 18, 20, 18, 0, -20 },
  { 3939, 26, 20, 27, 0, -20 },
  { 4004, 17, 20, 17, 0, -20 },
  { 4047, 18, 29, 18, 0, -20 },
  { 4113, 13, 20, 14, 1, -20 },
  { 4146, 12, 32, 13, 0, -26 },
  { 4194, 5, 36, 15, 5, -28 },
  { 4217, 12, 32, 13, 1, -26 },
  { 4265, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Black36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK36PT7B_H_
