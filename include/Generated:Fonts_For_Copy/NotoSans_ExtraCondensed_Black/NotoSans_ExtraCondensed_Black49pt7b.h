#ifndef _NOTOSANS_EXTRACONDENSED_BLACK49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xDF, 0xC3, 0x00, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x83, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xF7, 0x7C, 0xFE, 0x70, 0xCF, 0xE7, 0x00, 0xFE,
  0x70, 0x0F, 0xE7, 0x00, 0xFF, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x77, 0xF0, 0x07, 0x3F, 0x80, 0x73,
  0xFE, 0x07, 0x3F, 0xF8, 0x77, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x01,
  0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0xFC, 0x00, 0x1F, 0x9F, 0x81, 0xF8, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC7, 0xE0, 0x20, 0x1F, 0x9F, 0x8F, 0xC7, 0xF8, 0x3F, 0x3F,
  0x3F, 0x1F, 0xF8, 0x7F, 0xFE, 0x7E, 0x7F, 0xF8, 0x7F, 0xF8, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF3, 0xF3, 0xFF, 0xF0, 0xFF, 0xC7, 0xE7, 0xE7, 0xE0, 0xFF,
  0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x7E, 0x00,
  0x0F, 0xC3, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x00, 0x7E, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0x1F, 0x9F, 0x80,
  0x07, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE3, 0xFC, 0x07, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x3F, 0xE1, 0xFF, 0xFF, 0x7F, 0x87, 0xFF, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFE, 0x3F, 0xE7, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0x07, 0xFF,
  0xE1, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x40, 0xFC, 0x11, 0xC3, 0xF1, 0xC7, 0xEF, 0xBF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F,
  0xDF, 0xE1, 0xFE, 0x3F, 0xC1, 0xF8, 0xFE, 0x03, 0xC1, 0xE0, 0x03, 0x03,
  0x00, 0x04, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xF9, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x08, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x04,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF7, 0xF8, 0x7F, 0xBF,
  0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE,
  0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFF, 0x3F, 0xC7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0xCF, 0x9F,
  0xF1, 0xC7, 0xFC, 0x21, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xC3, 0xFE, 0x3C, 0x0F, 0xF0,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0x81, 0xFE, 0x10, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFB, 0xFC, 0x03, 0xF7, 0xF8, 0x0F,
  0xCF, 0xF0, 0x1F, 0x9F, 0xE0, 0x7E, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF0,
  0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xE1, 0x87, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF3, 0xF0, 0x7F,
  0x3F, 0xE3, 0xFB, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC,
  0xFF, 0x1F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F,
  0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF3, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0x3F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xBF, 0xE1, 0xFE, 0xFF,
  0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFB, 0xF8,
  0x3F, 0xEF, 0xE0, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x30, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x07, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0xCF, 0xC1, 0x80, 0x1F,
  0x8F, 0xF3, 0xFD, 0xFF, 0x7F, 0xCF, 0xF3, 0xFC, 0x7E, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xC0,
  0xFF, 0x20, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x60, 0x3F, 0x0F, 0xC1,
  0xFF, 0xC7, 0xE7, 0xE0, 0xFF, 0xF9, 0xF9, 0xF8, 0x7F, 0xFE, 0x3E, 0x7C,
  0x3F, 0xFF, 0x8F, 0xBF, 0x0F, 0xC7, 0xE3, 0xFF, 0xC7, 0xE1, 0xF8, 0xFF,
  0xF1, 0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x1F, 0x8F, 0xFE, 0x1F, 0x07, 0xE3,
  0xFF, 0x8F, 0xC1, 0xF8, 0xFF, 0xE3, 0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0x1F,
  0x0F, 0xFE, 0x3F, 0x0F, 0xC3, 0xEF, 0x87, 0xC3, 0xF0, 0xFB, 0xF1, 0xF8,
  0xFC, 0x7E, 0xFC, 0x7F, 0x7F, 0x9F, 0x3F, 0x1F, 0xFF, 0xFF, 0xCF, 0xC3,
  0xFF, 0x7F, 0xE1, 0xF8, 0x7F, 0xCF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x60, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xF8, 0x1C, 0x7F, 0xE0, 0x11, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x9F, 0xFC, 0x0C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF,
  0x07, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xE0, 0x18, 0x7F, 0xE0, 0x04, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC,
  0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F,
  0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xFF, 0xEF, 0xE1, 0xFB,
  0xFF, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0x3F, 0xBF, 0xFF, 0xDF, 0xCF,
  0xCF, 0xFF, 0xF7, 0xF3, 0xF3, 0xFF, 0xFC, 0xFD, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0x8F, 0xFF,
  0xEF, 0xF3, 0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0x7F, 0x9F, 0xFF, 0xDF, 0xE7,
  0xFF, 0xF3, 0xF9, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8,
  0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7,
  0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF,
  0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFC, 0x3C, 0x7F, 0x80, 0xC7, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xBF,
  0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0x80,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x7F,
  0x81, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF,
  0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xFC,
  0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x1F, 0xC3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xEF, 0xC7,
  0xF8, 0x1F, 0xE7, 0xEF, 0xCF, 0xF0, 0x0F, 0xE7, 0xE7, 0xEF, 0xF0, 0x0F,
  0xE7, 0xE7, 0xEF, 0xF0, 0x0F, 0xE7, 0xE7, 0xEF, 0xF0, 0x0F, 0xEF, 0xE7,
  0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xEF, 0xE0, 0x07, 0xFF, 0xC7, 0xEF, 0xE0,
  0x07, 0xFF, 0xC3, 0xEF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFC, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0,
  0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x1C,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xC1, 0xFF, 0x08, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xDF, 0xCF, 0xFC, 0x7E, 0x3F, 0xC3, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x08, 0x0F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF8, 0xFF, 0x7F, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFB, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xDF, 0xF8, 0xFE, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0x1C,
  0xFF, 0x81, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0xBF, 0xF1, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0C, 0x3F, 0xC3,
  0xF9, 0xFE, 0x3F, 0xEF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFE, 0xFE, 0x3F, 0xE7, 0xF0, 0xFE, 0x1F, 0x80, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x2F, 0xF8, 0x0E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xC4,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xFC, 0xFE,
  0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xEF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFD, 0xFE, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE8, 0x01, 0xFF, 0x78, 0x1F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x18, 0x0F, 0xF3, 0xFC, 0x3F, 0xDF, 0xF8, 0xFF, 0x7F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFB,
  0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xBF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xF8, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xA3, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x81, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xE0,
  0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x30, 0x3F, 0x8F, 0xF0, 0x7F,
  0x8F, 0xE7, 0xFF, 0x3F, 0xF3, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0x00, 0x06, 0x03, 0xF8, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F,
  0xBF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0x87, 0xFB, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x20, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xEF,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFE, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x06, 0x03, 0xF8, 0x7F, 0x0F, 0xE3, 0xFE, 0x3F, 0xDF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF1, 0xFE, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x3F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFD, 0xFF,
  0xCF, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xFC, 0xFE, 0x7F,
  0xF7, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xEF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFD, 0xFE, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x06, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFE,
  0x0C, 0xFF, 0x02, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF3, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xF9, 0xF8, 0xFF, 0xCF, 0xC3, 0xFC,
  0x7E, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7,
  0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xEF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x07,
  0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xE0, 0xFE, 0x7F, 0x87, 0xFE, 0x0F, 0xE7,
  0xF8, 0x7F, 0xE1, 0xFE, 0x7F, 0x87, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0xF1,
  0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0xCF,
  0xFF, 0x1F, 0xC3, 0xFC, 0xFF, 0xF3, 0xFC, 0x3F, 0xCF, 0xBF, 0x3F, 0xC1,
  0xFD, 0xF9, 0xFB, 0xF8, 0x1F, 0xDF, 0x9F, 0xBF, 0x81, 0xFD, 0xF9, 0xFB,
  0xF8, 0x1F, 0xDF, 0x9F, 0xBF, 0x81, 0xFD, 0xF9, 0xFB, 0xF8, 0x0F, 0xDF,
  0x9F, 0xBF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x81, 0xFE, 0xFF,
  0x03, 0xFD, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC,
  0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8,
  0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x27, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0x0F, 0x80, 0x04, 0xFF, 0xC0, 0x17, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFE, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Black49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 36, 13, 2, -35 },
  { 42, 20, 13, 24, 2, -35 },
  { 75, 25, 35, 27, 1, -35 },
  { 185, 20, 40, 24, 2, -37 },
  { 285, 39, 35, 41, 1, -35 },
  { 456, 31, 35, 32, 1, -35 },
  { 592, 8, 13, 12, 2, -35 },
  { 605, 14, 44, 16, 2, -36 },
  { 682, 14, 44, 16, 0, -36 },
  { 759, 22, 22, 23, 1, -37 },
  { 820, 21, 24, 25, 2, -29 },
  { 883, 9, 14, 13, 2, -7 },
  { 899, 14, 8, 16, 1, -17 },
  { 913, 9, 10, 13, 2, -9 },
  { 925, 21, 35, 21, 0, -35 },
  { 1017, 21, 35, 24, 2, -35 },
  { 1109, 18, 35, 24, 2, -35 },
  { 1188, 21, 35, 24, 1, -35 },
  { 1280, 21, 35, 24, 1, -35 },
  { 1372, 23, 35, 24, 1, -35 },
  { 1473, 20, 35, 24, 2, -35 },
  { 1561, 21, 35, 24, 2, -35 },
  { 1653, 20, 35, 24, 2, -35 },
  { 1741, 22, 35, 24, 1, -35 },
  { 1838, 22, 35, 24, 1, -35 },
  { 1935, 9, 28, 14, 2, -27 },
  { 1967, 10, 34, 14, 1, -27 },
  { 2010, 22, 25, 25, 1, -30 },
  { 2079, 21, 17, 25, 2, -26 },
  { 2124, 21, 25, 25, 2, -30 },
  { 2190, 19, 36, 20, 0, -35 },
  { 2276, 34, 39, 38, 2, -35 },
  { 2442, 28, 35, 28, 0, -35 },
  { 2565, 22, 35, 27, 3, -35 },
  { 2662, 22, 35, 25, 2, -35 },
  { 2759, 24, 35, 29, 3, -35 },
  { 2864, 17, 35, 22, 3, -35 },
  { 2939, 17, 35, 21, 3, -35 },
  { 3014, 25, 35, 29, 2, -35 },
  { 3124, 24, 35, 30, 3, -35 },
  { 3229, 15, 35, 17, 1, -35 },
  { 3295, 14, 46, 14, -3, -35 },
  { 3376, 25, 35, 27, 3, -35 },
  { 3486, 17, 35, 21, 3, -35 },
  { 3561, 34, 35, 40, 3, -35 },
  { 3710, 26, 35, 32, 3, -35 },
  { 3824, 27, 36, 30, 2, -36 },
  { 3946, 21, 35, 25, 3, -35 },
  { 4038, 27, 44, 30, 2, -36 },
  { 4187, 24, 35, 27, 3, -35 },
  { 4292, 20, 35, 22, 1, -35 },
  { 4380, 21, 35, 23, 1, -35 },
  { 4472, 23, 35, 29, 3, -35 },
  { 4573, 27, 35, 27, 0, -35 },
  { 4692, 40, 35, 40, 0, -35 },
  { 4867, 26, 35, 25, 0, -35 },
  { 4981, 26, 35, 26, 0, -35 },
  { 5095, 21, 35, 23, 1, -35 },
  { 5187, 12, 44, 15, 2, -36 },
  { 5253, 21, 35, 21, 0, -35 },
  { 5345, 12, 44, 15, 1, -36 },
  { 5411, 26, 23, 27, 0, -35 },
  { 5486, 25, 6, 25, 0, 3 },
  { 5505, 13, 8, 17, 2, -38 },
  { 5518, 21, 28, 24, 1, -28 },
  { 5592, 22, 37, 26, 2, -37 },
  { 5694, 18, 28, 21, 2, -28 },
  { 5757, 21, 37, 26, 2, -37 },
  { 5855, 20, 28, 24, 2, -28 },
  { 5925, 17, 37, 16, 0, -37 },
  { 6004, 21, 40, 26, 2, -28 },
  { 6109, 22, 37, 26, 2, -37 },
  { 6211, 9, 38, 13, 2, -38 },
  { 6254, 13, 50, 13, -2, -38 },
  { 6336, 24, 37, 26, 2, -37 },
  { 6447, 8, 37, 13, 2, -37 },
  { 6484, 34, 28, 39, 2, -28 },
  { 6603, 22, 28, 26, 2, -28 },
  { 6680, 22, 28, 25, 2, -28 },
  { 6757, 22, 40, 26, 2, -28 },
  { 6867, 21, 40, 26, 2, -28 },
  { 6972, 16, 28, 18, 2, -28 },
  { 7028, 17, 28, 19, 1, -28 },
  { 7088, 16, 33, 17, 0, -33 },
  { 7154, 21, 27, 26, 2, -27 },
  { 7225, 24, 27, 24, 0, -27 },
  { 7306, 36, 27, 36, 0, -27 },
  { 7428, 23, 27, 23, 0, -27 },
  { 7506, 24, 39, 24, 0, -27 },
  { 7623, 18, 27, 19, 1, -27 },
  { 7684, 16, 43, 18, 1, -35 },
  { 7770, 7, 49, 21, 7, -38 },
  { 7813, 16, 43, 18, 1, -35 },
  { 7899, 22, 9, 25, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Black49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK49PT7B_H_
