#ifndef _NOTOSANS_EXTRACONDENSED_BLACK28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0E, 0xFF,
  0xFE, 0xF0, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9E, 0xF3, 0xDC, 0x78,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x1E, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x8E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x06,
  0x00, 0x60, 0x1F, 0xC7, 0xFE, 0x7F, 0xEF, 0x6E, 0xF6, 0x0F, 0x60, 0x7E,
  0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x7F, 0x06, 0xF8, 0x6F, 0xF7,
  0xEF, 0xFE, 0xFF, 0xC3, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x07,
  0x81, 0xF8, 0x1C, 0x0F, 0xF0, 0xE0, 0x39, 0xC3, 0x80, 0xE7, 0x1E, 0x03,
  0x9E, 0x70, 0x0E, 0x7B, 0xC0, 0x39, 0xCE, 0x00, 0xE7, 0x39, 0xF3, 0xFD,
  0xEF, 0xE7, 0xE7, 0x7F, 0x8F, 0xBD, 0xEF, 0x00, 0xE7, 0xBC, 0x03, 0x9C,
  0xF0, 0x1E, 0x73, 0xC0, 0x71, 0xCF, 0x03, 0xC7, 0xBC, 0x0E, 0x0F, 0xE0,
  0x38, 0x3F, 0x81, 0xE0, 0x7C, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F,
  0x9E, 0x07, 0xCF, 0x03, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xCF, 0x9F, 0xF7, 0xDF, 0xFB, 0xEF, 0xBF, 0xE7, 0x9F, 0xF3, 0xC7,
  0xF9, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF0,
  0xFF, 0xFF, 0xFF, 0xBD, 0xC0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78,
  0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF8, 0x07, 0x80, 0x38, 0x11, 0xC4,
  0xEE, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xF8, 0x3F, 0xE3, 0xEF, 0x8F,
  0x38, 0x11, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x7B, 0xDF, 0xFF, 0xFB, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF,
  0xF7, 0x80, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0x83, 0xFC, 0x7F,
  0xC7, 0xFE, 0x79, 0xEF, 0x9E, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xF7, 0x9E, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC1, 0xF8, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBD, 0xCF,
  0x23, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xF6, 0x3E, 0x87, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xFC, 0xFF, 0xE7,
  0xFE, 0x43, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x3F, 0xC3, 0xF0, 0x3F, 0xC3,
  0xFE, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1D, 0xF0, 0xF7, 0xC7, 0x9F, 0x1E, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3E,
  0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x3F, 0xE7, 0xFE,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x7C, 0xF7, 0xEF, 0xFE, 0xFF, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xFE, 0x7F, 0xEF, 0xFE,
  0xF9, 0xEF, 0x9E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x3F, 0xC7, 0xFE,
  0xF9, 0xFF, 0x9F, 0xF0, 0xFF, 0x1F, 0xFB, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8,
  0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xF9, 0xEF, 0x9F, 0xF1, 0xFF, 0x1F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0x3D, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xE0, 0x33, 0xFF, 0xF7, 0x98, 0x00, 0x00,
  0x00, 0xF7, 0xFF, 0xEF, 0x33, 0xFF, 0xF7, 0x98, 0x00, 0x00, 0x00, 0x07,
  0xBD, 0xFF, 0xFF, 0xBD, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x3F,
  0xEF, 0xF8, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x3F, 0x9F, 0xFB, 0xFF, 0x3F, 0xF6, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x1E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0x9F, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x8F, 0xDE, 0x73, 0xFC, 0xEF,
  0x3D, 0xCE, 0xE7, 0x9C, 0xEE, 0x79, 0xCF, 0xE7, 0x1C, 0xFE, 0x71, 0xCE,
  0xE7, 0x1C, 0xEE, 0x7B, 0xCE, 0xE3, 0xFF, 0xCF, 0x3E, 0xFC, 0x70, 0xC7,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xFF, 0xEF, 0xFC, 0xFF, 0xEF, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F,
  0xE0, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xC2, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x82, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xEF, 0x1F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x7E, 0xFF, 0xF7,
  0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x09,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF8, 0x3F, 0xE0, 0xF7, 0xC3, 0xDF, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0xFF, 0xC3,
  0xEF, 0x1F, 0x3C, 0x7C, 0xF3, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xCF, 0x8F, 0x3E, 0x3C,
  0x7C, 0xF1, 0xF3, 0xC7, 0xEF, 0x0F, 0xBC, 0x3F, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFE, 0xF7, 0xFF, 0xDE, 0xEF, 0xFB,
  0xDD, 0xFF, 0x3F, 0xBF, 0xE7, 0xF7, 0xFC, 0xFC, 0xFF, 0x9F, 0x9F, 0xF1,
  0xF3, 0xFE, 0x3E, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xF0, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0xBF, 0xEF, 0x7F, 0xDF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xF0, 0x0F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xDF, 0x0F, 0xBE, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDF, 0x0F, 0xBE,
  0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF,
  0xEF, 0x3F, 0x78, 0xFB, 0xC7, 0xDE, 0x3E, 0xF3, 0xE7, 0xFF, 0x3F, 0xF1,
  0xFF, 0x0F, 0xFC, 0x7B, 0xE3, 0xCF, 0x9E, 0x7C, 0xF1, 0xF7, 0x8F, 0xBC,
  0x3F, 0xE1, 0xF0, 0x1F, 0xCF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8D, 0xF0, 0x3E,
  0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF8, 0x1F,
  0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF8, 0x78, 0x3F, 0xF0, 0xF8, 0x7B, 0xE1, 0xF1, 0xF3, 0xC3,
  0xE3, 0xE7, 0x87, 0xC7, 0xCF, 0x9F, 0x8F, 0x9F, 0x3F, 0x1E, 0x3E, 0x7F,
  0x3C, 0x3C, 0xFE, 0x78, 0x79, 0xDD, 0xF0, 0xF7, 0xBB, 0xE1, 0xEF, 0x77,
  0xC3, 0xFE, 0xEF, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00,
  0xF8, 0x7C, 0xF9, 0xF1, 0xF3, 0xE1, 0xE7, 0xC3, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3C, 0xF8, 0xF8, 0xF1, 0xF1, 0xF7,
  0xC3, 0xF0, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x87,
  0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78, 0xF1, 0xF0, 0xF3, 0xC1,
  0xEF, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x78, 0x78,
  0xF0, 0x0F, 0x0F, 0xF9, 0xFF, 0x9F, 0xF2, 0x1E, 0x03, 0xC7, 0xFB, 0xFF,
  0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xBB, 0xE7, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0xE3, 0xEF, 0x9F, 0xFE,
  0xFF, 0xF7, 0xEF, 0xBE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0x3C, 0x00, 0x0F, 0x0F,
  0xF7, 0xFD, 0xFF, 0xFC, 0xBE, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE1, 0xFF, 0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF1, 0xCF, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF,
  0x3E, 0xF0, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF9, 0xEF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x82, 0xFC, 0xE7, 0xFE, 0x3F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xE3, 0xF8, 0xFA, 0x3C, 0x0F, 0x07, 0xFB, 0xFE,
  0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1C, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9,
  0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0x7E, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x61, 0xF7, 0xFE, 0x7F,
  0xE7, 0xFC, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x9C, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0,
  0x77, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x1F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F,
  0xFF, 0xF7, 0xEF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x8F, 0xBE, 0x3C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xF9, 0xF3, 0xE7, 0xCF,
  0x8F, 0xBE, 0x3E, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC3, 0x8F, 0x7E, 0x7E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFD, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0x01,
  0xCF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x0F,
  0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xDE, 0x1F,
  0xF0, 0xFF, 0xC7, 0xBE, 0x3D, 0xF1, 0xE7, 0xFF, 0x3F, 0xF0, 0xFF, 0x83,
  0xF0, 0x01, 0xC7, 0x9F, 0x3F, 0xFD, 0xFF, 0xEF, 0xDF, 0x7C, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x9F, 0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x1C, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x9F,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0x7E, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x01, 0xF9, 0xFD, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x1C, 0x3F, 0xFF, 0xFF,
  0xFF, 0x17, 0xC3, 0xF1, 0xFE, 0x7F, 0x9F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFC, 0x1C, 0x0E, 0x07, 0x07, 0x87, 0xFF, 0xFF, 0xFE, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0x3F, 0x9F, 0xC7, 0xE0,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0xF8,
  0x7D, 0xE1, 0xE7, 0x8F, 0x9F, 0x3E, 0x7C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F,
  0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0xF7, 0x9F, 0x8F, 0x79, 0xF9, 0xF7, 0x9F, 0xDF,
  0x79, 0xFD, 0xE7, 0xDD, 0xDE, 0x3F, 0xDD, 0xE3, 0xFD, 0xDE, 0x3F, 0xDD,
  0xE3, 0xF9, 0xDC, 0x3F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x8F, 0x80, 0xFC, 0xFB, 0xEF, 0x8F, 0x7C, 0x7F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7B, 0xE7,
  0xDF, 0x3E, 0x7B, 0xE3, 0xE0, 0xF8, 0x7D, 0xE1, 0xE7, 0xCF, 0x9F, 0x3E,
  0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x7F, 0xCF, 0xF9, 0xFF,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xF1, 0xFC, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x0F, 0xE3, 0xF0, 0xF9, 0xFC, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC7, 0xE3, 0xF1, 0xF0, 0x80, 0x00, 0x10, 0x1F, 0xE1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF8, 0x1C,
};

const GFXglyph NotoSans_ExtraCondensed_Black28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 20, 8, 1, -20 },
  { 14, 11, 7, 14, 1, -20 },
  { 24, 14, 20, 15, 1, -20 },
  { 59, 12, 23, 14, 1, -21 },
  { 94, 22, 20, 24, 1, -20 },
  { 149, 17, 20, 18, 1, -20 },
  { 192, 5, 7, 7, 1, -20 },
  { 197, 8, 25, 9, 1, -21 },
  { 222, 8, 25, 9, 0, -21 },
  { 247, 13, 12, 13, 0, -21 },
  { 267, 12, 14, 14, 1, -17 },
  { 288, 5, 8, 8, 1, -4 },
  { 293, 7, 5, 9, 1, -10 },
  { 298, 5, 5, 8, 1, -5 },
  { 302, 12, 20, 12, 0, -20 },
  { 332, 12, 20, 14, 1, -20 },
  { 362, 10, 20, 14, 1, -20 },
  { 387, 11, 20, 14, 1, -20 },
  { 415, 12, 20, 14, 1, -20 },
  { 445, 14, 20, 14, 0, -20 },
  { 480, 12, 20, 14, 1, -20 },
  { 510, 12, 20, 14, 1, -20 },
  { 540, 12, 20, 14, 1, -20 },
  { 570, 12, 20, 14, 1, -20 },
  { 600, 12, 20, 14, 1, -20 },
  { 630, 5, 16, 8, 1, -16 },
  { 640, 5, 20, 8, 1, -16 },
  { 653, 12, 14, 14, 1, -17 },
  { 674, 12, 10, 14, 1, -15 },
  { 689, 12, 14, 14, 1, -17 },
  { 710, 11, 20, 11, 0, -20 },
  { 738, 20, 22, 21, 1, -20 },
  { 793, 16, 20, 16, 0, -20 },
  { 833, 12, 20, 16, 2, -20 },
  { 863, 13, 20, 14, 1, -20 },
  { 896, 13, 20, 16, 2, -20 },
  { 929, 9, 20, 12, 2, -20 },
  { 952, 9, 20, 12, 2, -20 },
  { 975, 14, 20, 17, 1, -20 },
  { 1010, 13, 20, 17, 2, -20 },
  { 1043, 8, 20, 10, 1, -20 },
  { 1063, 8, 26, 8, -2, -20 },
  { 1089, 14, 20, 15, 2, -20 },
  { 1124, 10, 20, 12, 2, -20 },
  { 1149, 19, 20, 23, 2, -20 },
  { 1197, 15, 20, 18, 2, -20 },
  { 1235, 15, 20, 17, 1, -20 },
  { 1273, 12, 20, 15, 2, -20 },
  { 1303, 15, 25, 17, 1, -20 },
  { 1350, 13, 20, 15, 2, -20 },
  { 1383, 11, 20, 13, 1, -20 },
  { 1411, 12, 20, 13, 0, -20 },
  { 1441, 13, 20, 16, 2, -20 },
  { 1474, 16, 20, 16, 0, -20 },
  { 1514, 23, 20, 23, 0, -20 },
  { 1572, 15, 20, 15, 0, -20 },
  { 1610, 15, 20, 15, 0, -20 },
  { 1648, 12, 20, 13, 1, -20 },
  { 1678, 7, 26, 8, 1, -21 },
  { 1701, 12, 20, 12, 0, -20 },
  { 1731, 7, 26, 8, 0, -21 },
  { 1754, 15, 13, 15, 0, -20 },
  { 1779, 14, 3, 14, 0, 2 },
  { 1785, 7, 4, 10, 1, -21 },
  { 1789, 11, 16, 14, 1, -16 },
  { 1811, 13, 21, 15, 1, -21 },
  { 1846, 10, 16, 12, 1, -16 },
  { 1866, 12, 21, 15, 1, -21 },
  { 1898, 12, 16, 14, 1, -16 },
  { 1922, 10, 21, 9, 0, -21 },
  { 1949, 12, 23, 15, 1, -16 },
  { 1984, 12, 21, 15, 1, -21 },
  { 2016, 5, 22, 7, 1, -22 },
  { 2030, 7, 29, 7, -1, -22 },
  { 2056, 14, 21, 15, 1, -21 },
  { 2093, 5, 21, 7, 1, -21 },
  { 2107, 20, 16, 22, 1, -16 },
  { 2147, 12, 16, 15, 1, -16 },
  { 2171, 13, 16, 14, 1, -16 },
  { 2197, 13, 23, 15, 1, -16 },
  { 2235, 12, 23, 15, 1, -16 },
  { 2270, 9, 16, 11, 1, -16 },
  { 2288, 9, 16, 11, 1, -16 },
  { 2306, 9, 19, 10, 0, -19 },
  { 2328, 12, 15, 15, 1, -15 },
  { 2351, 14, 15, 14, 0, -15 },
  { 2378, 20, 15, 21, 0, -15 },
  { 2416, 13, 15, 13, 0, -15 },
  { 2441, 14, 22, 14, 0, -15 },
  { 2480, 11, 15, 11, 0, -15 },
  { 2501, 10, 25, 10, 0, -20 },
  { 2533, 4, 28, 12, 4, -22 },
  { 2547, 9, 25, 10, 1, -20 },
  { 2576, 12, 6, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Black28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK28PT7B_H_
