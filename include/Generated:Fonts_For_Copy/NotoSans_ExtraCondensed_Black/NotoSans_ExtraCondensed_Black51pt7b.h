#ifndef _NOTOSANS_EXTRACONDENSED_BLACK51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x7F, 0x9F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFD, 0xFF, 0x1F, 0xEF, 0xF0,
  0xFF, 0x7F, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xDE,
  0xF9, 0xFC, 0xF0, 0xCF, 0xE7, 0x80, 0x7F, 0x3C, 0x03, 0xF9, 0xE0, 0x0F,
  0xEF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xDF, 0xC0, 0x1E, 0xFE, 0x00, 0xF3, 0xF4, 0x07, 0xBF,
  0xB8, 0x3D, 0xFD, 0xF1, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0x80,
  0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xF9, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x8F, 0xC1, 0xF8, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x00,
  0x0F, 0xE3, 0xF0, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x0F, 0xE0, 0x7E, 0x7F, 0x3F,
  0x1F, 0xF8, 0x3F, 0xFF, 0x1F, 0x8F, 0xFE, 0x0F, 0xFF, 0x9F, 0xCF, 0xFF,
  0x87, 0xFF, 0xCF, 0xCF, 0xFF, 0xC1, 0xFF, 0xC7, 0xE7, 0xF7, 0xF0, 0x7F,
  0xC7, 0xE3, 0xF1, 0xF8, 0x0F, 0x83, 0xF1, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC7, 0xF0, 0x00,
  0x7E, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x81,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xFE,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x02, 0x07, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0x87,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0xF7,
  0xF8, 0x7F, 0xDF, 0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x03, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0C, 0x1F, 0x83, 0x1E, 0x3F, 0x1E,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x9F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFC,
  0x3F, 0x80, 0xF8, 0x7C, 0x00, 0xE0, 0x70, 0x00, 0x40, 0x40, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xDF, 0xF7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x1F, 0xE7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F,
  0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x8F, 0xF3, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0xFF, 0x1F,
  0xF7, 0xF8, 0xFF, 0xBF, 0xE7, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x3F, 0xCF, 0xCF, 0xF1, 0xE3,
  0xFC, 0x30, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3E, 0x0F,
  0xF8, 0x70, 0x3F, 0xE1, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xEF, 0xFE, 0x38, 0x1F, 0xF1, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xEF,
  0xF0, 0x0F, 0xEF, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xCF,
  0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE3, 0x8F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFE, 0x04, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x7E, 0x0F, 0xF7, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFB, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE,
  0xFF, 0x87, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE3,
  0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0x3F, 0xE3, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xEF, 0xF8, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xF7, 0xFC, 0xFF, 0x8F,
  0xFB, 0xFC, 0x3F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF,
  0xE3, 0xFF, 0x3F, 0x87, 0xFD, 0xFE, 0x07, 0xC7, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x0F, 0xC7,
  0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x87, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0xE7, 0xF9, 0xFF, 0xFF, 0xDF, 0xF7, 0xFD, 0xFE, 0x3F, 0x01, 0x00, 0x0C,
  0x0F, 0xC7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x87, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xF7, 0xFF, 0x38, 0x1F, 0xF2, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x0F,
  0x83, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x1F, 0x83, 0xFF, 0xE7, 0xE7, 0xE0,
  0xFF, 0xFC, 0x7E, 0xFC, 0x3F, 0xFF, 0x8F, 0xDF, 0x8F, 0xE3, 0xF1, 0xFF,
  0xE1, 0xF8, 0x7E, 0x3F, 0xFC, 0x7F, 0x0F, 0xC3, 0xFF, 0x8F, 0xC1, 0xF8,
  0x7F, 0xF1, 0xF8, 0x3F, 0x0F, 0xFE, 0x3F, 0x07, 0xE1, 0xFF, 0xC7, 0xE0,
  0xFC, 0x3F, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0x1F, 0x87, 0xF1, 0xFF, 0xE3,
  0xF0, 0xFE, 0x3F, 0xFC, 0x7E, 0x1F, 0x87, 0xDF, 0x8F, 0xE3, 0xF9, 0xFB,
  0xF0, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF, 0xBF,
  0xF0, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xE0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x03,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xEF, 0xF8, 0x7F, 0xDF, 0xF1, 0xFF, 0xBF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xF0, 0x38, 0xFF, 0xC0, 0x11, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x87, 0xFF, 0x07, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF9, 0xFF, 0x1F, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF,
  0xBF, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x06, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC,
  0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x7F, 0xCF, 0xFE, 0x1F, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F,
  0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x3F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x3F,
  0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF, 0xDF, 0xC7, 0xF7, 0xFF,
  0xFB, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0x1F, 0xDF, 0xFF, 0xEF, 0xF3, 0xF3,
  0xFF, 0xFC, 0xFE, 0xFE, 0x7F, 0xFF, 0x9F, 0xDF, 0xCF, 0xFF, 0xF3, 0xFB,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB,
  0xFC, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xE7, 0xFB, 0xFF, 0xFC, 0xFF, 0x3F,
  0xFF, 0x9F, 0xF7, 0xFF, 0xF1, 0xFE, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xF1, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF,
  0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xC1, 0xE3,
  0xFE, 0x03, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F,
  0xEF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC,
  0x07, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF,
  0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xDF,
  0x8F, 0xF8, 0x3F, 0xC7, 0xEF, 0xC7, 0xF8, 0x1F, 0xE3, 0xF7, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFB, 0xF1, 0xFE, 0x03, 0xFD, 0xFD, 0xFD, 0xFF, 0x01, 0xFE,
  0xFE, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x3F, 0x7F, 0x80, 0x7F, 0xBF, 0x9F,
  0xBF, 0xC0, 0x3F, 0xDF, 0x8F, 0xDF, 0xE0, 0x0F, 0xEF, 0xC7, 0xEF, 0xF0,
  0x07, 0xF7, 0xE3, 0xF7, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC1, 0xFE, 0x08, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFD, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0x9F, 0xCF, 0xFC, 0x7F, 0x1F, 0xE0, 0xFC, 0x0C, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0xF0, 0x3F, 0xCF, 0xF0, 0xFF, 0x7F, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFE, 0xFF, 0xE3, 0xF9, 0xFF, 0x0F, 0xC3, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x3C, 0xFF, 0xC0, 0x9F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x05, 0xFF, 0x81, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x38, 0x3F, 0xC3, 0xFC, 0xFF, 0x1F, 0xFB,
  0xFC, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0xDF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xF0, 0xFF, 0x1F,
  0xC0, 0x20, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x19, 0xFF, 0x03, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFE,
  0x7F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xF7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xBF, 0xC7, 0xFE, 0xFF, 0x0F, 0xE3, 0xFC, 0x06, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x40, 0x07, 0xF9, 0xC0, 0x3F, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0x81,
  0xFE, 0x7F, 0x8F, 0xE7, 0xFE, 0x7F, 0x7F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xE0, 0x08, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x00,
  0x80, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFE,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x78, 0x1F, 0x87, 0xF8, 0x3F, 0xC3, 0xF1, 0xFF, 0x8F,
  0xFE, 0x7F, 0x7F, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF,
  0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x83,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0x07, 0xE1, 0xFE,
  0x3F, 0x1F, 0xF9, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE7, 0xFC, 0xFF,
  0x87, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF8, 0x3F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xFB, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFF, 0x0F, 0xE7, 0xFE, 0x3F,
  0xBF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF3,
  0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xDF, 0xF8, 0xFF, 0x3F, 0x83, 0xFC,
  0x18, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xC7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFE, 0x7F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xBF, 0xC7, 0xFE,
  0xFF, 0x0F, 0xE3, 0xFC, 0x04, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFC, 0x1C, 0xFF, 0x01, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x23, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x04, 0x00, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0xC7, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1, 0xFF, 0x8F,
  0xC3, 0xFC, 0x3F, 0x01, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0xC1, 0xFE,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFF,
  0x87, 0xF8, 0xFF, 0x1F, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xDF, 0x8F, 0xE1, 0xFE, 0x7E, 0xFC, 0xFF, 0x0F, 0xF3, 0xF7, 0xE7,
  0xF8, 0x3F, 0x9F, 0xBF, 0x3F, 0xC1, 0xFE, 0xFD, 0xFD, 0xFE, 0x0F, 0xF7,
  0xE7, 0xEF, 0xE0, 0x7F, 0xBF, 0x3F, 0x7F, 0x01, 0xFF, 0xF9, 0xFB, 0xF8,
  0x0F, 0xFF, 0x8F, 0xDF, 0xC0, 0x7F, 0xFC, 0x7E, 0xFE, 0x03, 0xFF, 0xE3,
  0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x7F,
  0xC3, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F,
  0xF7, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F,
  0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0, 0x05, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFD, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 37, 14, 2, -36 },
  { 48, 21, 13, 25, 2, -36 },
  { 83, 26, 36, 28, 1, -36 },
  { 200, 21, 42, 25, 2, -39 },
  { 311, 41, 37, 43, 1, -37 },
  { 501, 32, 38, 33, 1, -37 },
  { 653, 9, 13, 13, 2, -36 },
  { 668, 15, 45, 17, 2, -37 },
  { 753, 14, 45, 17, 0, -37 },
  { 832, 23, 23, 24, 1, -39 },
  { 899, 22, 24, 26, 2, -30 },
  { 965, 10, 14, 14, 2, -7 },
  { 983, 14, 8, 17, 1, -18 },
  { 997, 10, 10, 14, 2, -9 },
  { 1010, 22, 38, 22, 0, -37 },
  { 1115, 21, 38, 25, 2, -37 },
  { 1215, 18, 36, 25, 2, -36 },
  { 1296, 22, 37, 25, 1, -37 },
  { 1398, 21, 38, 25, 2, -37 },
  { 1498, 24, 36, 25, 1, -36 },
  { 1606, 20, 37, 25, 3, -36 },
  { 1699, 22, 38, 25, 2, -37 },
  { 1804, 21, 36, 25, 2, -36 },
  { 1899, 22, 38, 25, 2, -37 },
  { 2004, 22, 38, 25, 2, -37 },
  { 2109, 10, 30, 14, 2, -29 },
  { 2147, 10, 36, 14, 2, -29 },
  { 2192, 23, 25, 26, 1, -31 },
  { 2264, 22, 18, 26, 2, -27 },
  { 2314, 22, 25, 26, 2, -31 },
  { 2383, 20, 38, 21, 0, -37 },
  { 2478, 35, 41, 39, 2, -37 },
  { 2658, 29, 36, 29, 0, -36 },
  { 2789, 23, 36, 28, 3, -36 },
  { 2893, 23, 38, 26, 2, -37 },
  { 3003, 25, 36, 30, 3, -36 },
  { 3116, 18, 36, 23, 3, -36 },
  { 3197, 17, 36, 22, 3, -36 },
  { 3274, 26, 38, 30, 2, -37 },
  { 3398, 25, 36, 31, 3, -36 },
  { 3511, 16, 36, 18, 1, -36 },
  { 3583, 15, 47, 15, -3, -36 },
  { 3672, 26, 36, 28, 3, -36 },
  { 3789, 18, 36, 22, 3, -36 },
  { 3870, 35, 36, 41, 3, -36 },
  { 4028, 27, 36, 33, 3, -36 },
  { 4150, 28, 38, 32, 2, -37 },
  { 4283, 22, 36, 27, 3, -36 },
  { 4382, 28, 46, 32, 2, -37 },
  { 4543, 25, 36, 28, 3, -36 },
  { 4656, 21, 38, 23, 1, -37 },
  { 4756, 22, 36, 23, 1, -36 },
  { 4855, 24, 37, 30, 3, -36 },
  { 4966, 29, 36, 29, 0, -36 },
  { 5097, 41, 36, 41, 0, -36 },
  { 5282, 27, 36, 27, 0, -36 },
  { 5404, 27, 36, 27, 0, -36 },
  { 5526, 22, 36, 24, 1, -36 },
  { 5625, 13, 46, 15, 2, -37 },
  { 5700, 22, 38, 22, 0, -37 },
  { 5805, 12, 46, 15, 1, -37 },
  { 5874, 27, 24, 28, 0, -36 },
  { 5955, 26, 6, 26, 0, 3 },
  { 5975, 13, 8, 17, 2, -39 },
  { 5988, 22, 30, 25, 1, -29 },
  { 6071, 22, 40, 27, 3, -39 },
  { 6181, 19, 30, 22, 2, -29 },
  { 6253, 22, 40, 27, 2, -39 },
  { 6363, 21, 30, 25, 2, -29 },
  { 6442, 18, 39, 17, 0, -39 },
  { 6530, 22, 41, 27, 2, -29 },
  { 6643, 21, 39, 27, 3, -39 },
  { 6746, 9, 40, 14, 2, -40 },
  { 6791, 13, 52, 14, -2, -40 },
  { 6876, 24, 39, 27, 3, -39 },
  { 6993, 8, 39, 13, 3, -39 },
  { 7032, 35, 29, 40, 3, -29 },
  { 7159, 21, 29, 27, 3, -29 },
  { 7236, 23, 30, 26, 2, -29 },
  { 7323, 22, 41, 27, 3, -29 },
  { 7436, 22, 41, 27, 2, -29 },
  { 7549, 16, 29, 19, 3, -29 },
  { 7607, 18, 30, 20, 1, -29 },
  { 7675, 17, 35, 18, 0, -34 },
  { 7750, 22, 29, 27, 2, -28 },
  { 7830, 25, 28, 25, 0, -28 },
  { 7918, 37, 28, 38, 0, -28 },
  { 8048, 24, 28, 24, 0, -28 },
  { 8132, 25, 40, 25, 0, -28 },
  { 8257, 18, 28, 20, 1, -28 },
  { 8320, 17, 46, 19, 1, -37 },
  { 8418, 7, 51, 21, 7, -39 },
  { 8463, 17, 46, 19, 1, -37 },
  { 8561, 23, 10, 26, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Black51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK51PT7B_H_
