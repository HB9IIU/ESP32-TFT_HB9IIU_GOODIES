#ifndef _NOTOSANS_EXTRALIGHTITALIC7PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x37, 0x5E, 0xA0, 0x34, 0x25, 0xE0, 0xDE, 0xB5,
  0xB0, 0x75, 0x6B, 0xF0, 0xC0, 0x5A, 0xA0, 0x55, 0xA0, 0xD5, 0x00, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x79, 0x99, 0xE0, 0xD5, 0x80, 0x71,
  0x24, 0xE0, 0x71, 0x61, 0xE0, 0x32, 0x6F, 0x20, 0x74, 0x21, 0xE0, 0x74,
  0xB9, 0xE0, 0xE9, 0x48, 0x75, 0x69, 0xE0, 0x79, 0xF1, 0xE0, 0x90, 0x98,
  0x71, 0x80, 0xE0, 0xC7, 0x00, 0xDA, 0x00, 0x39, 0x5B, 0x75, 0xA9, 0xC0,
  0x26, 0x5B, 0x90, 0x75, 0xE9, 0xF0, 0xF2, 0x4E, 0x75, 0x59, 0xE0, 0x74,
  0xE8, 0xE0, 0x74, 0x68, 0x80, 0xF8, 0xA9, 0xE0, 0x4A, 0x7F, 0x29, 0x00,
  0x56, 0x80, 0x24, 0xA5, 0x80, 0x56, 0x4A, 0x90, 0x4A, 0x4E, 0x45, 0x2B,
  0x6A, 0xA8, 0x4A, 0x6B, 0x69, 0x00, 0xF9, 0x99, 0xE0, 0x75, 0xF8, 0x80,
  0xF9, 0x99, 0xA6, 0x75, 0x6A, 0x90, 0x78, 0x42, 0xE0, 0xEA, 0x48, 0x99,
  0x9A, 0xE0, 0xB7, 0x48, 0xAF, 0x7B, 0x2A, 0x00, 0x56, 0x4A, 0xA0, 0xBA,
  0x48, 0x72, 0x44, 0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x24, 0x93, 0x80, 0x26,
  0x90, 0xE0, 0x80, 0x79, 0x9E, 0x46, 0x99, 0xE0, 0x72, 0x70, 0x17, 0x99,
  0xE0, 0x77, 0x70, 0x36, 0x44, 0x44, 0x80, 0x79, 0x9E, 0x2C, 0x46, 0x99,
  0xA0, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4F, 0x6A, 0x5A, 0x80, 0x6A, 0x5A,
  0x6A, 0x69, 0x9A, 0x69, 0x9E, 0x69, 0x9E, 0x88, 0x79, 0x9E, 0x22, 0x72,
  0x40, 0x71, 0xF0, 0x7A, 0xC0, 0x59, 0x9E, 0xB7, 0x40, 0xAD, 0x5D, 0x40,
  0xA9, 0x50, 0x55, 0x64, 0x48, 0x65, 0x60, 0x69, 0x49, 0x00, 0xFE, 0x55,
  0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 4, 5, 5, 1, -5 },
  { 13, 4, 5, 5, 0, -5 },
  { 16, 1, 2, 1, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 4, 1, -5 },
  { 23, 3, 3, 4, 1, -4 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 5, 2, 0, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 2, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 1, 4, 2, 0, -4 },
  { 59, 1, 5, 2, 0, -4 },
  { 60, 3, 3, 4, 1, -4 },
  { 62, 3, 1, 4, 1, -3 },
  { 63, 3, 3, 4, 1, -4 },
  { 65, 2, 5, 3, 1, -5 },
  { 67, 6, 6, 6, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 4, 5, 5, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 3, 0, -5 },
  { 89, 4, 5, 5, 1, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 2, 5, 2, 0, -5 },
  { 98, 3, 6, 2, -1, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 6, 5, 6, 0, -5 },
  { 110, 5, 5, 5, 0, -5 },
  { 114, 4, 5, 5, 1, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 6, 5, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 3, 5, 3, 1, -5 },
  { 131, 4, 5, 5, 1, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 5, 5, 6, 1, -5 },
  { 140, 4, 5, 3, 0, -5 },
  { 143, 3, 5, 3, 1, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 3, 6, 2, 0, -5 },
  { 151, 1, 5, 2, 1, -5 },
  { 152, 3, 6, 2, -1, -5 },
  { 155, 4, 3, 4, 0, -5 },
  { 157, 3, 1, 3, -1, 0 },
  { 158, 1, 1, 2, 1, -5 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 4, 5, 4, 0, -5 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 4, 7, 2, -1, -5 },
  { 175, 4, 6, 4, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 2, 5, 2, 0, -5 },
  { 183, 3, 7, 2, -1, -5 },
  { 186, 3, 5, 3, 0, -5 },
  { 188, 2, 5, 2, 0, -5 },
  { 190, 6, 4, 6, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -4 },
  { 200, 4, 6, 4, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 2, 5, 2, 0, -5 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 3, 4, 3, 0, -4 },
  { 213, 5, 4, 5, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 4, 6, 3, -1, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 3, 6, 2, 0, -5 },
  { 226, 1, 7, 4, 2, -5 },
  { 227, 2, 6, 2, 0, -5 },
  { 229, 3, 1, 4, 1, -3 },
};

const GFXfont NotoSans_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRALIGHTITALIC7PT7B_H_
