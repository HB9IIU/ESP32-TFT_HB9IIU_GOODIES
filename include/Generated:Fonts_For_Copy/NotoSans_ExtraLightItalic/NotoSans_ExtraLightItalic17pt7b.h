#ifndef _NOTOSANS_EXTRALIGHTITALIC17PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x94, 0x80, 0x40, 0x99, 0xAA, 0x09, 0x02, 0x41, 0x11,
  0xF7, 0x12, 0x08, 0x82, 0x23, 0xFE, 0x24, 0x11, 0x04, 0x41, 0x20, 0x04,
  0x04, 0x3B, 0x48, 0x48, 0x48, 0x30, 0x1C, 0x12, 0x12, 0x12, 0xFC, 0x20,
  0x20, 0x38, 0x68, 0x89, 0x12, 0x44, 0x88, 0xA5, 0x15, 0x55, 0x49, 0x51,
  0x12, 0x22, 0x44, 0x88, 0xA0, 0xE0, 0x1E, 0x08, 0x42, 0x10, 0x88, 0x14,
  0x06, 0x06, 0x86, 0x12, 0x82, 0xA0, 0xC8, 0x31, 0xF2, 0xF0, 0x12, 0x24,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x80, 0x10, 0x42, 0x10, 0x84, 0x21, 0x10,
  0x84, 0x42, 0x22, 0x00, 0x08, 0x23, 0x41, 0xF3, 0x09, 0x22, 0x00, 0x08,
  0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x29, 0x40, 0xF0, 0x80, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x35,
  0x92, 0x22, 0x22, 0x44, 0x44, 0x1F, 0x00, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x1F, 0xC0, 0x1F, 0x10, 0x40, 0x20, 0x10,
  0x10, 0xF0, 0x08, 0x02, 0x01, 0x00, 0x80, 0x9F, 0x80, 0x01, 0x81, 0x41,
  0x41, 0x20, 0x90, 0x88, 0x88, 0x84, 0xFF, 0x81, 0x00, 0x80, 0x80, 0x3F,
  0x20, 0x20, 0x40, 0x40, 0x7C, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x0F,
  0x30, 0x20, 0x40, 0x5C, 0xA2, 0xC2, 0x81, 0x82, 0x82, 0x82, 0x7C, 0xFF,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E,
  0x21, 0x21, 0x21, 0x22, 0x1C, 0x64, 0x82, 0x82, 0x82, 0x82, 0x7C, 0x3E,
  0x41, 0x41, 0x41, 0x81, 0x43, 0x6D, 0x12, 0x02, 0x04, 0x08, 0xF0, 0x40,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x02, 0x44, 0x80, 0x01, 0x0E, 0x30, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x03,
  0x02, 0x1C, 0x60, 0x80, 0x7C, 0x10, 0x41, 0x04, 0x62, 0x10, 0x40, 0x00,
  0x30, 0x0F, 0xE0, 0x80, 0x88, 0x04, 0x87, 0x18, 0xC8, 0xC4, 0x46, 0x42,
  0x32, 0x11, 0x91, 0x14, 0x77, 0x20, 0x00, 0x80, 0x03, 0x08, 0x07, 0x80,
  0x01, 0x00, 0xC0, 0x50, 0x14, 0x08, 0x82, 0x21, 0x08, 0x7E, 0x20, 0x90,
  0x24, 0x0A, 0x01, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x13, 0xF1, 0x04, 0x82,
  0x81, 0x40, 0xA0, 0x9F, 0x80, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFC, 0x3F, 0x08, 0x22, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x02, 0x80, 0xA0, 0x48, 0x23, 0xF0, 0x3F,
  0x20, 0x20, 0x40, 0x40, 0x7E, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFC, 0x3F,
  0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x00, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x3E, 0x02, 0x80,
  0x90, 0x24, 0x08, 0xFC, 0x20, 0x24, 0x08, 0x81, 0x20, 0x24, 0x04, 0xFF,
  0x10, 0x22, 0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x80, 0x1C, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x38, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x38, 0x00, 0x20, 0xC8, 0x42, 0x21,
  0x10, 0x48, 0x1C, 0x04, 0x81, 0x20, 0x84, 0x21, 0x08, 0x22, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x3F, 0x20, 0x19, 0x80, 0x8C,
  0x0C, 0xA0, 0xA5, 0x05, 0x28, 0x49, 0x22, 0x49, 0x24, 0x8A, 0x24, 0x51,
  0x23, 0x09, 0x08, 0x80, 0x20, 0x26, 0x08, 0xC1, 0x24, 0x24, 0x84, 0x91,
  0x11, 0x22, 0x24, 0x82, 0x90, 0x52, 0x04, 0x40, 0x80, 0x1F, 0x84, 0x09,
  0x01, 0x20, 0x14, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x48, 0x11, 0x06,
  0x1F, 0x00, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x12, 0x09, 0xF8, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x00, 0x1F, 0x84, 0x09, 0x01, 0x20, 0x14, 0x03, 0x00,
  0x60, 0x14, 0x02, 0x80, 0x48, 0x11, 0x06, 0x1F, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x3F, 0x10, 0x88, 0x28, 0x14, 0x12, 0x11, 0xF0, 0x88, 0x84, 0x42,
  0x20, 0x90, 0x40, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x9F, 0x80, 0xFF, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04,
  0x80, 0x90, 0x14, 0x04, 0x80, 0x90, 0x11, 0x04, 0x1F, 0x00, 0x81, 0x81,
  0x82, 0x82, 0x84, 0x84, 0x88, 0x90, 0x50, 0x60, 0x60, 0x40, 0x82, 0x0C,
  0x30, 0x61, 0x85, 0x14, 0x28, 0x92, 0x44, 0x92, 0x45, 0x12, 0x28, 0xA1,
  0x45, 0x0C, 0x10, 0x40, 0x82, 0x00, 0x10, 0x62, 0x08, 0x22, 0x04, 0x80,
  0x60, 0x08, 0x03, 0x00, 0x50, 0x12, 0x04, 0x21, 0x04, 0x40, 0x80, 0x81,
  0x82, 0x84, 0x48, 0x48, 0x50, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x1F,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x03, 0xF8, 0x1C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x0E, 0x00, 0xAA, 0xA5, 0x55, 0x1C, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x8E, 0x00, 0x08, 0x14, 0x14, 0x22, 0x22, 0x42, 0x81,
  0xFC, 0xC8, 0x80, 0x3D, 0x43, 0x42, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x74,
  0x20, 0x20, 0x20, 0x40, 0x5E, 0x61, 0x41, 0x41, 0x81, 0x81, 0x82, 0x84,
  0xF8, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x00, 0x80, 0x40,
  0x20, 0x23, 0xD2, 0x1A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x87, 0xC0,
  0x3C, 0x85, 0x0C, 0x2F, 0x90, 0x20, 0x40, 0x7C, 0x03, 0x82, 0x01, 0x00,
  0x81, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0xC0, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x14, 0x12, 0x09, 0x04,
  0x86, 0x3E, 0x01, 0x00, 0x80, 0x8F, 0x80, 0x20, 0x40, 0x82, 0x05, 0xEC,
  0x50, 0xA1, 0x83, 0x06, 0x0C, 0x18, 0x40, 0x20, 0x24, 0x94, 0x92, 0x40,
  0x04, 0x00, 0x02, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30,
  0x20, 0x40, 0x82, 0x04, 0x28, 0x92, 0x28, 0xA1, 0xA2, 0x24, 0x48, 0x40,
  0x24, 0xA4, 0x92, 0x92, 0x48, 0x5C, 0xF6, 0x31, 0x42, 0x14, 0x21, 0x82,
  0x18, 0x21, 0x84, 0x18, 0x41, 0x84, 0x20, 0x5E, 0x61, 0x41, 0x42, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x3E, 0x42, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84,
  0x78, 0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0x84, 0xBC, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x3D, 0x43, 0x81, 0x81, 0x82, 0x82, 0x82, 0x86,
  0x7C, 0x04, 0x04, 0x04, 0x04, 0x5D, 0x84, 0x10, 0x82, 0x08, 0x20, 0x80,
  0x3E, 0x81, 0x01, 0x01, 0x80, 0x81, 0x02, 0xF8, 0x22, 0x3E, 0x84, 0x42,
  0x10, 0x84, 0x38, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x86, 0x8C, 0xF4,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x18, 0x30, 0x40, 0x84, 0x31, 0x8A, 0x31,
  0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x10, 0x82, 0x00, 0x30, 0x88, 0x84,
  0x81, 0x80, 0x80, 0xA0, 0x90, 0x44, 0xC2, 0x00, 0x10, 0x44, 0x21, 0x08,
  0x44, 0x11, 0x02, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0,
  0x00, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0xFC, 0x0E, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x60, 0x20, 0x41, 0x02, 0x04, 0x08, 0x0C, 0x00, 0xFF,
  0xFF, 0x80, 0x18, 0x10, 0x42, 0x08, 0x20, 0x83, 0x10, 0x41, 0x04, 0x20,
  0x8C, 0x00, 0x71, 0x8E,
};

const GFXglyph NotoSans_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 4, 4, 6, 2, -12 },
  { 8, 10, 12, 11, 1, -12 },
  { 23, 8, 14, 9, 1, -13 },
  { 37, 11, 12, 13, 1, -12 },
  { 54, 10, 12, 12, 1, -12 },
  { 69, 1, 4, 3, 2, -12 },
  { 70, 4, 15, 4, 1, -12 },
  { 78, 5, 15, 4, -1, -12 },
  { 88, 7, 7, 9, 2, -13 },
  { 95, 8, 8, 10, 1, -10 },
  { 103, 3, 4, 3, -1, -2 },
  { 105, 4, 1, 5, 1, -5 },
  { 106, 1, 1, 4, 1, -1 },
  { 107, 8, 12, 5, -1, -12 },
  { 119, 8, 12, 9, 1, -12 },
  { 131, 4, 12, 9, 3, -12 },
  { 137, 9, 12, 9, 0, -12 },
  { 151, 9, 12, 9, 0, -12 },
  { 165, 9, 12, 9, 0, -12 },
  { 179, 8, 12, 9, 1, -12 },
  { 191, 8, 12, 9, 1, -12 },
  { 203, 8, 12, 9, 2, -12 },
  { 215, 8, 12, 9, 1, -12 },
  { 227, 8, 12, 9, 1, -12 },
  { 239, 2, 9, 4, 1, -9 },
  { 242, 4, 11, 4, -1, -9 },
  { 248, 8, 8, 10, 1, -10 },
  { 256, 8, 4, 10, 1, -8 },
  { 260, 8, 8, 10, 1, -10 },
  { 268, 6, 12, 7, 1, -12 },
  { 277, 13, 14, 14, 1, -12 },
  { 300, 10, 12, 9, -1, -12 },
  { 315, 9, 12, 10, 1, -12 },
  { 329, 10, 12, 10, 1, -12 },
  { 344, 10, 12, 11, 1, -12 },
  { 359, 8, 12, 9, 1, -12 },
  { 371, 9, 12, 8, 1, -12 },
  { 385, 10, 12, 12, 1, -12 },
  { 400, 11, 12, 12, 1, -12 },
  { 417, 6, 12, 5, 0, -12 },
  { 426, 7, 15, 4, -3, -12 },
  { 440, 10, 12, 9, 1, -12 },
  { 455, 6, 12, 8, 1, -12 },
  { 464, 13, 12, 14, 1, -12 },
  { 484, 11, 12, 12, 1, -12 },
  { 501, 11, 12, 12, 1, -12 },
  { 518, 9, 12, 10, 1, -12 },
  { 532, 11, 15, 12, 1, -12 },
  { 553, 9, 12, 10, 1, -12 },
  { 567, 9, 12, 8, 0, -12 },
  { 581, 8, 12, 8, 2, -12 },
  { 593, 11, 12, 12, 1, -12 },
  { 610, 8, 12, 9, 2, -12 },
  { 622, 13, 12, 14, 2, -12 },
  { 642, 11, 12, 8, -1, -12 },
  { 659, 8, 12, 8, 2, -12 },
  { 671, 10, 12, 9, 0, -12 },
  { 686, 6, 15, 5, 0, -12 },
  { 698, 2, 12, 5, 2, -12 },
  { 701, 6, 15, 5, -1, -12 },
  { 713, 8, 7, 9, 1, -12 },
  { 720, 6, 1, 6, -1, 2 },
  { 721, 3, 3, 4, 2, -13 },
  { 723, 8, 9, 9, 1, -9 },
  { 732, 8, 13, 10, 1, -13 },
  { 745, 7, 9, 8, 1, -9 },
  { 753, 9, 13, 10, 1, -13 },
  { 768, 7, 9, 8, 1, -9 },
  { 776, 9, 17, 5, -2, -13 },
  { 796, 9, 13, 10, 0, -9 },
  { 811, 7, 13, 9, 1, -13 },
  { 823, 3, 12, 4, 1, -12 },
  { 828, 6, 16, 4, -2, -12 },
  { 840, 7, 13, 8, 1, -13 },
  { 852, 3, 13, 4, 1, -13 },
  { 857, 12, 9, 14, 1, -9 },
  { 871, 8, 9, 9, 1, -9 },
  { 880, 8, 9, 10, 1, -9 },
  { 889, 9, 13, 10, 0, -9 },
  { 904, 8, 13, 10, 1, -9 },
  { 917, 6, 9, 6, 1, -9 },
  { 924, 7, 9, 7, 0, -9 },
  { 932, 5, 11, 5, 1, -11 },
  { 939, 8, 9, 9, 1, -9 },
  { 948, 7, 9, 7, 1, -9 },
  { 956, 11, 9, 11, 1, -9 },
  { 969, 9, 9, 8, -1, -9 },
  { 980, 10, 13, 7, -2, -9 },
  { 997, 7, 9, 7, 0, -9 },
  { 1005, 7, 15, 6, 0, -12 },
  { 1019, 1, 17, 9, 5, -13 },
  { 1022, 6, 15, 6, -1, -12 },
  { 1034, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRALIGHTITALIC17PT7B_H_
