#ifndef _NOTOSANS_EXTRALIGHTITALIC68PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x01, 0x00, 0x00, 0x0E, 0x03, 0x0C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x18, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3E, 0x0C, 0x0F, 0x00, 0x78, 0x1C,
  0x02, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x3E, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x01, 0x87, 0x80, 0x00, 0x01, 0x83,
  0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0xC0, 0x0C, 0x0F, 0x00, 0xF8, 0x0C, 0x3E, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xE0,
  0x0F, 0x0F, 0x00, 0x00, 0x38, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x70, 0x0C,
  0x0C, 0x00, 0x18, 0x1C, 0x1F, 0xF1, 0x80, 0x07, 0x07, 0x07, 0xFF, 0x30,
  0x00, 0xC0, 0xC1, 0xC0, 0xF6, 0x00, 0x38, 0x38, 0x70, 0x0E, 0xE0, 0x06,
  0x0E, 0x1C, 0x00, 0xDC, 0x01, 0xC3, 0x83, 0x00, 0x1D, 0xC0, 0x70, 0x60,
  0xE0, 0x03, 0xBC, 0x3C, 0x1C, 0x18, 0x00, 0x73, 0xFF, 0x07, 0x07, 0x00,
  0x0E, 0x3F, 0x81, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0x60, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x60,
  0x00, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x20, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x18, 0x00, 0x00, 0x38, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xCE, 0x03, 0x80, 0x00, 0x00,
  0x6E, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x0E, 0x00,
  0x00, 0x1E, 0x70, 0x07, 0x80, 0x00, 0x1E, 0x1C, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18,
  0x30, 0x61, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x00, 0x07, 0xE0, 0x18, 0x00, 0x0F, 0x80, 0xC0, 0x00,
  0x1F, 0x06, 0x00, 0x00, 0x3E, 0x20, 0x00, 0x00, 0x3B, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x23, 0xBF, 0xEF, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xB0, 0x0F, 0x18, 0x0F,
  0x1C, 0x1E, 0x0E, 0x3E, 0x07, 0x3C, 0x03, 0x3C, 0x03, 0x88, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x08, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x07, 0xF8, 0x00, 0x38, 0x3F, 0xFE, 0x00, 0x30,
  0xFE, 0x1F, 0x80, 0x71, 0xE0, 0x03, 0xC0, 0x73, 0x80, 0x01, 0xC0, 0x77,
  0x00, 0x00, 0xE0, 0x6C, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x00, 0x70, 0xF8,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x7C, 0x07,
  0x00, 0x00, 0x76, 0x03, 0xC0, 0x00, 0x77, 0x00, 0xF0, 0x00, 0xF3, 0x80,
  0x3E, 0x01, 0xF1, 0x80, 0x0F, 0xFF, 0xE1, 0xC0, 0x01, 0xFF, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x1F, 0x03, 0xC0, 0x78,
  0x04, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0xF8, 0x1C, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x38, 0x60, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE3, 0x00, 0x03, 0xC0, 0x03, 0x00,
  0x0C, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x98, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x33, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x03, 0x80, 0x00,
  0x60, 0x00, 0xD8, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3B, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x60, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1D, 0x80,
  0x0C, 0x00, 0x03, 0x80, 0x03, 0xB0, 0x01, 0x80, 0x00, 0x70, 0x00, 0xE6,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x07,
  0x18, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xE3, 0x00, 0x18, 0x00, 0x3E, 0x00,
  0x38, 0x60, 0x03, 0x80, 0x06, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x01, 0x9C,
  0x03, 0xC1, 0xC0, 0x07, 0x00, 0xE1, 0xC0, 0xF0, 0x18, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x01, 0xF0, 0x01, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x01,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0x80, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x30,
  0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xE3, 0x80, 0x00, 0x3F, 0xFF, 0xC6, 0x00, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x01,
  0x80, 0xF0, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x00,
  0x03, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x70,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x07, 0x60, 0x07, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x76, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x67, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x06, 0x70, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x80, 0x1C,
  0x18, 0x00, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0x8C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x60, 0x07,
  0x00, 0x01, 0xD8, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x60, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x1D, 0x80, 0x00, 0x00, 0x70, 0x03, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x67,
  0x00, 0x00, 0x01, 0x80, 0x0C, 0x70, 0x00, 0x00, 0x30, 0x03, 0x8E, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x01, 0x81, 0x80, 0x00, 0x06, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x98,
  0x00, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x38, 0x00, 0x00, 0x07, 0x60, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFA, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x18, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x30, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x06, 0xF0, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x1F, 0xFF, 0x83, 0x00,
  0x7C, 0x03, 0xC3, 0x00, 0xF0, 0x00, 0xC7, 0x01, 0xE0, 0x00, 0x66, 0x03,
  0xC0, 0x00, 0x66, 0x03, 0x80, 0x00, 0x36, 0x07, 0x00, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x03, 0xE0, 0x60, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x06, 0xC0, 0x70,
  0x00, 0x0C, 0xC0, 0x70, 0x00, 0x1C, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x3C,
  0x00, 0xF1, 0x80, 0x1E, 0x01, 0xC1, 0x80, 0x0F, 0xFF, 0x81, 0x80, 0x07,
  0xFE, 0x01, 0x80, 0x00, 0x70, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0x70, 0xF0,
  0x0F, 0x00, 0x38, 0xE0, 0x03, 0xC0, 0x18, 0xC0, 0x00, 0xE0, 0x0C, 0xC0,
  0x00, 0x38, 0x0E, 0xC0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x07, 0x03, 0x60,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xB0, 0x00, 0x03, 0x81, 0xD8, 0x00, 0x03, 0x80, 0xCE, 0x00, 0x03,
  0x80, 0x63, 0x80, 0x07, 0x80, 0x30, 0xF0, 0x0F, 0x80, 0x38, 0x3F, 0xFF,
  0x80, 0x18, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x70,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0x01, 0x80, 0x00, 0xFF, 0xFE, 0x1C, 0x00, 0x1F, 0x00, 0x78, 0xE0, 0x01,
  0xE0, 0x00, 0xC7, 0x00, 0x1E, 0x00, 0x03, 0x30, 0x01, 0xE0, 0x00, 0x1D,
  0x80, 0x0E, 0x00, 0x00, 0x6C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x18, 0x00, 0x00,
  0x7C, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x36, 0x00, 0x38,
  0x00, 0x03, 0x30, 0x01, 0xC0, 0x00, 0x31, 0x80, 0x07, 0x00, 0x03, 0x1C,
  0x00, 0x3C, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0x0F, 0x06, 0x00, 0x03, 0xFF,
  0xF0, 0x30, 0x00, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF8, 0x70, 0x00, 0xFC, 0x0C, 0x0F,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x30, 0x00, 0xFF,
  0xFE, 0x0C, 0x00, 0xF8, 0x03, 0xC3, 0x00, 0x78, 0x00, 0x31, 0xC0, 0x3C,
  0x00, 0x06, 0x60, 0x1E, 0x00, 0x01, 0x98, 0x07, 0x00, 0x00, 0x36, 0x03,
  0x80, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0xE0,
  0x30, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0x6C, 0x03, 0x80, 0x00, 0x33,
  0x00, 0xE0, 0x00, 0x19, 0xC0, 0x1C, 0x00, 0x0C, 0x70, 0x07, 0x80, 0x0E,
  0x18, 0x00, 0xF0, 0x0F, 0x06, 0x00, 0x1F, 0xFF, 0x83, 0x80, 0x03, 0xFF,
  0x80, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x80, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x01, 0xC1, 0xFF, 0xF8, 0x01,
  0xC3, 0xC0, 0x3C, 0x01, 0xC7, 0x00, 0x0E, 0x01, 0x8E, 0x00, 0x0E, 0x01,
  0x98, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x07, 0x03,
  0x60, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x02, 0x0F, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x18, 0xEE, 0x00, 0x00, 0x33, 0x9C, 0x00, 0x00, 0x6E, 0x1C, 0x00,
  0x01, 0xF8, 0x38, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x18, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x01, 0x8E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x19, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x01, 0x98, 0x00, 0x18, 0xE0, 0x00, 0x60, 0x3B, 0x00, 0x01, 0x9C,
  0x00, 0x07, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x70, 0x34, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x7F, 0xF0, 0x01, 0xC1, 0xFF, 0xFC, 0x01,
  0xC3, 0xC0, 0x3C, 0x01, 0x87, 0x00, 0x1E, 0x01, 0x8E, 0x00, 0x0E, 0x01,
  0x98, 0x00, 0x07, 0x03, 0xB0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x07, 0x03,
  0x60, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0xFF, 0xE0, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0x03, 0x07, 0x80,
  0x78, 0x00, 0x30, 0xE0, 0x03, 0xC0, 0x03, 0x1C, 0x00, 0x1C, 0x00, 0x33,
  0x00, 0x00, 0xE0, 0x07, 0x60, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0x70,
  0x06, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x06, 0xC0,
  0x00, 0x0E, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x0E, 0xE0, 0x00, 0x38, 0x00,
  0xC7, 0x00, 0x0F, 0x00, 0x0C, 0x3C, 0x03, 0xE0, 0x01, 0xC1, 0xFF, 0xFC,
  0x00, 0x1C, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0xC0, 0x07, 0xFF, 0xF0, 0x60, 0x0F, 0x80, 0x3C, 0x30, 0x0F,
  0x00, 0x06, 0x38, 0x0F, 0x00, 0x01, 0x98, 0x0F, 0x00, 0x00, 0xCC, 0x07,
  0x00, 0x00, 0x36, 0x07, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0x3E, 0x06, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x1B, 0x01, 0xC0, 0x00,
  0x19, 0x80, 0xE0, 0x00, 0x19, 0xC0, 0x38, 0x00, 0x1C, 0xE0, 0x1E, 0x00,
  0x38, 0x60, 0x07, 0x80, 0x78, 0x30, 0x01, 0xFF, 0xF8, 0x38, 0x00, 0x3F,
  0xF0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x3F, 0xC0, 0x70, 0x7F, 0xE0, 0x30, 0x78, 0x00, 0x18, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x00, 0x41, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x38, 0x30, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x40, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x07, 0xC0, 0xC0, 0x00, 0x0D, 0xC0, 0xE0, 0x00, 0x1D, 0x80, 0xE0,
  0x00, 0x39, 0x80, 0xE0, 0x00, 0x71, 0x80, 0x70, 0x00, 0xE3, 0x80, 0x7C,
  0x03, 0xC3, 0x80, 0x3F, 0xFF, 0x03, 0x00, 0x0F, 0xFE, 0x03, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x38, 0x00,
  0x19, 0x80, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xE6,
  0x00, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00,
  0x30, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x80,
  0xC0, 0x0E, 0x06, 0x00, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x00,
  0x70, 0x18, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x30, 0x1C, 0x01, 0xC0,
  0xE0, 0x06, 0x03, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x03, 0x00,
  0x1C, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x18, 0x00, 0x70,
  0xC0, 0x01, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xC0, 0x01, 0xC6, 0x00,
  0x06, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x19,
  0xC0, 0x00, 0xEE, 0x00, 0x03, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFE, 0x00, 0x05, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0xD0, 0x00, 0x03, 0xFE,
  0x00,
};

const GFXglyph NotoSans_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 50, 15, 2, -49 },
  { 89, 16, 18, 22, 7, -49 },
  { 125, 41, 49, 42, 2, -49 },
  { 377, 32, 56, 37, 3, -52 },
  { 601, 43, 50, 52, 6, -49 },
  { 870, 41, 50, 46, 3, -49 },
  { 1127, 7, 18, 12, 7, -49 },
  { 1143, 20, 60, 17, 2, -49 },
  { 1293, 19, 60, 17, -4, -49 },
  { 1436, 29, 30, 36, 8, -52 },
  { 1545, 31, 32, 39, 5, -40 },
  { 1669, 10, 17, 13, -3, -8 },
  { 1691, 17, 3, 21, 2, -20 },
  { 1698, 5, 6, 15, 2, -5 },
  { 1702, 30, 49, 21, -3, -49 },
  { 1886, 32, 50, 37, 4, -49 },
  { 2086, 17, 49, 37, 11, -49 },
  { 2191, 34, 49, 37, 1, -49 },
  { 2400, 35, 50, 37, 1, -49 },
  { 2619, 35, 49, 37, 1, -49 },
  { 2834, 34, 50, 37, 3, -49 },
  { 3047, 32, 50, 37, 5, -49 },
  { 3247, 31, 49, 37, 7, -49 },
  { 3437, 33, 50, 37, 3, -49 },
  { 3644, 33, 50, 37, 3, -49 },
  { 3851, 11, 37, 15, 2, -36 },
  { 3902, 16, 45, 15, -3, -36 },
  { 3992, 31, 31, 39, 5, -40 },
  { 4113, 31, 16, 39, 5, -32 },
  { 4175, 31, 31, 39, 5, -40 },
  { 4296, 24, 50, 28, 5, -49 },
  { 4446, 51, 54, 57, 4, -48 },
  { 4791, 37, 49, 37, -3, -49 },
  { 5018, 37, 49, 41, 3, -49 },
  { 5245, 37, 50, 40, 6, -49 },
  { 5477, 40, 49, 46, 3, -49 },
  { 5722, 35, 49, 36, 3, -49 },
  { 5937, 35, 49, 33, 3, -49 },
  { 6152, 39, 50, 47, 6, -49 },
  { 6396, 43, 49, 46, 3, -49 },
  { 6660, 22, 49, 20, 0, -49 },
  { 6795, 27, 61, 16, -11, -49 },
  { 7001, 40, 49, 37, 3, -49 },
  { 7246, 25, 49, 33, 3, -49 },
  { 7400, 52, 49, 55, 3, -49 },
  { 7719, 43, 49, 46, 3, -49 },
  { 7983, 40, 50, 49, 6, -49 },
  { 8233, 35, 49, 38, 3, -49 },
  { 8448, 40, 61, 49, 6, -49 },
  { 8753, 35, 49, 38, 3, -49 },
  { 8968, 34, 50, 34, 1, -49 },
  { 9181, 33, 49, 33, 6, -49 },
  { 9384, 41, 50, 47, 6, -49 },
  { 9641, 35, 49, 37, 7, -49 },
  { 9856, 53, 49, 57, 8, -49 },
  { 10181, 43, 49, 34, -4, -49 },
  { 10445, 34, 49, 33, 6, -49 },
  { 10654, 40, 49, 37, -1, -49 },
  { 10899, 26, 60, 20, -1, -49 },
  { 11094, 11, 49, 21, 7, -49 },
  { 11162, 26, 60, 20, -5, -49 },
  { 11357, 32, 30, 38, 3, -49 },
  { 11477, 26, 2, 26, -6, 7 },
  { 11484, 8, 11, 16, 10, -52 },
  { 11495, 32, 38, 37, 3, -37 },
  { 11647, 33, 53, 39, 2, -52 },
  { 11866, 27, 38, 31, 4, -37 },
  { 11995, 37, 53, 39, 3, -52 },
  { 12241, 27, 38, 34, 4, -37 },
  { 12370, 37, 68, 19, -9, -52 },
  { 12685, 34, 53, 39, 2, -37 },
  { 12911, 32, 52, 38, 2, -52 },
  { 13119, 14, 49, 15, 2, -49 },
  { 13205, 25, 65, 15, -9, -49 },
  { 13409, 31, 52, 31, 2, -52 },
  { 13611, 14, 52, 15, 2, -52 },
  { 13702, 52, 37, 58, 2, -37 },
  { 13943, 32, 37, 38, 2, -37 },
  { 14091, 31, 38, 38, 4, -37 },
  { 14239, 36, 53, 39, -1, -37 },
  { 14478, 33, 53, 39, 3, -37 },
  { 14697, 25, 37, 26, 2, -37 },
  { 14813, 26, 38, 29, 1, -37 },
  { 14937, 19, 46, 21, 4, -45 },
  { 15047, 32, 37, 38, 4, -36 },
  { 15195, 29, 36, 29, 3, -36 },
  { 15326, 43, 36, 45, 4, -36 },
  { 15520, 34, 36, 31, -2, -36 },
  { 15673, 39, 52, 29, -7, -36 },
  { 15927, 31, 36, 30, -1, -36 },
  { 16067, 24, 60, 23, 2, -49 },
  { 16247, 2, 68, 37, 19, -52 },
  { 16264, 24, 59, 23, -3, -48 },
  { 16441, 31, 6, 39, 5, -27 },
};

const GFXfont NotoSans_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRALIGHTITALIC68PT7B_H_
