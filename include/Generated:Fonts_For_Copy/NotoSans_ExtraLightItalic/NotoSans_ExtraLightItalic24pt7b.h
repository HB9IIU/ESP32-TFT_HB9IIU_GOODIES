#ifndef _NOTOSANS_EXTRALIGHTITALIC24PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x84, 0x00, 0x10, 0x80,
  0x4C, 0x63, 0x29, 0x48, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x08, 0x04,
  0x21, 0xFF, 0xF0, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x08, 0x3F,
  0xFE, 0x10, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x01, 0x00,
  0x20, 0x3F, 0x88, 0x82, 0x10, 0x44, 0x08, 0x80, 0x90, 0x1A, 0x00, 0xE0,
  0x12, 0x02, 0x20, 0x44, 0x08, 0x82, 0x24, 0x48, 0x3C, 0x01, 0x00, 0x60,
  0x00, 0x3C, 0x04, 0x84, 0x11, 0x08, 0x22, 0x10, 0x88, 0x22, 0x10, 0x48,
  0x21, 0x12, 0x42, 0x5B, 0x89, 0x22, 0xF4, 0x84, 0x09, 0x08, 0x22, 0x10,
  0x88, 0x22, 0x10, 0x44, 0x21, 0x10, 0x42, 0x40, 0x78, 0x07, 0xE0, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x58, 0x01, 0x80, 0x1A,
  0x00, 0x84, 0x14, 0x10, 0x60, 0x22, 0x80, 0x52, 0x00, 0xC8, 0x06, 0x10,
  0x24, 0x3F, 0x08, 0x6A, 0xA0, 0x06, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x00,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x20, 0x81, 0x0C, 0x00, 0x04, 0x01, 0x08, 0x41, 0x90,
  0x1F, 0xC2, 0x01, 0x41, 0x90, 0x42, 0x00, 0x80, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x24, 0xA5, 0x00, 0xFC, 0xC0, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x20, 0x14, 0x02,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01,
  0x20, 0x46, 0x10, 0x7C, 0x00, 0x0C, 0x56, 0xA2, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x40, 0x07, 0xE0, 0x81, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x0F, 0xC3, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x18, 0x1F, 0x00, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x18, 0xFF, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x14, 0x01, 0x20, 0x12, 0x01, 0x10, 0x10, 0x81, 0x04, 0x10,
  0x41, 0x82, 0x08, 0x10, 0x80, 0x8B, 0xFF, 0x80, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0F, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x03, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC8, 0x18, 0xFE, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x13, 0x05, 0x8C, 0xC0, 0x90, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20,
  0x26, 0x08, 0x7E, 0x00, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x10, 0x11, 0x02, 0x08,
  0x40, 0x58, 0x0F, 0x03, 0x08, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x44, 0x08, 0x3F, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x22, 0x02, 0x20, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x20, 0x61, 0xBA, 0x04, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0xFC, 0x00, 0x32, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x80, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x21, 0x04,
  0x20, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x00, 0x00, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04,
  0x18, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0xFC, 0x00,
  0xC0, 0xC0, 0xC0, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x3F, 0x14, 0x10,
  0x45, 0x08, 0x21, 0x44, 0x08, 0x61, 0x02, 0x18, 0x41, 0x06, 0x10, 0x42,
  0x84, 0x30, 0x90, 0xB2, 0xC4, 0x10, 0x41, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x02, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x40, 0x82, 0x04, 0x10, 0x40, 0x87, 0xFC, 0x20, 0x22,
  0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0x80, 0x08, 0x0F, 0xE0, 0x80, 0x84,
  0x02, 0x20, 0x11, 0x00, 0x88, 0x08, 0x80, 0x44, 0x3C, 0x3F, 0xC1, 0x01,
  0x08, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x90, 0x18, 0xFF, 0x00,
  0x07, 0xF8, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x01, 0x10,
  0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50,
  0x02, 0x40, 0x09, 0x00, 0x44, 0x02, 0x20, 0x30, 0xFF, 0x00, 0x0F, 0xF1,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF, 0x80,
  0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x3F, 0xC2, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x00, 0x07, 0xFC, 0x20, 0x11, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x81, 0xFA, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x44, 0x01, 0x08, 0x08, 0x1F, 0xE0, 0x08, 0x02, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x3F,
  0xF8, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04,
  0x40, 0x08, 0x80, 0x10, 0x0F, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0xF0, 0x00,
  0x08, 0x0C, 0x40, 0x41, 0x02, 0x04, 0x10, 0x10, 0x80, 0x44, 0x02, 0x60,
  0x0B, 0x00, 0x32, 0x00, 0x88, 0x02, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02,
  0x04, 0x04, 0x20, 0x10, 0x80, 0x60, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0xFF, 0x80, 0x08, 0x00, 0x46, 0x00, 0x31, 0x40, 0x14, 0x50, 0x05, 0x14,
  0x02, 0x85, 0x00, 0xA2, 0x40, 0x48, 0x90, 0x22, 0x22, 0x08, 0x88, 0x84,
  0x44, 0x21, 0x11, 0x08, 0x84, 0x42, 0x41, 0x10, 0x90, 0x44, 0x18, 0x22,
  0x06, 0x08, 0x81, 0x02, 0x00, 0x08, 0x02, 0x30, 0x04, 0x50, 0x08, 0xA0,
  0x11, 0x20, 0x42, 0x40, 0x88, 0x81, 0x10, 0x82, 0x21, 0x08, 0x41, 0x11,
  0x02, 0x22, 0x04, 0x44, 0x04, 0x88, 0x0A, 0x10, 0x0C, 0x40, 0x18, 0x80,
  0x10, 0x07, 0xF0, 0x60, 0x23, 0x00, 0xC8, 0x01, 0x40, 0x05, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x44, 0x03, 0x08, 0x18, 0x1F, 0x80, 0x0F, 0xE1, 0x03, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x43, 0xF8, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x60,
  0x23, 0x00, 0xC8, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x03, 0x08,
  0x18, 0x1F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x0F, 0xE1,
  0x03, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x21, 0xC3,
  0xF0, 0x21, 0x04, 0x08, 0x40, 0x84, 0x08, 0x40, 0x48, 0x04, 0x80, 0x60,
  0x07, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x08,
  0x7F, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x00, 0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x20, 0x60, 0x3F, 0x80,
  0xC0, 0x1A, 0x00, 0x90, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08,
  0x10, 0x41, 0x01, 0x08, 0x08, 0x80, 0x48, 0x02, 0x40, 0x14, 0x00, 0xA0,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x40, 0x70, 0x18, 0x0A, 0x03, 0x02, 0x40,
  0xA0, 0x48, 0x14, 0x09, 0x04, 0x82, 0x20, 0x90, 0x44, 0x22, 0x10, 0x84,
  0x42, 0x11, 0x08, 0x82, 0x21, 0x10, 0x48, 0x14, 0x09, 0x02, 0x81, 0x40,
  0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x00, 0x08, 0x06, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0, 0x00, 0xC0,
  0x01, 0x00, 0x05, 0x00, 0x12, 0x00, 0x44, 0x01, 0x04, 0x06, 0x08, 0x08,
  0x08, 0x20, 0x10, 0x80, 0x30, 0x80, 0x34, 0x02, 0x40, 0x44, 0x08, 0x20,
  0x82, 0x10, 0x22, 0x02, 0x60, 0x14, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xFF,
  0xE0, 0x0F, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0F,
  0x80, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x11, 0x11, 0x10, 0x0F, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x80, 0x01, 0x00,
  0x50, 0x12, 0x02, 0x40, 0x88, 0x20, 0x84, 0x11, 0x02, 0x40, 0x38, 0x04,
  0xFF, 0x80, 0xA4, 0x07, 0x23, 0x14, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x1A, 0x06, 0x21, 0x43, 0xC8, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x47, 0x0B, 0x19, 0x81, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x70, 0x16, 0x02, 0xA0, 0x93, 0xE0, 0x07, 0xC6,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x03,
  0xC8, 0x61, 0x44, 0x04, 0x60, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x28, 0x43, 0x41, 0xE4, 0x00, 0x07, 0x86, 0x12,
  0x04, 0x81, 0x40, 0xD0, 0x67, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x3F, 0x00, 0x00, 0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x07, 0xF0,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x91, 0x85, 0x20, 0x66, 0x02, 0x40,
  0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x44, 0x34, 0x3C,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x08, 0x60, 0x78, 0x00, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x47, 0x8B, 0x19, 0x81, 0x20, 0x24, 0x05,
  0x00, 0xA0, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x10, 0x18,
  0x00, 0x02, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x10, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0xC8, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20,
  0x2C, 0x06, 0x40, 0x88, 0x20, 0x84, 0x10, 0x81, 0x10, 0x20, 0x18, 0x84,
  0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x84, 0x00, 0x27, 0x87,
  0x8A, 0x12, 0x33, 0x05, 0x04, 0x81, 0x81, 0x20, 0x40, 0x50, 0x10, 0x14,
  0x04, 0x09, 0x01, 0x02, 0x40, 0x80, 0xA0, 0x20, 0x28, 0x08, 0x0A, 0x02,
  0x04, 0x81, 0x01, 0x00, 0x23, 0xC5, 0x8C, 0xC0, 0x90, 0x12, 0x02, 0x80,
  0x50, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x07, 0x83,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09,
  0x01, 0x20, 0x43, 0xF0, 0x11, 0xC1, 0x63, 0x18, 0x11, 0x01, 0x10, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x16, 0x02, 0x60, 0x25, 0x04, 0x4F, 0x84,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0x91, 0x85,
  0x20, 0x66, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C,
  0x81, 0x44, 0x34, 0x3C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x27, 0x94, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x0F, 0x8C, 0x12, 0x00, 0x80, 0x20, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x12, 0x04, 0x7E, 0x00, 0x10, 0x20,
  0x47, 0xF2, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x3C,
  0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x04,
  0x80, 0x48, 0x0C, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x80, 0x60, 0x18, 0x09,
  0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44, 0x12, 0x03, 0x00, 0xC0, 0x20,
  0x00, 0x81, 0x01, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x44, 0x84, 0x44,
  0x88, 0x48, 0x88, 0x48, 0x90, 0x50, 0x90, 0x50, 0xA0, 0x60, 0xA0, 0x60,
  0x40, 0x40, 0x40, 0x10, 0x10, 0x82, 0x08, 0x60, 0x44, 0x04, 0x80, 0x50,
  0x02, 0x00, 0x60, 0x09, 0x01, 0x10, 0x20, 0x86, 0x08, 0xC0, 0x40, 0x08,
  0x04, 0x20, 0x10, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01,
  0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00,
  0xFF, 0x00, 0x07, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60,
  0xC0, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x30, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x01, 0x00, 0xE0, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x0C, 0x00, 0x70, 0x11, 0x8E, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 5, 1, -17 },
  { 12, 5, 6, 8, 3, -17 },
  { 16, 14, 17, 15, 1, -17 },
  { 46, 11, 19, 13, 1, -18 },
  { 73, 15, 17, 18, 2, -17 },
  { 105, 14, 17, 16, 1, -17 },
  { 135, 2, 6, 4, 3, -17 },
  { 137, 7, 21, 6, 1, -17 },
  { 156, 7, 21, 6, -2, -17 },
  { 175, 10, 10, 13, 3, -18 },
  { 188, 11, 11, 14, 2, -14 },
  { 204, 3, 6, 5, -1, -3 },
  { 207, 6, 1, 7, 1, -7 },
  { 208, 1, 2, 5, 1, -2 },
  { 209, 11, 17, 8, -1, -17 },
  { 233, 11, 17, 13, 2, -17 },
  { 257, 6, 17, 13, 4, -17 },
  { 270, 12, 17, 13, 0, -17 },
  { 296, 12, 17, 13, 1, -17 },
  { 322, 13, 17, 13, 0, -17 },
  { 350, 12, 17, 13, 1, -17 },
  { 376, 11, 17, 13, 2, -17 },
  { 400, 10, 17, 13, 3, -17 },
  { 422, 12, 17, 13, 1, -17 },
  { 448, 12, 17, 13, 1, -17 },
  { 474, 4, 13, 5, 1, -13 },
  { 481, 6, 16, 5, -1, -13 },
  { 493, 11, 11, 14, 2, -14 },
  { 509, 11, 5, 14, 2, -11 },
  { 516, 11, 11, 14, 2, -14 },
  { 532, 8, 17, 10, 2, -17 },
  { 549, 18, 19, 20, 1, -17 },
  { 592, 13, 17, 13, -1, -17 },
  { 620, 13, 17, 14, 1, -17 },
  { 648, 13, 17, 14, 2, -17 },
  { 676, 14, 17, 16, 1, -17 },
  { 706, 12, 17, 13, 1, -17 },
  { 732, 12, 17, 12, 1, -17 },
  { 758, 14, 17, 17, 2, -17 },
  { 788, 15, 17, 16, 1, -17 },
  { 820, 8, 17, 7, 0, -17 },
  { 837, 10, 21, 6, -4, -17 },
  { 864, 14, 17, 13, 1, -17 },
  { 894, 9, 17, 12, 1, -17 },
  { 914, 18, 17, 20, 1, -17 },
  { 953, 15, 17, 16, 1, -17 },
  { 985, 14, 17, 17, 2, -17 },
  { 1015, 12, 17, 13, 1, -17 },
  { 1041, 14, 21, 17, 2, -17 },
  { 1078, 12, 17, 14, 1, -17 },
  { 1104, 12, 17, 12, 0, -17 },
  { 1130, 12, 17, 12, 2, -17 },
  { 1156, 15, 17, 17, 2, -17 },
  { 1188, 13, 17, 13, 2, -17 },
  { 1216, 19, 17, 20, 3, -17 },
  { 1257, 15, 17, 12, -1, -17 },
  { 1289, 12, 17, 12, 2, -17 },
  { 1315, 14, 17, 13, 0, -17 },
  { 1345, 9, 21, 7, 0, -17 },
  { 1369, 4, 17, 8, 2, -17 },
  { 1378, 9, 21, 7, -2, -17 },
  { 1402, 11, 10, 13, 1, -17 },
  { 1416, 9, 1, 9, -2, 2 },
  { 1418, 2, 3, 6, 4, -18 },
  { 1419, 11, 13, 13, 1, -13 },
  { 1437, 11, 18, 14, 1, -18 },
  { 1462, 10, 13, 11, 1, -13 },
  { 1479, 13, 18, 14, 1, -18 },
  { 1509, 10, 13, 12, 1, -13 },
  { 1526, 13, 24, 7, -3, -18 },
  { 1565, 12, 19, 14, 1, -13 },
  { 1594, 11, 18, 13, 1, -18 },
  { 1619, 5, 17, 5, 1, -17 },
  { 1630, 8, 23, 5, -3, -17 },
  { 1653, 11, 18, 11, 1, -18 },
  { 1678, 5, 18, 5, 1, -18 },
  { 1690, 18, 13, 20, 1, -13 },
  { 1720, 11, 13, 13, 1, -13 },
  { 1738, 11, 13, 14, 1, -13 },
  { 1756, 12, 19, 14, 0, -13 },
  { 1785, 12, 19, 14, 1, -13 },
  { 1814, 9, 13, 9, 1, -13 },
  { 1829, 10, 13, 10, 0, -13 },
  { 1846, 7, 16, 8, 1, -16 },
  { 1860, 12, 13, 13, 1, -13 },
  { 1880, 10, 13, 10, 1, -13 },
  { 1897, 16, 13, 16, 1, -13 },
  { 1923, 12, 13, 11, -1, -13 },
  { 1943, 14, 19, 10, -3, -13 },
  { 1977, 10, 13, 11, 0, -13 },
  { 1994, 8, 21, 8, 1, -17 },
  { 2015, 1, 24, 13, 7, -18 },
  { 2018, 9, 21, 8, -1, -17 },
  { 2042, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRALIGHTITALIC24PT7B_H_
