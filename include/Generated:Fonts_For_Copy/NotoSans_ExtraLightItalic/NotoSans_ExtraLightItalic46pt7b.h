#ifndef _NOTOSANS_EXTRALIGHTITALIC46PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x66, 0x0C, 0xC3, 0x10,
  0x66, 0x0C, 0xC1, 0x98, 0x22, 0x04, 0x41, 0x88, 0x33, 0x04, 0x40, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x01, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x10, 0x04, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x38, 0x61, 0x81,
  0xC1, 0x80, 0x06, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80, 0x01, 0xC6, 0x00,
  0x03, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0xC3, 0x00, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x04, 0x06, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0,
  0x03, 0x06, 0x0E, 0x0C, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x71, 0x80, 0x03, 0x06, 0x06, 0x00, 0x30,
  0x20, 0x30, 0x03, 0x03, 0x01, 0x80, 0x10, 0x10, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x18, 0x08, 0x06, 0x00, 0xC0,
  0xC0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x0C, 0x03, 0x04, 0x00,
  0x60, 0x18, 0x61, 0xF3, 0x00, 0x86, 0x3F, 0xD8, 0x0C, 0x63, 0x06, 0xC0,
  0x42, 0x10, 0x1E, 0x06, 0x31, 0x80, 0xDC, 0xE3, 0x18, 0x06, 0x7E, 0x30,
  0xC0, 0x30, 0x01, 0x84, 0x01, 0x80, 0x18, 0x60, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x18, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x40, 0x60, 0x08, 0x06, 0x06, 0x00,
  0x60, 0x20, 0x60, 0x03, 0x03, 0x02, 0x00, 0x0C, 0x30, 0x70, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x18, 0x01, 0x8C, 0x03, 0x00,
  0x33, 0x00, 0x30, 0x0C, 0xC0, 0x03, 0x01, 0x90, 0x00, 0x30, 0x66, 0x00,
  0x06, 0x18, 0xC0, 0x00, 0x63, 0x18, 0x00, 0x06, 0xC3, 0x00, 0x00, 0xF0,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x01, 0xCC, 0x1C, 0x00,
  0xE1, 0x81, 0xE0, 0xF8, 0x18, 0x0F, 0xFC, 0x01, 0x80, 0x33, 0x32, 0x66,
  0x64, 0x44, 0xC8, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x01, 0x80, 0xC0, 0x3C, 0x10, 0x01, 0xC2, 0x00, 0x0E, 0x40, 0x20, 0x7F,
  0xFC, 0x03, 0xF0, 0x01, 0xA0, 0x00, 0x66, 0x00, 0x18, 0x40, 0x06, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x00, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0E,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0x83, 0x00, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0x8F, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x60, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x80, 0xC0, 0x38, 0x03, 0x87, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x72, 0x0E, 0x63, 0x86,
  0xF0, 0x64, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xF0, 0xF0, 0x0F, 0x00, 0x70, 0x38, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x7C, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19,
  0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x70, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x9F, 0x80, 0x03, 0xFF,
  0xC0, 0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x01, 0xC0, 0x78,
  0x1F, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x30, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC3, 0xFC, 0x02, 0x3C, 0x78, 0x19, 0x80,
  0x30, 0x68, 0x00, 0x61, 0x40, 0x01, 0x86, 0x00, 0x02, 0x38, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x10, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x0E, 0x03, 0x00, 0x70, 0x07, 0x07, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xF1, 0xE0, 0x07, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x60, 0x18,
  0x01, 0xC0, 0x18, 0x07, 0x00, 0x18, 0x18, 0x00, 0x19, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0x06, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0F, 0x07, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC7, 0x80, 0x18, 0x03, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x18, 0x00,
  0x78, 0x30, 0x03, 0x60, 0x70, 0x79, 0x80, 0xFF, 0x8C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x30, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x07, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x7E, 0x78,
  0x20, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x31, 0x00, 0x1F, 0xF8,
  0x0C, 0xC0, 0x0E, 0x0E, 0x03, 0x60, 0x0E, 0x01, 0x80, 0x58, 0x06, 0x00,
  0x60, 0x14, 0x01, 0x00, 0x10, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x60,
  0x03, 0x00, 0xF0, 0x18, 0x00, 0x80, 0x38, 0x04, 0x00, 0x20, 0x0E, 0x03,
  0x00, 0x18, 0x03, 0x80, 0xC0, 0x06, 0x01, 0xA0, 0x30, 0x03, 0x00, 0x68,
  0x0C, 0x00, 0xC0, 0x32, 0x03, 0x00, 0x70, 0x0C, 0x80, 0x40, 0x34, 0x06,
  0x30, 0x18, 0x19, 0x83, 0x0C, 0x03, 0xBC, 0x7F, 0x83, 0x00, 0x7C, 0x0F,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x30, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x60, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x8F, 0xC0, 0x3C, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x1F, 0x07, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x06,
  0x00, 0xF8, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xE0, 0x18, 0x01, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x03, 0xC0, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x98,
  0x00, 0x7F, 0xE3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00, 0x7C,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x03,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x0D, 0x98, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x07, 0x81, 0xA0, 0x00, 0x01, 0xB0, 0x34, 0x00, 0x00, 0x34, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x01, 0xB0, 0x13, 0x00, 0x00, 0x66,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0xC4, 0x00, 0x03, 0x30, 0x18, 0x80, 0x00,
  0xC6, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x43, 0x00, 0x06, 0x18, 0x18, 0x60,
  0x00, 0x82, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x60, 0x80, 0x0C, 0x18, 0x08,
  0x10, 0x01, 0x83, 0x03, 0x03, 0x00, 0x60, 0x60, 0x60, 0x60, 0x08, 0x08,
  0x0C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x0C, 0x02, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x20, 0x30, 0x0C,
  0x30, 0x0C, 0x06, 0x01, 0x84, 0x01, 0x80, 0x80, 0x31, 0x80, 0x30, 0x30,
  0x02, 0x60, 0x04, 0x06, 0x00, 0x4C, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0x30,
  0x18, 0x01, 0xC0, 0x06, 0x02, 0x00, 0x38, 0x00, 0xC0, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x06, 0x07, 0x80, 0x00, 0x20, 0x36, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x18,
  0x0C, 0x80, 0x00, 0xC0, 0x46, 0x00, 0x06, 0x06, 0x30, 0x00, 0x20, 0x30,
  0xC0, 0x03, 0x01, 0x86, 0x00, 0x18, 0x0C, 0x10, 0x00, 0xC0, 0x40, 0xC0,
  0x06, 0x06, 0x06, 0x00, 0x20, 0x30, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x18,
  0x08, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x06, 0x00, 0x40, 0x20, 0x30,
  0x03, 0x03, 0x01, 0x80, 0x18, 0x18, 0x08, 0x00, 0x60, 0xC0, 0xC0, 0x03,
  0x04, 0x06, 0x00, 0x08, 0x60, 0x30, 0x00, 0x63, 0x01, 0x80, 0x03, 0x18,
  0x08, 0x00, 0x0C, 0xC0, 0xC0, 0x00, 0x64, 0x06, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x0F, 0x01, 0x80, 0x00, 0x38, 0x08, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x07,
  0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0x80, 0x3C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18, 0x0F, 0xE0,
  0x1F, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x00, 0x80, 0x20, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x01, 0xF9,
  0xFC, 0x07, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x20, 0x01, 0xE0,
  0x7C, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x98, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x03, 0x40, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x16, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x30, 0x00, 0x98, 0x00, 0x66, 0x00, 0x33, 0x00, 0x18, 0xC0,
  0x04, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18,
  0x60, 0x0C, 0x10, 0x06, 0x0C, 0x01, 0x82, 0x00, 0xC1, 0x80, 0x60, 0x40,
  0x10, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x18, 0x06, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x18, 0x30, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x61, 0x80,
  0x10, 0xC0, 0x0C, 0x60, 0x02, 0x10, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x31,
  0x00, 0x08, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0x34, 0x00,
  0x0B, 0x00, 0x07, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x82, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x08, 0x00, 0xE0,
  0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x06, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x00, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02,
  0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x10,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x11, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xC0, 0xC6, 0x18, 0x43, 0x0C, 0x20, 0x00, 0x3E, 0x00, 0x03,
  0xFE, 0x30, 0x38, 0x1C, 0x81, 0xC0, 0x12, 0x0E, 0x00, 0x78, 0x30, 0x00,
  0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C,
  0x10, 0x00, 0xF0, 0x60, 0x02, 0xC1, 0x80, 0x12, 0x03, 0x01, 0x88, 0x0F,
  0x1C, 0x20, 0x1F, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x1F,
  0x00, 0x30, 0xFF, 0x80, 0x63, 0x03, 0x80, 0xD8, 0x03, 0x81, 0x20, 0x03,
  0x02, 0x80, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x1E, 0x00, 0x18, 0x34, 0x00,
  0x70, 0x6C, 0x01, 0xC0, 0x8E, 0x0E, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x0F, 0x00, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x40, 0xF0, 0x70, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x81, 0x80, 0x1F, 0xF0, 0x80,
  0x38, 0x0C, 0xC0, 0x38, 0x03, 0x60, 0x30, 0x00, 0xB0, 0x38, 0x00, 0x78,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x0E, 0x02, 0x00, 0x0F, 0x01, 0x80, 0x0D, 0x00, 0xC0,
  0x0C, 0x80, 0x30, 0x0C, 0xC0, 0x1E, 0x1C, 0x60, 0x07, 0xF8, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x38, 0x18, 0x38, 0x03, 0x0C, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00, 0xEC, 0x00,
  0xF3, 0x01, 0xF0, 0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x20, 0x70, 0x78, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3C, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x01,
  0x00, 0x7F, 0xC2, 0x01, 0xC0, 0x62, 0x03, 0x80, 0x36, 0x07, 0x00, 0x16,
  0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x20, 0x00, 0xF0, 0x30, 0x01, 0xA0,
  0x30, 0x03, 0x60, 0x18, 0x06, 0x60, 0x1E, 0x1C, 0x60, 0x0F, 0xF0, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x0E, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x7C, 0x01, 0x87, 0xFC, 0x06, 0x30, 0x38, 0x1B, 0x80, 0x70,
  0x48, 0x00, 0xC1, 0x40, 0x03, 0x0F, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x70, 0x60, 0x06, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x10, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x80, 0x03, 0x64, 0x00, 0x16,
  0x30, 0x01, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0xC3, 0xFC, 0x0F, 0xF8, 0x19, 0xC1, 0x83,
  0x03, 0x03, 0x60, 0x18, 0xC0, 0x30, 0x58, 0x03, 0x30, 0x06, 0x0A, 0x00,
  0x2C, 0x00, 0xC3, 0x80, 0x05, 0x00, 0x08, 0x70, 0x00, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00, 0x0C, 0x20, 0x00, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x04, 0x30, 0x00, 0x40,
  0x01, 0x84, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x06, 0x30, 0x00,
  0x60, 0x00, 0x86, 0x00, 0x08, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x06, 0x10,
  0x00, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x02,
  0x18, 0x00, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x7F, 0xC0, 0x63, 0x03, 0x81, 0xB8,
  0x07, 0x04, 0x80, 0x0C, 0x14, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x0C, 0x0C, 0x00,
  0x30, 0x70, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x19, 0x00,
  0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x31, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x07, 0x03,
  0x80, 0x38, 0x07, 0x83, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xC3, 0xFE, 0x00, 0x63, 0x03, 0x80, 0x36, 0x00, 0xE0, 0x12, 0x00, 0x30,
  0x0A, 0x00, 0x18, 0x0F, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x10, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xE0,
  0x01, 0x80, 0xD0, 0x01, 0xC0, 0x6C, 0x01, 0xC0, 0x33, 0x83, 0x80, 0x10,
  0xFF, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x02, 0x01, 0xFF, 0x08, 0x0E, 0x03, 0x10, 0x38, 0x03,
  0x60, 0xE0, 0x02, 0xC3, 0x80, 0x07, 0x86, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86,
  0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x82, 0x00, 0x0F, 0x06, 0x00,
  0x34, 0x0C, 0x00, 0xD8, 0x0C, 0x03, 0x30, 0x1E, 0x1C, 0x60, 0x0F, 0xE0,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x83,
  0x0F, 0xC1, 0x9C, 0x00, 0xD8, 0x00, 0x48, 0x00, 0x28, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x70, 0x0C, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x8C, 0x00, 0xE3, 0xE0, 0xF0, 0x3F, 0xF0, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x17, 0xFF,
  0x83, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x80, 0xFE, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00,
  0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4,
  0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0xCC, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x38, 0x80,
  0x01, 0xC4, 0x00, 0x1C, 0x20, 0x00, 0xE1, 0x00, 0x0B, 0x0C, 0x00, 0xD8,
  0x60, 0x1C, 0x81, 0xC3, 0x84, 0x07, 0xF8, 0x60, 0xC0, 0x00, 0x74, 0x00,
  0x06, 0x40, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x01, 0x06, 0x00,
  0x10, 0xC0, 0x01, 0x88, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xA0, 0x03, 0x80, 0x0D, 0x00, 0x34, 0x00, 0xCC, 0x01,
  0xB0, 0x06, 0x60, 0x19, 0x80, 0x63, 0x00, 0xCC, 0x03, 0x18, 0x0C, 0x60,
  0x30, 0xC0, 0x63, 0x01, 0x86, 0x06, 0x18, 0x08, 0x30, 0x30, 0xC0, 0xC1,
  0x83, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x60, 0x61, 0x80, 0x83, 0x03, 0x0C,
  0x06, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC6, 0x01, 0x98, 0x02, 0x60, 0x0C,
  0xC0, 0x13, 0x00, 0x6C, 0x00, 0xB0, 0x03, 0x60, 0x05, 0x80, 0x1A, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x30, 0x00, 0x40, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x83, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xE0, 0x10, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x02,
  0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1B, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x05, 0xC3, 0xE0, 0x3C, 0x01, 0xFF,
  0xA0, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 33, 10, 1, -33 },
  { 43, 11, 12, 15, 5, -33 },
  { 60, 27, 33, 29, 2, -33 },
  { 172, 22, 38, 25, 2, -35 },
  { 277, 29, 34, 35, 4, -33 },
  { 401, 27, 33, 31, 2, -33 },
  { 513, 4, 12, 8, 5, -33 },
  { 519, 13, 40, 12, 2, -33 },
  { 584, 13, 40, 12, -3, -33 },
  { 649, 19, 20, 25, 6, -35 },
  { 697, 22, 21, 26, 3, -27 },
  { 755, 7, 11, 9, -2, -5 },
  { 765, 11, 1, 14, 2, -13 },
  { 767, 3, 3, 10, 1, -3 },
  { 769, 20, 33, 15, -2, -33 },
  { 852, 21, 33, 25, 3, -33 },
  { 939, 12, 33, 25, 7, -33 },
  { 989, 24, 33, 25, 0, -33 },
  { 1088, 23, 33, 25, 1, -33 },
  { 1183, 23, 33, 25, 1, -33 },
  { 1278, 23, 33, 25, 2, -33 },
  { 1373, 22, 33, 25, 3, -33 },
  { 1464, 21, 33, 25, 5, -33 },
  { 1551, 23, 33, 25, 2, -33 },
  { 1646, 22, 33, 25, 2, -33 },
  { 1737, 8, 25, 10, 1, -25 },
  { 1762, 11, 31, 10, -2, -25 },
  { 1805, 22, 21, 26, 3, -27 },
  { 1863, 22, 11, 26, 3, -22 },
  { 1894, 22, 21, 26, 3, -27 },
  { 1952, 16, 33, 19, 4, -33 },
  { 2018, 34, 37, 39, 3, -33 },
  { 2176, 25, 33, 25, -2, -33 },
  { 2280, 25, 33, 28, 2, -33 },
  { 2384, 25, 33, 27, 4, -33 },
  { 2488, 27, 33, 31, 2, -33 },
  { 2600, 24, 33, 24, 2, -33 },
  { 2699, 24, 33, 22, 2, -33 },
  { 2798, 27, 33, 32, 4, -33 },
  { 2910, 29, 33, 31, 2, -33 },
  { 3030, 15, 33, 13, 0, -33 },
  { 3092, 19, 41, 11, -8, -33 },
  { 3190, 27, 33, 25, 2, -33 },
  { 3302, 17, 33, 22, 2, -33 },
  { 3373, 35, 33, 37, 2, -33 },
  { 3518, 29, 33, 31, 2, -33 },
  { 3638, 27, 33, 33, 4, -33 },
  { 3750, 24, 33, 26, 2, -33 },
  { 3849, 27, 41, 33, 4, -33 },
  { 3988, 24, 33, 26, 2, -33 },
  { 4087, 23, 33, 23, 1, -33 },
  { 4182, 23, 33, 22, 4, -33 },
  { 4277, 28, 33, 32, 4, -33 },
  { 4393, 23, 33, 25, 5, -33 },
  { 4488, 35, 33, 38, 6, -33 },
  { 4633, 29, 33, 23, -3, -33 },
  { 4753, 23, 33, 23, 4, -33 },
  { 4848, 26, 33, 25, 0, -33 },
  { 4956, 17, 40, 14, 0, -33 },
  { 5041, 7, 33, 15, 5, -33 },
  { 5070, 17, 40, 14, -3, -33 },
  { 5155, 21, 20, 25, 2, -33 },
  { 5208, 18, 1, 17, -4, 5 },
  { 5211, 5, 7, 11, 7, -35 },
  { 5216, 22, 25, 25, 2, -25 },
  { 5285, 23, 35, 26, 1, -35 },
  { 5386, 19, 25, 21, 2, -25 },
  { 5446, 25, 35, 26, 2, -35 },
  { 5556, 18, 25, 23, 3, -25 },
  { 5613, 25, 46, 13, -6, -35 },
  { 5757, 24, 36, 26, 1, -25 },
  { 5865, 22, 35, 26, 1, -35 },
  { 5962, 10, 33, 10, 1, -33 },
  { 6004, 16, 44, 10, -6, -33 },
  { 6092, 21, 35, 21, 1, -35 },
  { 6184, 10, 35, 10, 1, -35 },
  { 6228, 35, 25, 39, 1, -25 },
  { 6338, 22, 25, 26, 1, -25 },
  { 6407, 22, 25, 26, 2, -25 },
  { 6476, 25, 36, 26, -1, -25 },
  { 6589, 23, 36, 26, 2, -25 },
  { 6693, 17, 25, 17, 1, -25 },
  { 6747, 18, 25, 20, 0, -25 },
  { 6804, 14, 30, 14, 2, -30 },
  { 6857, 21, 24, 26, 3, -24 },
  { 6920, 20, 24, 19, 2, -24 },
  { 6980, 29, 24, 31, 3, -24 },
  { 7067, 24, 24, 21, -2, -24 },
  { 7139, 27, 35, 19, -5, -24 },
  { 7258, 21, 24, 20, -1, -24 },
  { 7321, 17, 40, 15, 1, -33 },
  { 7406, 1, 46, 25, 13, -35 },
  { 7412, 16, 40, 15, -2, -33 },
  { 7492, 22, 4, 26, 3, -18 },
};

const GFXfont NotoSans_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRALIGHTITALIC46PT7B_H_
