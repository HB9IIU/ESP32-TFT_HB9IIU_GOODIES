#ifndef _NOTOSANS_EXTRALIGHTITALIC64PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0x00, 0x00, 0x1C, 0x0E, 0x30, 0x1C, 0x60, 0x38,
  0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0,
  0x31, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x10,
  0xC0, 0x60, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3E, 0x30, 0xFC, 0x01, 0xE0, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xDF, 0x00, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0C, 0x07, 0x02, 0x00, 0x60, 0x38, 0x0E, 0x01, 0x83, 0xC0, 0x3F, 0xF7,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x70, 0x00, 0x06, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x70, 0x03, 0x80, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x01,
  0xC0, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x00, 0x60, 0x60,
  0x3E, 0x1C, 0x00, 0x70, 0x70, 0x7F, 0xCE, 0x00, 0x30, 0x70, 0xF0, 0xE3,
  0x00, 0x38, 0x30, 0xF0, 0x39, 0x80, 0x18, 0x30, 0x60, 0x0C, 0xC0, 0x1C,
  0x38, 0x70, 0x07, 0x70, 0x1C, 0x38, 0x30, 0x03, 0x9C, 0x1C, 0x18, 0x30,
  0x00, 0xCF, 0xFC, 0x1C, 0x18, 0x00, 0x61, 0xFC, 0x1C, 0x1C, 0x00, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x07, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x01, 0x87, 0x00, 0x06,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x01, 0xC7,
  0x00, 0x00, 0x70, 0x0E, 0x18, 0x00, 0x00, 0xC0, 0x30, 0xE0, 0x00, 0x03,
  0x81, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x30,
  0x00, 0x00, 0x39, 0x80, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x60,
  0x00, 0x01, 0xCE, 0x01, 0xC0, 0x00, 0x0E, 0x18, 0x03, 0x80, 0x00, 0xF0,
  0x70, 0x07, 0x80, 0x1F, 0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x61, 0x86,
  0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0x78, 0x10, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x1E, 0xC0,
  0x0E, 0x00, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x74, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xF0, 0x30, 0x00, 0x3C, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x03, 0xC0,
  0x0E, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x7F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0x70, 0x1E, 0x30, 0x1E, 0x18, 0x3C, 0x1C, 0x3C, 0x0E, 0x78, 0x07, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x10, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x3F, 0xE0, 0x00, 0xC1, 0xFF, 0xF0, 0x03, 0x8F, 0x80,
  0xF0, 0x06, 0x38, 0x00, 0x70, 0x0C, 0xC0, 0x00, 0x70, 0x3B, 0x00, 0x00,
  0x60, 0x7C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0F,
  0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0D, 0x81,
  0xC0, 0x00, 0x76, 0x07, 0x80, 0x07, 0xB8, 0x0F, 0x00, 0x78, 0xE0, 0x1F,
  0xFF, 0xC3, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x02, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x20, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x04, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xF0, 0x1F, 0x06, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x1C, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0x18, 0x00, 0x3E, 0x00, 0x60, 0x07, 0x38, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x70, 0x01,
  0xC0, 0x00, 0xC0, 0x03, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x60, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x07,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x06, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x0E, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x0C,
  0x00, 0x07, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x1E, 0x00, 0x38, 0xC0, 0x0C,
  0x00, 0x3E, 0x00, 0x70, 0xC0, 0x0E, 0x00, 0x76, 0x00, 0xE0, 0xC0, 0x06,
  0x00, 0xE7, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0xC3, 0x87, 0x80, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x60, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x06, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x7C, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x01,
  0xF8, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0x08, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8, 0xE0, 0x00, 0x0F, 0xFF, 0xE3,
  0x80, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x0F, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x18, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0xFE,
  0x00, 0x00, 0x00, 0x77, 0x38, 0x00, 0x00, 0x01, 0xB8, 0x70, 0x00, 0x00,
  0x07, 0xC1, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0xB0, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB8, 0x03,
  0xB0, 0x00, 0x00, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0xCE, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x73, 0x80, 0x38, 0xC0, 0x00, 0x00, 0x71, 0x80,
  0x1C, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x60,
  0x06, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x03, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x07, 0x01,
  0x80, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x03, 0x80,
  0xE0, 0x06, 0x01, 0x80, 0x01, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x1C,
  0x00, 0x30, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x0E,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE6,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x37, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1B,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x00, 0xC6, 0x00, 0x00,
  0x0E, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x01,
  0xC3, 0x80, 0x00, 0x0C, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x30, 0x00,
  0x30, 0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x0C,
  0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x18, 0x00, 0x01, 0x81,
  0xC0, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x30, 0x00, 0x00,
  0x63, 0x80, 0x30, 0x00, 0x00, 0x73, 0x00, 0x70, 0x00, 0x00, 0x33, 0x00,
  0x70, 0x00, 0x00, 0x3B, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x00,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x01, 0xE0, 0x03,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xE0, 0x0C, 0x00, 0x07, 0xC0, 0x06, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x80,
  0x06, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x05, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x8E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x03, 0x81, 0x80, 0x03, 0x80, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x18, 0x00,
  0x60, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x06, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x60,
  0x00, 0x60, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x30, 0x03, 0xFF, 0xE0, 0xC0,
  0x1E, 0x01, 0xC3, 0x01, 0xE0, 0x03, 0x9C, 0x07, 0x00, 0x06, 0x60, 0x38,
  0x00, 0x0D, 0x81, 0xC0, 0x00, 0x36, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x78, 0x18, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x1B,
  0x01, 0xC0, 0x00, 0xCC, 0x07, 0x00, 0x06, 0x30, 0x0E, 0x00, 0x30, 0xC0,
  0x1C, 0x03, 0x87, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0x7F, 0xC0, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x01,
  0x00, 0x00, 0xE0, 0x7F, 0xE0, 0x01, 0x83, 0xFF, 0xE0, 0x03, 0x0F, 0x01,
  0xE0, 0x0E, 0x38, 0x00, 0xE0, 0x1C, 0xC0, 0x00, 0xE0, 0x33, 0x00, 0x01,
  0xC0, 0x6C, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xF0, 0x00,
  0x07, 0x03, 0x60, 0x00, 0x0E, 0x06, 0x60, 0x00, 0x78, 0x0C, 0xE0, 0x01,
  0xE0, 0x18, 0xF0, 0x0F, 0x80, 0x60, 0xFF, 0xFC, 0x00, 0xC0, 0x7F, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x10, 0x0F, 0x00, 0x38, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x3F,
  0xFF, 0x0E, 0x00, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0x00, 0x1C, 0xC0, 0x0F,
  0x00, 0x03, 0x30, 0x03, 0x80, 0x00, 0x6C, 0x01, 0xC0, 0x00, 0x1B, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x01, 0xF0,
  0x06, 0x00, 0x00, 0xD8, 0x01, 0xC0, 0x00, 0x66, 0x00, 0x70, 0x00, 0x31,
  0x80, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC0, 0x3C, 0x38, 0x00, 0x3F, 0xFE,
  0x0C, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x01, 0xE0,
  0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0x80, 0x00, 0xF8, 0xC0, 0x01,
  0xF0, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x10, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0x00, 0x1F, 0xFF, 0x83, 0x00, 0x3C, 0x01, 0xC3,
  0x00, 0xF0, 0x00, 0xE7, 0x01, 0xE0, 0x00, 0x66, 0x01, 0xC0, 0x00, 0x36,
  0x03, 0x80, 0x00, 0x36, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x60, 0x30, 0x00, 0x03, 0xE0,
  0x30, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x0C, 0xC0, 0x38, 0x00, 0x18, 0xC0,
  0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x01, 0xE1, 0xC0, 0x07, 0xFF, 0xC1, 0x80,
  0x03, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x80, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x40,
  0x00, 0x70, 0x3F, 0xF0, 0x01, 0x83, 0xFF, 0xF0, 0x06, 0x1E, 0x01, 0xC0,
  0x38, 0xE0, 0x03, 0x80, 0xE6, 0x00, 0x06, 0x03, 0x30, 0x00, 0x1C, 0x0D,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x83, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x01, 0x8F, 0xC0, 0x00, 0x1C, 0xEE,
  0x00, 0x00, 0xEE, 0x38, 0x00, 0x06, 0xC1, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x60, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x31, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x39, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x19, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0x0C, 0xC0, 0x01,
  0xCC, 0x00, 0x0C, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0x03, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x06,
  0x03, 0xFF, 0x00, 0x18, 0x3F, 0xFF, 0x00, 0x61, 0xE0, 0x3E, 0x03, 0x8E,
  0x00, 0x38, 0x0C, 0x70, 0x00, 0x70, 0x33, 0x00, 0x01, 0xC0, 0xD8, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0x03, 0x07, 0xFF, 0xC0, 0x00,
  0xC3, 0xC0, 0x78, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x18, 0xC0, 0x00, 0xE0,
  0x06, 0x60, 0x00, 0x38, 0x01, 0xB0, 0x00, 0x06, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x3E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00,
  0x38, 0x03, 0x60, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x0F, 0x00, 0x33, 0x80,
  0x07, 0x80, 0x0C, 0x78, 0x07, 0xC0, 0x07, 0x0F, 0xFF, 0xC0, 0x01, 0xC0,
  0xFF, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x0C, 0x00, 0xFF, 0xFC, 0x18, 0x03, 0xC0, 0x1C, 0x30, 0x1E,
  0x00, 0x1C, 0xE0, 0x78, 0x00, 0x19, 0x80, 0xE0, 0x00, 0x1B, 0x03, 0x80,
  0x00, 0x36, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x1B, 0x03, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0xD8, 0x0E,
  0x00, 0x03, 0x30, 0x1C, 0x00, 0x0C, 0x60, 0x1C, 0x00, 0x71, 0xC0, 0x1C,
  0x03, 0xC3, 0x80, 0x1F, 0xFF, 0x06, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0xFF,
  0x01, 0x83, 0xFE, 0x01, 0x87, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x7C, 0x00, 0xE0, 0x78, 0x00, 0x10, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC1, 0x00, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0x78, 0x30, 0x00, 0x06, 0xC1, 0x80, 0x00, 0x6E, 0x0C, 0x00, 0x07, 0x60,
  0x70, 0x00, 0x73, 0x03, 0x80, 0x07, 0x18, 0x0F, 0x00, 0xF0, 0xC0, 0x3F,
  0xFE, 0x0E, 0x00, 0xFF, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x60,
  0x0E, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x00, 0x01, 0x98, 0x00, 0x0F, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x30, 0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x38, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x38, 0x00, 0xC3, 0x00,
  0x1C, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x0E, 0x00, 0x60, 0xC0, 0x0E, 0x07,
  0x00, 0x60, 0x60, 0x06, 0x03, 0x80, 0x30, 0x38, 0x07, 0x01, 0xC0, 0x30,
  0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x07, 0x01,
  0x80, 0x18, 0x1C, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0E, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x70, 0x01, 0x87, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x00, 0x0C, 0x38, 0x00, 0x63, 0x80, 0x06, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5F, 0xBF, 0x80,
  0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 47, 14, 2, -46 },
  { 78, 15, 17, 21, 7, -46 },
  { 110, 38, 46, 40, 2, -46 },
  { 329, 30, 53, 35, 3, -49 },
  { 528, 41, 47, 49, 5, -46 },
  { 769, 38, 47, 44, 3, -46 },
  { 993, 6, 17, 12, 7, -46 },
  { 1006, 19, 56, 16, 2, -46 },
  { 1139, 18, 56, 16, -4, -46 },
  { 1265, 27, 28, 34, 8, -49 },
  { 1360, 29, 29, 36, 5, -37 },
  { 1466, 10, 15, 13, -3, -7 },
  { 1485, 16, 3, 20, 2, -19 },
  { 1491, 4, 5, 14, 2, -4 },
  { 1494, 29, 46, 20, -3, -46 },
  { 1661, 30, 47, 35, 4, -46 },
  { 1838, 17, 46, 35, 10, -46 },
  { 1936, 32, 46, 35, 1, -46 },
  { 2120, 33, 47, 35, 1, -46 },
  { 2314, 33, 46, 35, 1, -46 },
  { 2504, 32, 47, 35, 2, -46 },
  { 2692, 31, 47, 35, 4, -46 },
  { 2875, 29, 46, 35, 7, -46 },
  { 3042, 31, 47, 35, 3, -46 },
  { 3225, 30, 47, 35, 3, -46 },
  { 3402, 10, 35, 14, 2, -34 },
  { 3446, 15, 42, 14, -3, -34 },
  { 3525, 29, 29, 36, 5, -38 },
  { 3631, 29, 15, 36, 5, -30 },
  { 3686, 29, 29, 36, 5, -38 },
  { 3792, 22, 47, 26, 5, -46 },
  { 3922, 48, 51, 54, 4, -45 },
  { 4228, 35, 46, 35, -3, -46 },
  { 4430, 34, 46, 38, 3, -46 },
  { 4626, 36, 47, 38, 5, -46 },
  { 4838, 38, 46, 43, 3, -46 },
  { 5057, 33, 46, 34, 3, -46 },
  { 5247, 33, 46, 31, 3, -46 },
  { 5437, 38, 47, 44, 5, -46 },
  { 5661, 40, 46, 44, 3, -46 },
  { 5891, 21, 46, 18, 0, -46 },
  { 6012, 26, 57, 15, -11, -46 },
  { 6198, 38, 46, 35, 3, -46 },
  { 6417, 23, 46, 31, 3, -46 },
  { 6550, 49, 46, 52, 3, -46 },
  { 6832, 40, 46, 44, 3, -46 },
  { 7062, 38, 47, 46, 5, -46 },
  { 7286, 33, 46, 36, 3, -46 },
  { 7476, 38, 57, 46, 5, -46 },
  { 7747, 33, 46, 36, 3, -46 },
  { 7937, 32, 47, 32, 1, -46 },
  { 8125, 31, 46, 31, 6, -46 },
  { 8304, 39, 47, 44, 5, -46 },
  { 8534, 32, 46, 34, 7, -46 },
  { 8718, 50, 46, 53, 8, -46 },
  { 9006, 41, 46, 32, -4, -46 },
  { 9242, 31, 46, 31, 6, -46 },
  { 9421, 38, 46, 34, -1, -46 },
  { 9640, 25, 56, 19, -1, -46 },
  { 9815, 11, 46, 20, 6, -46 },
  { 9879, 25, 56, 19, -5, -46 },
  { 10054, 30, 28, 35, 3, -46 },
  { 10159, 25, 2, 24, -6, 7 },
  { 10166, 8, 10, 15, 9, -49 },
  { 10176, 30, 36, 35, 3, -35 },
  { 10311, 31, 50, 36, 2, -49 },
  { 10505, 26, 36, 29, 3, -35 },
  { 10622, 34, 50, 36, 3, -49 },
  { 10835, 25, 36, 32, 4, -35 },
  { 10948, 35, 64, 18, -8, -49 },
  { 11228, 32, 50, 36, 2, -35 },
  { 11428, 30, 49, 36, 2, -49 },
  { 11612, 13, 46, 14, 2, -46 },
  { 11687, 24, 61, 14, -9, -46 },
  { 11870, 29, 49, 29, 2, -49 },
  { 12048, 13, 49, 14, 2, -49 },
  { 12128, 49, 35, 54, 2, -35 },
  { 12343, 30, 35, 36, 2, -35 },
  { 12475, 30, 36, 36, 3, -35 },
  { 12610, 34, 50, 36, -1, -35 },
  { 12823, 31, 50, 36, 3, -35 },
  { 13017, 24, 34, 24, 2, -34 },
  { 13119, 25, 36, 27, 1, -35 },
  { 13232, 19, 43, 20, 3, -42 },
  { 13335, 29, 35, 36, 4, -34 },
  { 13462, 27, 34, 27, 3, -34 },
  { 13577, 41, 34, 43, 4, -34 },
  { 13752, 33, 34, 30, -2, -34 },
  { 13893, 37, 49, 27, -7, -34 },
  { 14120, 29, 34, 28, -1, -34 },
  { 14244, 23, 56, 21, 2, -46 },
  { 14405, 2, 64, 34, 18, -49 },
  { 14421, 23, 56, 21, -3, -46 },
  { 14582, 29, 6, 36, 5, -26 },
};

const GFXfont NotoSans_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRALIGHTITALIC64PT7B_H_
