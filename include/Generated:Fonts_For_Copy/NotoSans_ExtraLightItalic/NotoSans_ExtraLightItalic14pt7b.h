#ifndef _NOTOSANS_EXTRALIGHTITALIC14PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x10, 0xB7, 0x60, 0x09, 0x04, 0x84, 0x8F, 0xF1,
  0x21, 0x23, 0xFC, 0x48, 0x24, 0x24, 0x00, 0x08, 0x27, 0x54, 0x50, 0x83,
  0x89, 0x26, 0xE6, 0x10, 0x71, 0xA8, 0xA4, 0x92, 0x89, 0xBF, 0x64, 0x52,
  0x49, 0x24, 0xA3, 0x80, 0x3C, 0x24, 0x24, 0x28, 0x30, 0x51, 0x89, 0x86,
  0x84, 0xFA, 0xF0, 0x19, 0x08, 0x84, 0x22, 0x10, 0x84, 0x20, 0x80, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x4C, 0x10, 0x8E, 0x0F, 0x62, 0x40, 0x10, 0x20,
  0x47, 0xF1, 0x02, 0x00, 0x56, 0xF0, 0x80, 0x02, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x41, 0x00, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x61, 0x89, 0xC0,
  0x35, 0xA2, 0x22, 0x24, 0x44, 0x3E, 0x04, 0x08, 0x10, 0x41, 0x04, 0x10,
  0x41, 0xF8, 0x3E, 0x04, 0x08, 0x11, 0xC4, 0x80, 0x81, 0x05, 0xF0, 0x02,
  0x0C, 0x28, 0x92, 0x48, 0xA1, 0x3F, 0x04, 0x10, 0x3E, 0x81, 0x02, 0x07,
  0x80, 0x81, 0x02, 0x09, 0xE0, 0x1E, 0x41, 0x04, 0x0F, 0x90, 0xA1, 0x42,
  0x88, 0xE0, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x80, 0x3D,
  0x14, 0x51, 0x39, 0x28, 0x61, 0x87, 0xE0, 0x3D, 0x18, 0x61, 0x85, 0xF0,
  0x42, 0x0B, 0xC0, 0x24, 0x00, 0x04, 0x11, 0x00, 0x00, 0x24, 0x48, 0x0C,
  0xCC, 0x10, 0x38, 0x10, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0xC3, 0x33, 0x00,
  0x70, 0x42, 0x11, 0x31, 0x10, 0x04, 0x00, 0x1F, 0x88, 0x14, 0x06, 0x3D,
  0x91, 0x68, 0x9A, 0x26, 0x9A, 0x99, 0x20, 0x07, 0xE0, 0x02, 0x06, 0x0A,
  0x0A, 0x12, 0x11, 0x2F, 0x21, 0x41, 0x81, 0x3C, 0x85, 0x0A, 0x17, 0xD0,
  0xA0, 0xC1, 0x85, 0xF0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x3C, 0x42, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x84, 0xF8,
  0x3E, 0x81, 0x02, 0x07, 0xD0, 0x20, 0x40, 0x81, 0xF0, 0x3E, 0x81, 0x02,
  0x04, 0x17, 0xA0, 0x40, 0x81, 0x00, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x8F,
  0x81, 0x82, 0x82, 0x7E, 0x41, 0x41, 0x41, 0x41, 0x7F, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x38, 0x88, 0x42, 0x11, 0x08, 0x47, 0x00, 0x08, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x89, 0xC0, 0x43, 0x44, 0x48, 0x50, 0x60, 0x50, 0x90,
  0x88, 0x88, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x87, 0xC0, 0x20, 0x58,
  0x16, 0x0D, 0x85, 0x51, 0x64, 0xA9, 0x4A, 0x52, 0x98, 0xA2, 0x20, 0x21,
  0x61, 0x51, 0x51, 0x51, 0x89, 0x8A, 0x86, 0x86, 0x82, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x82, 0x3E, 0x00, 0x3C, 0x85, 0x0A,
  0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C,
  0x06, 0x05, 0x02, 0x82, 0x3A, 0x02, 0x00, 0x80, 0x3C, 0x85, 0x0A, 0x14,
  0x4F, 0x22, 0x44, 0x89, 0x08, 0x1E, 0x41, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x05, 0xF0, 0xFE, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x80, 0x40,
  0xA0, 0x50, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x3E, 0x00, 0x81,
  0x82, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x84, 0x31, 0x8A,
  0x51, 0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x30, 0x86, 0x10, 0x80, 0x10,
  0x88, 0x84, 0x81, 0x80, 0x80, 0x40, 0x50, 0x48, 0x42, 0x41, 0x00, 0x82,
  0x89, 0x12, 0x45, 0x04, 0x08, 0x10, 0x40, 0x80, 0x3F, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0xFC, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0xC0, 0x91, 0x24, 0x92, 0x24, 0x38, 0x42, 0x10, 0x88, 0x42, 0x11,
  0x09, 0xC0, 0x10, 0xA2, 0x91, 0x46, 0x10, 0xF8, 0xA4, 0x31, 0x38, 0x61,
  0x86, 0x28, 0xBE, 0x20, 0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A,
  0xE0, 0x3A, 0x21, 0x08, 0x42, 0x0E, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1,
  0x42, 0x85, 0x13, 0xE0, 0x32, 0x63, 0x3E, 0x42, 0x0E, 0x03, 0x04, 0x08,
  0x1C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xE0, 0x1C,
  0x45, 0x0A, 0x14, 0x30, 0x51, 0x3E, 0x04, 0x0B, 0xE0, 0x20, 0x40, 0x81,
  0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A, 0x10, 0x20, 0x14, 0x92, 0x50, 0x08,
  0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x4E, 0x00, 0x20, 0x40, 0x81, 0x12,
  0x49, 0x14, 0x38, 0x50, 0x92, 0x30, 0x24, 0x92, 0x92, 0x4A, 0x00, 0x0C,
  0xC6, 0x64, 0x88, 0xA1, 0x14, 0x42, 0x88, 0x51, 0x14, 0x22, 0x0C, 0x64,
  0x8A, 0x14, 0x28, 0x51, 0x42, 0x39, 0x18, 0x61, 0x86, 0x18, 0x9C, 0x0C,
  0x64, 0x8A, 0x14, 0x28, 0x51, 0x5C, 0x81, 0x02, 0x00, 0x39, 0x18, 0x61,
  0x86, 0x18, 0xBE, 0x08, 0x20, 0x80, 0x0C, 0xC2, 0x10, 0x41, 0x04, 0x20,
  0x39, 0x14, 0x18, 0x10, 0x20, 0xBC, 0x4F, 0x48, 0x88, 0x88, 0xE0, 0x86,
  0x18, 0x61, 0x8A, 0x2F, 0x80, 0x8E, 0x29, 0x24, 0xA3, 0x04, 0x00, 0x88,
  0xCC, 0xAA, 0x55, 0x4C, 0xA6, 0x22, 0x10, 0x46, 0x50, 0x41, 0x85, 0x09,
  0x22, 0x00, 0x11, 0x88, 0x84, 0x82, 0x41, 0x40, 0xC0, 0x20, 0x20, 0x10,
  0x70, 0x00, 0x7C, 0x21, 0x08, 0x41, 0x0F, 0x80, 0x08, 0x88, 0x42, 0x13,
  0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x42, 0x11, 0x08, 0x22, 0x11,
  0x09, 0x80, 0x66, 0x70,
};

const GFXglyph NotoSans_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 5, 2, -10 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 6, 12, 8, 1, -11 },
  { 28, 9, 10, 11, 1, -10 },
  { 40, 8, 10, 10, 1, -10 },
  { 50, 1, 4, 3, 2, -10 },
  { 51, 5, 12, 4, 0, -10 },
  { 59, 4, 12, 4, -1, -10 },
  { 65, 6, 6, 7, 2, -11 },
  { 70, 7, 6, 8, 1, -8 },
  { 76, 2, 4, 3, -1, -2 },
  { 77, 4, 1, 4, 0, -4 },
  { 78, 1, 1, 3, 0, -1 },
  { 79, 7, 10, 4, -1, -10 },
  { 88, 6, 10, 8, 1, -10 },
  { 96, 4, 10, 8, 2, -10 },
  { 101, 7, 10, 8, 0, -10 },
  { 110, 7, 10, 8, 0, -10 },
  { 119, 7, 10, 8, 0, -10 },
  { 128, 7, 10, 8, 1, -10 },
  { 137, 7, 10, 8, 1, -10 },
  { 146, 7, 10, 8, 1, -10 },
  { 155, 6, 10, 8, 1, -10 },
  { 163, 6, 10, 8, 1, -10 },
  { 171, 3, 8, 3, 0, -8 },
  { 174, 4, 10, 3, -1, -8 },
  { 179, 6, 6, 8, 1, -8 },
  { 184, 6, 4, 8, 1, -7 },
  { 187, 6, 6, 8, 1, -8 },
  { 192, 5, 10, 6, 1, -10 },
  { 199, 10, 11, 12, 1, -10 },
  { 213, 8, 10, 8, -1, -10 },
  { 223, 7, 10, 8, 1, -10 },
  { 232, 8, 10, 8, 1, -10 },
  { 242, 8, 10, 9, 1, -10 },
  { 252, 7, 10, 7, 1, -10 },
  { 261, 7, 10, 7, 1, -10 },
  { 270, 8, 10, 10, 1, -10 },
  { 280, 8, 10, 10, 1, -10 },
  { 290, 5, 10, 4, 0, -10 },
  { 297, 5, 12, 3, -2, -10 },
  { 305, 8, 10, 8, 1, -10 },
  { 315, 5, 10, 7, 1, -10 },
  { 322, 10, 10, 11, 1, -10 },
  { 335, 8, 10, 10, 1, -10 },
  { 345, 9, 10, 10, 1, -10 },
  { 357, 7, 10, 8, 1, -10 },
  { 366, 9, 12, 10, 1, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 7, 10, 7, 0, -10 },
  { 398, 7, 10, 7, 1, -10 },
  { 407, 9, 10, 10, 1, -10 },
  { 419, 8, 10, 8, 1, -10 },
  { 429, 11, 10, 12, 2, -10 },
  { 443, 9, 10, 7, -1, -10 },
  { 455, 7, 10, 7, 1, -10 },
  { 464, 8, 10, 8, 0, -10 },
  { 474, 5, 12, 4, 0, -10 },
  { 482, 3, 10, 4, 1, -10 },
  { 486, 5, 12, 4, -1, -10 },
  { 494, 6, 6, 8, 1, -10 },
  { 499, 5, 1, 5, -1, 1 },
  { 500, 2, 3, 3, 2, -11 },
  { 501, 6, 8, 8, 1, -8 },
  { 507, 7, 11, 8, 0, -11 },
  { 517, 5, 8, 6, 1, -8 },
  { 522, 7, 11, 8, 1, -11 },
  { 532, 5, 8, 7, 1, -8 },
  { 537, 8, 14, 4, -2, -11 },
  { 551, 7, 11, 8, 0, -8 },
  { 561, 7, 11, 8, 0, -11 },
  { 571, 3, 10, 3, 0, -10 },
  { 575, 5, 13, 3, -2, -10 },
  { 584, 7, 11, 6, 0, -11 },
  { 594, 3, 11, 3, 0, -11 },
  { 599, 11, 8, 12, 0, -8 },
  { 610, 7, 8, 8, 0, -8 },
  { 617, 6, 8, 8, 1, -8 },
  { 623, 7, 11, 8, 0, -8 },
  { 633, 6, 11, 8, 1, -8 },
  { 642, 6, 8, 5, 0, -8 },
  { 648, 6, 8, 6, 0, -8 },
  { 654, 4, 9, 4, 1, -9 },
  { 659, 6, 7, 8, 1, -7 },
  { 665, 6, 7, 6, 1, -7 },
  { 671, 9, 7, 9, 1, -7 },
  { 679, 7, 7, 6, 0, -7 },
  { 686, 9, 10, 6, -2, -7 },
  { 698, 6, 7, 6, 0, -7 },
  { 704, 5, 12, 5, 0, -10 },
  { 712, 1, 14, 8, 4, -11 },
  { 714, 5, 12, 5, -1, -10 },
  { 722, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRALIGHTITALIC14PT7B_H_
