#ifndef _NOTOSANS_EXTRALIGHTITALIC36PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x21, 0x61, 0x63, 0x43, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x00, 0x20,
  0x20, 0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x06, 0x04, 0x03, 0xFF, 0xFF, 0x80,
  0x40, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x3F, 0xD0, 0x62, 0x30, 0x61, 0x00, 0x60,
  0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x06, 0x10, 0x03, 0x18, 0x00,
  0xE8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0x70, 0x01, 0x8C, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x18, 0x60, 0x08, 0x61, 0x84,
  0xE0, 0x7F, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x0F, 0x80, 0x0C, 0x31, 0x80, 0x30, 0xC1, 0x00, 0x41, 0x02, 0x01, 0x06,
  0x04, 0x06, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x60, 0x20, 0x80, 0xC0,
  0x43, 0x01, 0x01, 0x8C, 0x02, 0x02, 0x10, 0xC4, 0x04, 0x47, 0xE8, 0x19,
  0x98, 0x58, 0x26, 0x60, 0xD9, 0x88, 0x81, 0x9E, 0x23, 0x03, 0x00, 0xC6,
  0x06, 0x01, 0x08, 0x0C, 0x04, 0x10, 0x10, 0x18, 0x20, 0x20, 0x60, 0xC0,
  0x40, 0x81, 0x81, 0x82, 0x03, 0x02, 0x0C, 0x02, 0x0C, 0x30, 0x06, 0x30,
  0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0x38, 0x00, 0xC0, 0x40, 0x04,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x60,
  0x02, 0x06, 0x00, 0x10, 0x60, 0x00, 0x4E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0x20, 0x00, 0x61, 0x80, 0x6C, 0x06, 0x02, 0x40, 0x10, 0x36,
  0x00, 0x41, 0x20, 0x03, 0x19, 0x00, 0x0D, 0x88, 0x00, 0x38, 0x40, 0x01,
  0x82, 0x00, 0x1E, 0x18, 0x01, 0x90, 0x60, 0x30, 0x41, 0xFE, 0x03, 0x00,
  0x2D, 0xA4, 0x94, 0x90, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x02, 0x04, 0x0E,
  0x08, 0x07, 0x10, 0x01, 0xC1, 0x80, 0xFF, 0x02, 0x80, 0x09, 0x00, 0x22,
  0x01, 0x82, 0x06, 0x04, 0x04, 0x0C, 0x00, 0x08, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x61, 0x84, 0x30, 0x86,
  0x10, 0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xC3, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x02,
  0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x34, 0x00,
  0x1A, 0x00, 0x0D, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0x98, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x00, 0x60, 0xC0, 0x60,
  0x30, 0x60, 0x0F, 0xE0, 0x00, 0x01, 0x81, 0xC3, 0x43, 0x27, 0x16, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x00, 0x00,
  0x7E, 0x00, 0x70, 0xE0, 0x30, 0x0C, 0x08, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x3F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0xE0, 0xC0, 0xE0, 0x18, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x03, 0xF0, 0x01, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x62, 0x00, 0x30, 0xC0, 0x38, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x00,
  0x06, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00,
  0x80, 0x80, 0x20, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x10, 0x30,
  0x02, 0x0C, 0x00, 0xC1, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xE0, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x62, 0x00, 0x30, 0xE0, 0x38, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x3C, 0x20, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x1F, 0x00, 0x9C,
  0xF0, 0x68, 0x06, 0x14, 0x00, 0x86, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x86,
  0x00, 0xC0, 0x80, 0x60, 0x30, 0x30, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xC3, 0x81, 0x80, 0x41, 0x80, 0x30, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x06, 0x01, 0x81, 0x83,
  0x00, 0x67, 0x00, 0x1E, 0x00, 0x39, 0x80, 0x60, 0x60, 0x60, 0x18, 0x40,
  0x06, 0x60, 0x03, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x33,
  0x00, 0x10, 0x80, 0x18, 0x70, 0x38, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0x87, 0x03, 0x00, 0x83, 0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x06,
  0x40, 0x03, 0x20, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x62, 0x00,
  0x31, 0x80, 0x68, 0x70, 0xEC, 0x0F, 0xC4, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x81, 0xC0, 0x7F, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x1F, 0x87, 0x0E,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19,
  0x80, 0x7F, 0x81, 0x20, 0x38, 0x10, 0x2C, 0x0C, 0x06, 0x05, 0x01, 0x00,
  0x80, 0xA0, 0x40, 0x10, 0x1C, 0x08, 0x02, 0x03, 0x83, 0x00, 0xC0, 0xE0,
  0x40, 0x10, 0x1C, 0x08, 0x02, 0x02, 0x81, 0x00, 0xC0, 0xD0, 0x20, 0x38,
  0x12, 0x06, 0x05, 0x06, 0x60, 0x43, 0x21, 0x84, 0x07, 0xC3, 0xC0, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x0C, 0x80,
  0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x02, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x04, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x60, 0x06, 0x0C, 0x00, 0x20, 0x80,
  0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60,
  0x00, 0x3C, 0x00, 0x01, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x10, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x03, 0x18,
  0x00, 0x43, 0x00, 0x18, 0x40, 0x06, 0x08, 0x03, 0x81, 0xFF, 0x80, 0x60,
  0x1C, 0x0C, 0x00, 0xC1, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x11, 0x80,
  0x02, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00,
  0x30, 0x80, 0x38, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0E, 0x0F, 0x03,
  0x80, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0xF8, 0x01, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xC0, 0x02,
  0x06, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00,
  0x18, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0xC3, 0x00, 0x1C, 0x18,
  0x01, 0xC0, 0x80, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0x83, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x07, 0xC0,
  0xE0, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xF2, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x02, 0x06, 0x00, 0x10, 0x1C, 0x03, 0x80,
  0x3F, 0xF0, 0x00, 0x06, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x1F, 0xFF, 0xF0, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x82,
  0x00, 0x02, 0x00, 0x07, 0xF0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x7E, 0x00, 0x06, 0x00, 0x18, 0x20, 0x01, 0x01,
  0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x20, 0x30,
  0x01, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x60, 0x00, 0x27,
  0x00, 0x01, 0x68, 0x00, 0x1E, 0x60, 0x00, 0xE1, 0x00, 0x04, 0x0C, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0x80, 0x80, 0x06, 0x04,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE0,
  0xD0, 0x00, 0x34, 0x12, 0x00, 0x04, 0x82, 0x40, 0x01, 0xB0, 0x48, 0x00,
  0x26, 0x19, 0x80, 0x0C, 0x83, 0x30, 0x01, 0x10, 0x42, 0x00, 0x42, 0x08,
  0x40, 0x18, 0xC1, 0x08, 0x02, 0x18, 0x61, 0x00, 0xC2, 0x0C, 0x30, 0x10,
  0x41, 0x06, 0x04, 0x08, 0x20, 0x41, 0x83, 0x04, 0x08, 0x20, 0x61, 0x81,
  0x0C, 0x08, 0x30, 0x21, 0x01, 0x04, 0x06, 0x60, 0x60, 0x80, 0xD8, 0x0C,
  0x30, 0x0A, 0x01, 0x06, 0x01, 0xC0, 0x20, 0x80, 0x30, 0x04, 0x10, 0x06,
  0x01, 0x80, 0x04, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0x43, 0xC0,
  0x03, 0x0D, 0x00, 0x0C, 0x26, 0x00, 0x20, 0x88, 0x00, 0x82, 0x20, 0x06,
  0x18, 0xC0, 0x18, 0x61, 0x00, 0x41, 0x06, 0x01, 0x04, 0x08, 0x04, 0x10,
  0x20, 0x30, 0xC0, 0xC0, 0xC3, 0x01, 0x02, 0x08, 0x06, 0x08, 0x20, 0x08,
  0x20, 0x80, 0x31, 0x86, 0x00, 0x46, 0x18, 0x01, 0x10, 0x40, 0x06, 0x41,
  0x00, 0x09, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x70, 0x80, 0x01, 0x82, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x18, 0x18, 0x00,
  0x61, 0x80, 0x01, 0x08, 0x00, 0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x60,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x61,
  0x80, 0x06, 0x06, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x40, 0x18, 0x30, 0x02, 0x0C, 0x00, 0xC3, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x31, 0x00, 0x08,
  0x40, 0x06, 0x10, 0x03, 0x0C, 0x03, 0x83, 0xFF, 0x80, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01, 0x08,
  0x00, 0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00,
  0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x06, 0x06, 0x00,
  0x60, 0x1C, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0xC0, 0x40, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x08, 0x40,
  0x06, 0x10, 0x07, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x80, 0xC0, 0x20, 0x30,
  0x08, 0x04, 0x06, 0x01, 0x81, 0x80, 0x60, 0x40, 0x08, 0x10, 0x03, 0x0C,
  0x00, 0x43, 0x00, 0x10, 0xC0, 0x06, 0x20, 0x00, 0x80, 0x00, 0xFE, 0x01,
  0xC1, 0xC1, 0x80, 0x21, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0xC0, 0x70, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00,
  0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x8C,
  0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x60, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x83, 0x00, 0x06, 0x04, 0x00, 0x30, 0x18, 0x01, 0x80, 0x38, 0x1C,
  0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1A, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x61, 0x00, 0x10, 0x40, 0x0C,
  0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40, 0x60, 0x30, 0x18, 0x08, 0x06,
  0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x8C,
  0x00, 0x32, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x24, 0x00, 0xE0, 0x06, 0x40, 0x0A, 0x00, 0x64, 0x01, 0xA0, 0x04,
  0x40, 0x13, 0x00, 0xC4, 0x03, 0x30, 0x08, 0x40, 0x23, 0x01, 0x84, 0x06,
  0x30, 0x10, 0x40, 0x43, 0x03, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06,
  0x04, 0x18, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x30, 0x10, 0xC0, 0x42,
  0x01, 0x08, 0x06, 0x20, 0x11, 0x80, 0x64, 0x01, 0x10, 0x06, 0x40, 0x13,
  0x00, 0x6C, 0x01, 0x20, 0x06, 0x80, 0x16, 0x00, 0x78, 0x01, 0x40, 0x07,
  0x00, 0x14, 0x00, 0x70, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x08, 0x02,
  0x00, 0x18, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x63, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x90, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x26, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x20, 0x06,
  0x08, 0x01, 0x03, 0x00, 0xC0, 0x40, 0x60, 0x10, 0x10, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x23, 0x00, 0x08, 0x80, 0x03, 0x60, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xF8, 0x1F,
  0xC0, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x42, 0x18, 0x42, 0x10, 0x86, 0x30,
  0x84, 0x21, 0x0C, 0x61, 0x08, 0x40, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x20, 0x00, 0x70, 0x00, 0x50, 0x00, 0x90, 0x01, 0x98,
  0x01, 0x08, 0x02, 0x08, 0x06, 0x0C, 0x04, 0x04, 0x0C, 0x04, 0x18, 0x06,
  0x10, 0x02, 0x30, 0x02, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xFF, 0xFC,
  0xC2, 0x18, 0x41, 0x0C, 0x03, 0xF1, 0x87, 0x04, 0x86, 0x01, 0x46, 0x00,
  0xA2, 0x00, 0x33, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x06, 0x60,
  0x03, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x71,
  0x80, 0x50, 0x40, 0x68, 0x30, 0x64, 0x0F, 0xC6, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x7E, 0x02, 0x60, 0xC0, 0xB0, 0x18, 0x70, 0x02,
  0x14, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x60, 0x01, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0xC0, 0x18, 0x50, 0x0C, 0x36, 0x06, 0x08, 0x7F, 0x00, 0x03, 0xFE,
  0x1C, 0x08, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x60, 0x7F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x03, 0xF8, 0x81, 0xC1, 0x90, 0x60, 0x1E,
  0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x18,
  0xC0, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x61,
  0x00, 0x18, 0x20, 0x07, 0x06, 0x00, 0xA0, 0x40, 0x24, 0x0C, 0x19, 0x80,
  0xFE, 0x20, 0x00, 0x03, 0xF8, 0x0C, 0x18, 0x20, 0x10, 0x80, 0x33, 0x00,
  0x64, 0x00, 0x98, 0x03, 0x20, 0x1C, 0xC1, 0xE1, 0xFE, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x60, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFC, 0x41, 0xC1, 0x90, 0xC0, 0x2C, 0x60, 0x07, 0x10, 0x01, 0x8C,
  0x00, 0x62, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x0C, 0x40, 0x03, 0x10, 0x01, 0x84, 0x00, 0xE1, 0x80, 0x28,
  0x20, 0x16, 0x0C, 0x19, 0x81, 0xFC, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x20, 0x18, 0x0F, 0xFC,
  0x00, 0x38, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x7E, 0x04, 0xC1,
  0x82, 0xC0, 0x63, 0xC0, 0x31, 0x40, 0x08, 0xC0, 0x0C, 0x40, 0x06, 0x20,
  0x03, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x23,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x60, 0x02, 0x30, 0x01,
  0x00, 0x06, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x07, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x01, 0x08, 0x03, 0x04, 0x03, 0x02, 0x03, 0x03, 0x03, 0x01, 0x83,
  0x00, 0x83, 0x00, 0x43, 0x00, 0x23, 0x00, 0x33, 0x00, 0x12, 0x80, 0x0A,
  0x60, 0x06, 0x10, 0x06, 0x0C, 0x03, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x40, 0x30, 0x60, 0x08, 0x30, 0x06, 0x00, 0x02, 0x04, 0x18, 0x30, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x00, 0x08, 0xFC, 0x0F, 0xC1, 0x30,
  0xC6, 0x0C, 0x28, 0x09, 0x80, 0x8E, 0x01, 0xA0, 0x11, 0x40, 0x38, 0x02,
  0x30, 0x06, 0x00, 0x44, 0x00, 0xC0, 0x08, 0x80, 0x18, 0x01, 0x30, 0x02,
  0x00, 0x66, 0x00, 0x40, 0x0C, 0x80, 0x18, 0x01, 0x10, 0x03, 0x00, 0x26,
  0x00, 0x40, 0x04, 0xC0, 0x08, 0x01, 0x90, 0x01, 0x00, 0x32, 0x00, 0x60,
  0x04, 0x40, 0x0C, 0x00, 0x98, 0x01, 0x00, 0x33, 0x00, 0x20, 0x06, 0x00,
  0x08, 0x7E, 0x04, 0xC1, 0x82, 0xC0, 0x63, 0xC0, 0x31, 0xC0, 0x08, 0xC0,
  0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0xC4,
  0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06,
  0x60, 0x02, 0x30, 0x01, 0x00, 0x03, 0xF8, 0x0E, 0x0E, 0x18, 0x02, 0x30,
  0x03, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x06, 0xC0,
  0x0C, 0x60, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x02, 0x1F, 0x80, 0x26, 0x0C,
  0x02, 0xC0, 0x60, 0x78, 0x02, 0x05, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x40, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x06, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0xC0, 0x18, 0x14,
  0x03, 0x03, 0x20, 0x60, 0x31, 0xFC, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x87, 0x06, 0x46, 0x01, 0x66, 0x00, 0x72,
  0x00, 0x33, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x01,
  0x20, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x62, 0x00, 0x71, 0x80,
  0x28, 0x40, 0x2C, 0x30, 0x66, 0x0F, 0xE2, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x08, 0xF8, 0x4C, 0x02, 0xC0, 0x38, 0x01, 0x40, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x30, 0x11,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x33, 0x01, 0x87, 0xFC, 0x00, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x3F, 0xF1, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xF0,
  0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x22, 0x00, 0x31, 0x00,
  0x19, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x98,
  0x00, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x71, 0x00, 0x78, 0xC0, 0x68,
  0x30, 0x64, 0x0F, 0xC2, 0x00, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x26, 0x00,
  0xCC, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x30, 0x40, 0x40, 0xC1, 0x01,
  0x86, 0x03, 0x08, 0x02, 0x30, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x80, 0x10, 0x07, 0x00, 0x60, 0x0A, 0x00,
  0xC0, 0x36, 0x02, 0x80, 0x4C, 0x05, 0x81, 0x98, 0x13, 0x02, 0x30, 0x66,
  0x04, 0x60, 0x84, 0x18, 0xC3, 0x08, 0x20, 0x84, 0x10, 0xC1, 0x18, 0x21,
  0x02, 0x20, 0x46, 0x04, 0xC0, 0x88, 0x09, 0x01, 0x30, 0x16, 0x02, 0x40,
  0x28, 0x07, 0x80, 0x50, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x00,
  0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x30, 0x08, 0x18, 0x03, 0x0C, 0x00,
  0x42, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x0C, 0x80, 0x06, 0x30, 0x01, 0x04, 0x00, 0x81, 0x00, 0x40, 0x60,
  0x30, 0x08, 0x18, 0x03, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x18, 0x10, 0x00,
  0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x60, 0x04,
  0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x80,
  0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x1A,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x1E, 0x00, 0xE0, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x00, 0x1F, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x07, 0x00, 0x78, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x03,
  0xE0, 0x18, 0x00, 0x7F, 0x01, 0x81, 0xC3, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 10, 12, 4, -26 },
  { 34, 22, 26, 22, 1, -26 },
  { 106, 17, 29, 20, 2, -27 },
  { 168, 23, 26, 28, 3, -26 },
  { 243, 21, 26, 24, 2, -26 },
  { 312, 3, 10, 7, 4, -26 },
  { 316, 11, 32, 9, 1, -26 },
  { 360, 10, 32, 9, -2, -26 },
  { 400, 15, 15, 19, 4, -27 },
  { 429, 16, 17, 21, 3, -21 },
  { 463, 6, 9, 7, -2, -4 },
  { 470, 9, 1, 11, 1, -10 },
  { 472, 2, 2, 8, 1, -2 },
  { 473, 16, 26, 11, -2, -26 },
  { 525, 17, 26, 20, 2, -26 },
  { 581, 9, 26, 20, 6, -26 },
  { 611, 18, 26, 20, 0, -26 },
  { 670, 18, 26, 20, 1, -26 },
  { 729, 19, 26, 20, 0, -26 },
  { 791, 18, 26, 20, 1, -26 },
  { 850, 18, 26, 20, 2, -26 },
  { 909, 16, 26, 20, 4, -26 },
  { 961, 17, 26, 20, 2, -26 },
  { 1017, 17, 26, 20, 2, -26 },
  { 1073, 6, 19, 8, 1, -19 },
  { 1088, 9, 24, 8, -2, -19 },
  { 1115, 16, 16, 21, 3, -21 },
  { 1147, 16, 9, 21, 3, -17 },
  { 1165, 16, 16, 21, 3, -21 },
  { 1197, 12, 26, 15, 3, -26 },
  { 1236, 27, 28, 30, 2, -25 },
  { 1331, 20, 26, 20, -2, -26 },
  { 1396, 19, 26, 22, 2, -26 },
  { 1458, 20, 26, 21, 3, -26 },
  { 1523, 21, 26, 24, 2, -26 },
  { 1592, 18, 26, 19, 2, -26 },
  { 1651, 18, 26, 17, 2, -26 },
  { 1710, 21, 26, 25, 3, -26 },
  { 1779, 22, 26, 25, 2, -26 },
  { 1851, 12, 26, 10, 0, -26 },
  { 1890, 15, 32, 9, -6, -26 },
  { 1950, 21, 26, 20, 2, -26 },
  { 2019, 13, 26, 18, 2, -26 },
  { 2062, 27, 26, 29, 2, -26 },
  { 2150, 22, 26, 25, 2, -26 },
  { 2222, 21, 26, 26, 3, -26 },
  { 2291, 18, 26, 20, 2, -26 },
  { 2350, 21, 32, 26, 3, -26 },
  { 2434, 18, 26, 20, 2, -26 },
  { 2493, 17, 26, 18, 1, -26 },
  { 2549, 18, 26, 18, 3, -26 },
  { 2608, 22, 26, 25, 3, -26 },
  { 2680, 18, 26, 19, 4, -26 },
  { 2739, 28, 26, 30, 4, -26 },
  { 2830, 23, 26, 18, -2, -26 },
  { 2905, 18, 26, 18, 3, -26 },
  { 2964, 21, 26, 19, 0, -26 },
  { 3033, 13, 32, 11, 0, -26 },
  { 3085, 5, 26, 11, 4, -26 },
  { 3102, 14, 32, 11, -3, -26 },
  { 3158, 16, 16, 20, 2, -26 },
  { 3190, 14, 1, 14, -3, 4 },
  { 3192, 5, 6, 9, 5, -28 },
  { 3196, 17, 19, 20, 2, -19 },
  { 3237, 18, 27, 21, 1, -27 },
  { 3298, 15, 19, 16, 2, -19 },
  { 3334, 19, 27, 21, 2, -27 },
  { 3399, 15, 19, 18, 2, -19 },
  { 3435, 20, 37, 10, -5, -28 },
  { 3528, 18, 28, 21, 1, -19 },
  { 3591, 17, 27, 20, 1, -27 },
  { 3649, 7, 26, 8, 1, -26 },
  { 3672, 13, 35, 8, -5, -26 },
  { 3729, 17, 27, 16, 1, -27 },
  { 3787, 7, 27, 8, 1, -27 },
  { 3811, 27, 19, 31, 1, -19 },
  { 3876, 17, 19, 20, 1, -19 },
  { 3917, 16, 19, 20, 2, -19 },
  { 3955, 20, 27, 21, -1, -19 },
  { 4023, 17, 27, 21, 2, -19 },
  { 4081, 13, 19, 14, 1, -19 },
  { 4112, 14, 19, 15, 0, -19 },
  { 4146, 10, 24, 11, 2, -24 },
  { 4176, 17, 19, 20, 2, -19 },
  { 4217, 15, 19, 15, 2, -19 },
  { 4253, 23, 19, 24, 2, -19 },
  { 4308, 18, 19, 17, -1, -19 },
  { 4351, 21, 28, 15, -4, -19 },
  { 4425, 17, 19, 16, -1, -19 },
  { 4466, 13, 32, 12, 1, -26 },
  { 4518, 1, 36, 19, 10, -27 },
  { 4523, 13, 32, 12, -2, -26 },
  { 4575, 16, 3, 21, 3, -14 },
};

const GFXfont NotoSans_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRALIGHTITALIC36PT7B_H_
