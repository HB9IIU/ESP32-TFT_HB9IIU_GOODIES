#ifndef _NOTOSANS_EXTRALIGHTITALIC39PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0x30, 0x90, 0x48, 0x64, 0x36, 0x12, 0x09,
  0x04, 0x86, 0x42, 0x61, 0x00, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00,
  0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20, 0x20, 0x00,
  0x60, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x1F, 0xFF, 0xFF, 0x00,
  0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x03, 0x00, 0xFF,
  0xFF, 0xF8, 0x02, 0x02, 0x00, 0x06, 0x02, 0x00, 0x04, 0x06, 0x00, 0x04,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x08,
  0x08, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x01, 0xFF, 0x80, 0xE4, 0x70, 0x61, 0x00, 0x30, 0x40, 0x18,
  0x30, 0x06, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x08, 0x60, 0x03, 0x18,
  0x00, 0x74, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x37, 0x00, 0x08, 0x60,
  0x02, 0x0C, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x04, 0x08, 0x01,
  0x06, 0x20, 0x43, 0x0F, 0x97, 0x80, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x03, 0x06, 0x30, 0x03, 0x06,
  0x08, 0x03, 0x06, 0x04, 0x01, 0x02, 0x03, 0x01, 0x83, 0x01, 0x81, 0x81,
  0x80, 0x81, 0x80, 0x80, 0x40, 0x80, 0x40, 0x20, 0xC0, 0x60, 0x10, 0xC0,
  0x30, 0x18, 0x40, 0x18, 0x08, 0x43, 0xCC, 0x04, 0x67, 0x36, 0x06, 0x66,
  0x0D, 0x06, 0x22, 0x06, 0xC6, 0x23, 0x01, 0x3E, 0x31, 0x00, 0x80, 0x30,
  0x80, 0xC0, 0x10, 0xC0, 0x60, 0x10, 0x60, 0x30, 0x18, 0x20, 0x10, 0x18,
  0x10, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x0C, 0x02, 0x02, 0x0C,
  0x01, 0x83, 0x04, 0x00, 0xC3, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00, 0x60, 0x02, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x04, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0x88, 0x00, 0x0C, 0x18, 0x03, 0x30, 0x18, 0x04, 0xC0, 0x10,
  0x1B, 0x00, 0x30, 0x26, 0x00, 0x30, 0xC8, 0x00, 0x33, 0x10, 0x00, 0x2C,
  0x20, 0x00, 0x70, 0x40, 0x00, 0xE0, 0xC0, 0x03, 0x40, 0xC0, 0x0C, 0xC1,
  0xC0, 0xE0, 0xC0, 0xFF, 0x00, 0xC0, 0x32, 0x22, 0x64, 0x44, 0x4C, 0x00,
  0x30, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x80, 0x80, 0xE0, 0x80, 0x30, 0x80, 0x0D, 0x00, 0x03, 0xFF, 0x03,
  0x00, 0x06, 0x80, 0x0C, 0x80, 0x18, 0xC0, 0x30, 0x40, 0x60, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x30, 0x86, 0x10,
  0xC2, 0x18, 0x43, 0x00, 0xFF, 0xC0, 0x5F, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x38, 0x70, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x10,
  0x00, 0x86, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x80,
  0x01, 0xB0, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x32, 0x00,
  0x06, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x10, 0x80, 0x06, 0x10, 0x00, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x60, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x32, 0x38,
  0xB8, 0x64, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x00, 0x3F, 0x80, 0x0E, 0x0C, 0x03, 0x80,
  0x60, 0x20, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x78, 0x38, 0x38, 0x01, 0x82, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x10, 0x00, 0xC3, 0x80, 0x70, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x32, 0x00,
  0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x08, 0x00, 0x10, 0x40, 0x01, 0x06,
  0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01, 0x80, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x60, 0xE0, 0x3C, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x3C, 0x10, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x8F,
  0xE0, 0x4E, 0x0C, 0x16, 0x01, 0x8F, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x01,
  0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8,
  0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x0C, 0x03, 0x03,
  0x00, 0x20, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xC0, 0x80, 0x10, 0x18, 0x0E, 0x01, 0x83, 0x00, 0x1D, 0xC0, 0x01,
  0xC0, 0x01, 0xE6, 0x00, 0xE0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00,
  0x04, 0x60, 0x00, 0x88, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x46, 0x00,
  0x18, 0xC0, 0x02, 0x0C, 0x00, 0xC0, 0xE0, 0x70, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x18, 0x00, 0xC6, 0x00,
  0x13, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x71, 0x80, 0x68, 0x30, 0x32, 0x07,
  0xF1, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1C, 0x08, 0x1C, 0x03,
  0xFE, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x0E, 0x00, 0x01, 0x80, 0x70,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xE0, 0xE1, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80,
  0x18, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x00, 0x20, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x01, 0xF0, 0x08,
  0xC0, 0x3C, 0xF0, 0x22, 0x01, 0x80, 0xC0, 0xD8, 0x0C, 0x02, 0x03, 0x60,
  0x60, 0x08, 0x0D, 0x01, 0x00, 0x60, 0x34, 0x0C, 0x01, 0x80, 0xB0, 0x20,
  0x04, 0x02, 0xC0, 0x80, 0x10, 0x1B, 0x02, 0x00, 0xC0, 0x6C, 0x08, 0x03,
  0x01, 0x30, 0x20, 0x18, 0x0C, 0xC0, 0x80, 0xE0, 0x63, 0x03, 0x06, 0xC3,
  0x04, 0x07, 0xF1, 0xB8, 0x10, 0x0F, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00,
  0xD0, 0x00, 0x06, 0x40, 0x00, 0x19, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x41, 0x80, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x03, 0x00, 0x80, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x10,
  0x20, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x09, 0x80,
  0x00, 0x26, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x18,
  0x30, 0x01, 0x81, 0x80, 0x78, 0x0F, 0xFE, 0x00, 0x40, 0x0E, 0x02, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x01,
  0x86, 0x00, 0x38, 0x30, 0x0F, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x01, 0x80, 0x40, 0x01, 0x80, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x02,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40,
  0x03, 0x81, 0x80, 0x1E, 0x03, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xE0,
  0x7C, 0x07, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x03, 0xFE, 0x60, 0x07, 0xFC, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x10, 0x30, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x38, 0x0F,
  0x80, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x03, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0x02, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x10, 0x60, 0x00, 0x21, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C,
  0x00, 0x02, 0x68, 0x00, 0x05, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x03, 0x00, 0x40, 0x02, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x03, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x02, 0x81, 0x40, 0x00,
  0x1E, 0x05, 0x80, 0x00, 0x58, 0x16, 0x00, 0x03, 0x40, 0xC8, 0x00, 0x19,
  0x03, 0x20, 0x00, 0x44, 0x0C, 0x80, 0x03, 0x30, 0x22, 0x00, 0x08, 0xC0,
  0x8C, 0x00, 0x62, 0x06, 0x30, 0x03, 0x08, 0x18, 0x40, 0x0C, 0x60, 0x41,
  0x00, 0x61, 0x81, 0x04, 0x01, 0x06, 0x04, 0x10, 0x0C, 0x10, 0x30, 0x60,
  0x20, 0x40, 0xC1, 0x81, 0x83, 0x02, 0x02, 0x0C, 0x0C, 0x08, 0x08, 0x20,
  0x30, 0x60, 0x21, 0x80, 0x81, 0x80, 0x84, 0x02, 0x06, 0x03, 0x30, 0x18,
  0x10, 0x0D, 0x80, 0x60, 0x40, 0x14, 0x01, 0x03, 0x00, 0x70, 0x04, 0x0C,
  0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x07, 0x00,
  0x01, 0x07, 0x00, 0x03, 0x05, 0x00, 0x03, 0x05, 0x80, 0x03, 0x04, 0x80,
  0x02, 0x0C, 0xC0, 0x02, 0x0C, 0x40, 0x06, 0x08, 0x60, 0x06, 0x08, 0x60,
  0x04, 0x08, 0x20, 0x04, 0x18, 0x30, 0x04, 0x18, 0x10, 0x0C, 0x10, 0x18,
  0x0C, 0x10, 0x08, 0x08, 0x10, 0x08, 0x08, 0x30, 0x0C, 0x18, 0x30, 0x04,
  0x18, 0x20, 0x06, 0x18, 0x20, 0x02, 0x10, 0x60, 0x03, 0x10, 0x60, 0x03,
  0x30, 0x60, 0x01, 0x30, 0x40, 0x01, 0xB0, 0x40, 0x00, 0xA0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x03, 0xC1,
  0xE0, 0x0E, 0x00, 0x60, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x98, 0x00, 0x01, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x1E,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x00, 0xC0,
  0x60, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00,
  0xC1, 0x80, 0x18, 0x10, 0x07, 0x01, 0xFF, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC1, 0xE0, 0x0E, 0x00, 0x60, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00,
  0x01, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x1E, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x04, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0xC1, 0x80, 0x38, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x30,
  0x18, 0x03, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x60, 0x0C, 0x06,
  0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x01, 0x0C, 0x00, 0x18, 0x00, 0xFF, 0x80, 0x78, 0x3C, 0x1C, 0x00,
  0x86, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x10, 0x01, 0x83, 0x80, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0xC0, 0x00, 0x6C, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x18, 0x40, 0x01,
  0x84, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x04, 0x06, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20,
  0x20, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x11, 0x80, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x50, 0x01, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x12,
  0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x30, 0x04, 0x40, 0x18, 0xC0,
  0x31, 0x00, 0x43, 0x00, 0x84, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x30, 0x10,
  0x40, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x40, 0x60, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x08, 0x06, 0x10,
  0x04, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x98, 0x01,
  0x30, 0x02, 0x40, 0x04, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x2C, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x03, 0x01, 0x80, 0x02, 0x01, 0x80, 0x04, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x60, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x13, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x03, 0x00, 0x03, 0x01, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x10, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x80, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x06, 0x20, 0x00, 0x86,
  0x00, 0x30, 0xC0, 0x0C, 0x08, 0x03, 0x01, 0x00, 0x40, 0x30, 0x18, 0x06,
  0x06, 0x00, 0x40, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x13, 0x00, 0x02,
  0x40, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0x03,
  0xF8, 0x00, 0x83, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x60, 0x82, 0x08, 0x20,
  0xC3, 0x04, 0x10, 0x41, 0x06, 0x18, 0x20, 0x82, 0x0C, 0x30, 0x41, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x01, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x01, 0x30,
  0x00, 0xC4, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x01,
  0x80, 0x80, 0xC0, 0x30, 0x20, 0x04, 0x18, 0x01, 0x0C, 0x00, 0x62, 0x00,
  0x09, 0x80, 0x02, 0xC0, 0x00, 0xC0, 0xFF, 0xFE, 0x8C, 0x46, 0x31, 0x01,
  0xF8, 0x40, 0xE7, 0x10, 0xE0, 0x2C, 0x60, 0x0B, 0x18, 0x01, 0x8C, 0x00,
  0x62, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x90, 0x00, 0x4C, 0x00, 0x13,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0E, 0x30, 0x05, 0x86, 0x02, 0x41, 0xC3, 0x10, 0x1F, 0x84, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x87, 0xE0, 0x33,
  0x8E, 0x06, 0xC0, 0x60, 0xB0, 0x04, 0x14, 0x00, 0xC7, 0x00, 0x18, 0xC0,
  0x01, 0x18, 0x00, 0x23, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x8E, 0x00,
  0x31, 0x40, 0x0C, 0x2C, 0x03, 0x04, 0xC1, 0xC1, 0x8F, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0x87, 0x0E, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x18, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x0F, 0xC3, 0x00, 0xE3, 0x98, 0x1C, 0x06,
  0x81, 0x80, 0x14, 0x08, 0x00, 0xA0, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60,
  0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10,
  0x60, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00,
  0x70, 0x30, 0x06, 0x80, 0xC0, 0x64, 0x07, 0x06, 0x60, 0x0F, 0xC3, 0x00,
  0x00, 0xFC, 0x03, 0x8E, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x30, 0x03,
  0x20, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x40, 0xF8, 0x7F, 0xC0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x18, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x10, 0x1C, 0x73, 0x07, 0x01, 0xA0, 0xC0, 0x0A, 0x0C,
  0x00, 0xA1, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0xC2,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0xD0, 0x30, 0x19,
  0x03, 0x83, 0x30, 0x0F, 0xC3, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x70, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x0F, 0xC0, 0xC7, 0x38, 0x36, 0x03, 0x0B, 0x00, 0x42, 0x80, 0x11,
  0xC0, 0x04, 0x60, 0x01, 0x18, 0x00, 0x46, 0x00, 0x31, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x44, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x80,
  0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C,
  0x08, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x40, 0x04,
  0x20, 0x01, 0x38, 0x00, 0xDA, 0x00, 0x3C, 0xC0, 0x0E, 0x10, 0x03, 0x06,
  0x00, 0x80, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x01, 0x81, 0x00, 0x60,
  0x40, 0x0C, 0x30, 0x03, 0x00, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x04,
  0x3E, 0x03, 0xE0, 0x33, 0x9C, 0x38, 0xE0, 0x98, 0x19, 0x81, 0x82, 0xC0,
  0x64, 0x03, 0x0A, 0x00, 0xA0, 0x0C, 0x70, 0x03, 0x00, 0x31, 0x80, 0x0C,
  0x00, 0xC6, 0x00, 0x20, 0x03, 0x18, 0x01, 0x80, 0x08, 0x40, 0x06, 0x00,
  0x23, 0x00, 0x10, 0x01, 0x8C, 0x00, 0x40, 0x06, 0x30, 0x03, 0x00, 0x10,
  0x80, 0x0C, 0x00, 0x42, 0x00, 0x30, 0x01, 0x18, 0x00, 0x80, 0x0C, 0x60,
  0x02, 0x00, 0x31, 0x00, 0x18, 0x00, 0x84, 0x00, 0x60, 0x02, 0x10, 0x01,
  0x00, 0x18, 0xC0, 0x04, 0x00, 0x60, 0x04, 0x3F, 0x01, 0x9E, 0x70, 0x26,
  0x03, 0x05, 0x80, 0x20, 0xA0, 0x04, 0x38, 0x00, 0xC6, 0x00, 0x10, 0xC0,
  0x02, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43, 0x00,
  0x08, 0x40, 0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00,
  0x21, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x20, 0x00, 0xFC, 0x00, 0xE3,
  0x80, 0xE0, 0x30, 0x60, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x18, 0x01,
  0x86, 0x00, 0xC0, 0xE0, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0x0F, 0xC0, 0x18,
  0xC7, 0x00, 0x98, 0x0C, 0x05, 0x80, 0x20, 0x28, 0x01, 0x83, 0x80, 0x0C,
  0x1C, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC3,
  0x00, 0x04, 0x1C, 0x00, 0x60, 0xA0, 0x06, 0x05, 0x80, 0x60, 0x26, 0x0E,
  0x03, 0x1F, 0xE0, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xF8, 0x20, 0x71, 0xCC, 0x38, 0x0D, 0x0C, 0x00,
  0xA1, 0x80, 0x14, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x03, 0x41, 0x80, 0xC8,
  0x38, 0x33, 0x01, 0xF8, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x3E, 0x19, 0xE8, 0x26, 0x00, 0x58, 0x00, 0xA0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x07, 0x1F, 0x0C,
  0x01, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x80, 0x18, 0xE0, 0x70, 0x3F,
  0xE0, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0xFF, 0xFF, 0xF8, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F,
  0xC0, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x98, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0A, 0x30, 0x07, 0x8C, 0x03, 0x61, 0x83, 0x90, 0x3F, 0x84,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x0C, 0x40,
  0x08, 0x40, 0x18, 0x40, 0x10, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x20,
  0xC0, 0x20, 0x80, 0x21, 0x80, 0x21, 0x00, 0x33, 0x00, 0x32, 0x00, 0x36,
  0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0xE0, 0x0C,
  0x00, 0xF0, 0x06, 0x00, 0x58, 0x07, 0x80, 0x6C, 0x02, 0xC0, 0x26, 0x03,
  0x60, 0x33, 0x01, 0x10, 0x10, 0x81, 0x88, 0x18, 0x40, 0x84, 0x08, 0x20,
  0xC2, 0x0C, 0x10, 0x41, 0x04, 0x08, 0x60, 0x86, 0x04, 0x20, 0x42, 0x02,
  0x30, 0x33, 0x01, 0x10, 0x19, 0x80, 0x98, 0x0D, 0x80, 0x48, 0x06, 0xC0,
  0x2C, 0x01, 0x40, 0x14, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0xC0, 0x20, 0x18, 0x03,
  0x03, 0x00, 0x10, 0x60, 0x01, 0x8C, 0x00, 0x08, 0x80, 0x00, 0xD0, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x31, 0x00,
  0x06, 0x18, 0x00, 0xC0, 0x80, 0x08, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x06,
  0x06, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x08, 0x18,
  0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00,
  0x33, 0x00, 0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x05, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0,
  0x07, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x38, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x1F, 0xE0, 0x1C, 0x0E, 0x1E, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 28, 9, 1, -28 },
  { 29, 9, 10, 13, 4, -28 },
  { 41, 24, 28, 24, 1, -28 },
  { 125, 18, 32, 21, 2, -30 },
  { 197, 25, 28, 30, 3, -28 },
  { 285, 23, 28, 27, 2, -28 },
  { 366, 4, 10, 7, 4, -28 },
  { 371, 12, 34, 10, 1, -28 },
  { 422, 12, 34, 10, -3, -28 },
  { 473, 16, 17, 21, 5, -30 },
  { 507, 18, 18, 22, 3, -23 },
  { 548, 6, 10, 8, -2, -5 },
  { 556, 10, 1, 12, 1, -11 },
  { 558, 3, 3, 9, 1, -3 },
  { 560, 18, 28, 12, -2, -28 },
  { 623, 19, 28, 21, 2, -28 },
  { 690, 10, 28, 21, 6, -28 },
  { 725, 20, 28, 21, 0, -28 },
  { 795, 19, 28, 21, 1, -28 },
  { 862, 21, 28, 21, 0, -28 },
  { 936, 20, 28, 21, 1, -28 },
  { 1006, 18, 28, 21, 3, -28 },
  { 1069, 18, 28, 21, 4, -28 },
  { 1132, 19, 28, 21, 2, -28 },
  { 1199, 18, 28, 21, 2, -28 },
  { 1262, 7, 21, 9, 1, -21 },
  { 1281, 10, 26, 9, -2, -21 },
  { 1314, 18, 18, 22, 3, -23 },
  { 1355, 18, 9, 22, 3, -18 },
  { 1376, 18, 18, 22, 3, -23 },
  { 1417, 14, 28, 16, 3, -28 },
  { 1466, 30, 32, 33, 2, -28 },
  { 1586, 22, 28, 21, -2, -28 },
  { 1663, 21, 28, 23, 2, -28 },
  { 1737, 22, 28, 23, 3, -28 },
  { 1814, 23, 28, 26, 2, -28 },
  { 1895, 20, 28, 21, 2, -28 },
  { 1965, 20, 28, 19, 2, -28 },
  { 2035, 23, 28, 27, 3, -28 },
  { 2116, 24, 28, 27, 2, -28 },
  { 2200, 13, 28, 11, 0, -28 },
  { 2246, 16, 35, 9, -7, -28 },
  { 2316, 23, 28, 21, 2, -28 },
  { 2397, 14, 28, 19, 2, -28 },
  { 2446, 30, 28, 32, 2, -28 },
  { 2551, 24, 28, 27, 2, -28 },
  { 2635, 23, 28, 28, 3, -28 },
  { 2716, 20, 28, 22, 2, -28 },
  { 2786, 23, 35, 28, 3, -28 },
  { 2887, 20, 28, 22, 2, -28 },
  { 2957, 19, 28, 19, 1, -28 },
  { 3024, 19, 28, 19, 4, -28 },
  { 3091, 24, 28, 27, 3, -28 },
  { 3175, 20, 28, 21, 4, -28 },
  { 3245, 30, 28, 32, 5, -28 },
  { 3350, 24, 28, 19, -2, -28 },
  { 3434, 19, 28, 19, 4, -28 },
  { 3501, 22, 28, 21, 0, -28 },
  { 3578, 14, 34, 12, 0, -28 },
  { 3638, 6, 28, 12, 4, -28 },
  { 3659, 15, 34, 12, -3, -28 },
  { 3723, 18, 17, 22, 2, -28 },
  { 3762, 15, 1, 15, -3, 4 },
  { 3764, 4, 6, 9, 6, -30 },
  { 3767, 18, 21, 21, 2, -21 },
  { 3815, 19, 30, 22, 1, -30 },
  { 3887, 16, 21, 18, 2, -21 },
  { 3929, 21, 30, 22, 2, -30 },
  { 4008, 16, 21, 19, 2, -21 },
  { 4050, 21, 39, 11, -5, -30 },
  { 4153, 20, 30, 22, 1, -21 },
  { 4228, 18, 30, 22, 1, -30 },
  { 4296, 8, 28, 8, 1, -28 },
  { 4324, 14, 37, 8, -5, -28 },
  { 4389, 18, 30, 18, 1, -30 },
  { 4457, 8, 30, 8, 1, -30 },
  { 4487, 30, 21, 33, 1, -21 },
  { 4566, 19, 21, 22, 1, -21 },
  { 4616, 18, 21, 22, 2, -21 },
  { 4664, 21, 30, 22, -1, -21 },
  { 4743, 19, 30, 22, 2, -21 },
  { 4815, 15, 21, 15, 1, -21 },
  { 4855, 16, 21, 17, 0, -21 },
  { 4897, 11, 26, 12, 2, -26 },
  { 4933, 18, 21, 22, 2, -21 },
  { 4981, 16, 21, 16, 2, -21 },
  { 5023, 25, 21, 26, 2, -21 },
  { 5089, 20, 21, 18, -1, -21 },
  { 5142, 22, 30, 16, -4, -21 },
  { 5225, 18, 21, 17, -1, -21 },
  { 5273, 14, 34, 13, 1, -28 },
  { 5333, 1, 39, 21, 11, -30 },
  { 5338, 14, 34, 13, -2, -28 },
  { 5398, 18, 4, 22, 3, -16 },
};

const GFXfont NotoSans_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRALIGHTITALIC39PT7B_H_
