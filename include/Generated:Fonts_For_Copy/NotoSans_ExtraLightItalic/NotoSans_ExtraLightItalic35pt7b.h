#ifndef _NOTOSANS_EXTRALIGHTITALIC35PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x20, 0x40, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x63,
  0x63, 0x42, 0x42, 0x42, 0xC2, 0x86, 0x84, 0x84, 0x00, 0x20, 0x60, 0x03,
  0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x60, 0x40,
  0x02, 0x06, 0x00, 0x10, 0x20, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40,
  0xC0, 0x02, 0x04, 0x00, 0x20, 0x20, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00,
  0xC0, 0x80, 0xFF, 0xFF, 0xE0, 0x20, 0x60, 0x01, 0x02, 0x00, 0x10, 0x10,
  0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x70, 0x03, 0xFF,
  0x0C, 0x21, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0,
  0x18, 0x80, 0x0C, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0x18,
  0x01, 0x0C, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x18,
  0xC2, 0x70, 0xFF, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0F, 0x80, 0x18, 0x43, 0x00, 0x42, 0x04, 0x02, 0x18, 0x10, 0x10, 0x40,
  0x40, 0xC1, 0x01, 0x02, 0x0C, 0x04, 0x10, 0x30, 0x30, 0x80, 0x80, 0xC6,
  0x02, 0x02, 0x10, 0x08, 0x08, 0x8F, 0xA0, 0x46, 0x63, 0xC1, 0x33, 0x07,
  0x08, 0x88, 0x17, 0xC4, 0x40, 0x40, 0x31, 0x01, 0x01, 0x84, 0x04, 0x04,
  0x30, 0x10, 0x20, 0x80, 0xC1, 0x82, 0x02, 0x0C, 0x08, 0x08, 0x20, 0x20,
  0x61, 0x00, 0xC1, 0x0C, 0x01, 0x08, 0x60, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x18, 0x60, 0x02, 0x03, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x60, 0x20, 0x02, 0x0C, 0x00, 0x31, 0x80, 0x01, 0x60,
  0x00, 0x38, 0x00, 0x06, 0xC0, 0x01, 0x84, 0x01, 0x20, 0x20, 0x14, 0x03,
  0x02, 0xC0, 0x18, 0x68, 0x00, 0x84, 0x80, 0x0C, 0x88, 0x00, 0x78, 0x80,
  0x03, 0x08, 0x00, 0x70, 0xC0, 0x19, 0x86, 0x03, 0x0C, 0x3F, 0xC0, 0x60,
  0x6D, 0x25, 0xA4, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x18, 0x0E, 0x20, 0x06, 0x40, 0x03,
  0xBF, 0x03, 0x80, 0x0A, 0x00, 0x22, 0x00, 0x84, 0x06, 0x04, 0x04, 0x08,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0C,
  0x61, 0x84, 0x30, 0x86, 0x10, 0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01,
  0xFC, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x80, 0x21, 0x80, 0x10, 0x80, 0x08,
  0xC0, 0x06, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x02, 0x60,
  0x03, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0x82, 0x00, 0xC1, 0x80, 0xC0,
  0x60, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0x83, 0x87, 0x46, 0x6E, 0x34, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0xFF,
  0x00, 0xE0, 0x60, 0x20, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0x81, 0x83,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x22, 0x00, 0x31, 0x80, 0x70, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00,
  0xC8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03, 0x08, 0x00, 0x41, 0x00, 0x10,
  0x20, 0x04, 0x0C, 0x01, 0x01, 0x00, 0x60, 0x20, 0x18, 0x04, 0x06, 0x01,
  0x81, 0x80, 0x30, 0x60, 0x04, 0x0F, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0xFF, 0x00, 0x70, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x08, 0x00, 0x83, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0xFE, 0x0D, 0x81, 0x85,
  0x00, 0x63, 0x00, 0x11, 0x80, 0x09, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x01,
  0x30, 0x01, 0x98, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x80, 0x60, 0x60,
  0x60, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0x83, 0x01, 0x00,
  0xC1, 0x00, 0x20, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x04, 0x10, 0x06, 0x0C,
  0x02, 0x02, 0x06, 0x00, 0xC6, 0x00, 0x3C, 0x00, 0x76, 0x00, 0xE1, 0x80,
  0xC0, 0x20, 0xC0, 0x18, 0xC0, 0x04, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00,
  0xC8, 0x00, 0x44, 0x00, 0x63, 0x00, 0x60, 0xE0, 0x60, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x06, 0x0C, 0x0C, 0x02, 0x18, 0x03, 0x30, 0x01, 0x30, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x60, 0x01, 0x60, 0x03, 0x20, 0x07,
  0x30, 0x0F, 0x18, 0x1A, 0x0F, 0xE2, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x81, 0x80,
  0xFF, 0x00, 0x08, 0x70, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x01, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x3F, 0xC6, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x0C, 0xC0, 0x1F, 0x01, 0x20, 0x1C, 0x70, 0x58,
  0x08, 0x08, 0x14, 0x04, 0x02, 0x05, 0x02, 0x01, 0x81, 0xC1, 0x80, 0x40,
  0x60, 0x40, 0x10, 0x18, 0x10, 0x0C, 0x06, 0x04, 0x03, 0x03, 0x81, 0x00,
  0x80, 0xA0, 0x40, 0x60, 0x68, 0x10, 0x38, 0x33, 0x06, 0x1B, 0x18, 0xC0,
  0xFC, 0x7C, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00,
  0x09, 0x80, 0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80,
  0x06, 0x08, 0x00, 0x40, 0x80, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x04,
  0x03, 0x00, 0x40, 0x3F, 0xFC, 0x06, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00,
  0x61, 0x80, 0x06, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00,
  0x02, 0xC0, 0x00, 0x30, 0x07, 0xFE, 0x01, 0x00, 0xE0, 0xC0, 0x0C, 0x30,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00,
  0xC4, 0x00, 0x61, 0x00, 0x30, 0x7F, 0xF0, 0x30, 0x7C, 0x0C, 0x01, 0x82,
  0x00, 0x30, 0x80, 0x04, 0x60, 0x01, 0x98, 0x00, 0x64, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0xE0, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x38, 0x0C, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x40, 0xF0, 0x0C, 0x01, 0xC0, 0xC0, 0x06, 0x08,
  0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x01, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x03,
  0x20, 0x00, 0x32, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x03, 0x8C, 0x00, 0x60, 0xC0, 0x1C, 0x08, 0x0F,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x1C, 0x07, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0xFE, 0x80, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08,
  0x40, 0x00, 0x86, 0x00, 0x18, 0x30, 0x01, 0x81, 0xC0, 0x70, 0x0F, 0xFC,
  0x00, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x02,
  0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0x80, 0x01, 0x06, 0x00, 0x04, 0x18,
  0x00, 0x10, 0x40, 0x00, 0xC1, 0x00, 0x03, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41,
  0x80, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0x83, 0x00,
  0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x80, 0x07, 0xF0,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x40, 0x06,
  0x0C, 0x00, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x18,
  0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11, 0x00, 0x01, 0x78,
  0x00, 0x3C, 0x80, 0x03, 0x8C, 0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x60,
  0x20, 0x06, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x40, 0x18, 0x0C,
  0x00, 0x80, 0xC0, 0x0C, 0x08, 0x00, 0x40, 0x80, 0x06, 0x00, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x0B, 0x00, 0x02, 0x82, 0x40, 0x01, 0x20, 0x90, 0x00, 0xC8, 0x64,
  0x00, 0x26, 0x19, 0x00, 0x19, 0x84, 0x40, 0x04, 0x41, 0x18, 0x02, 0x10,
  0x42, 0x01, 0x84, 0x30, 0x80, 0x43, 0x08, 0x20, 0x30, 0xC2, 0x08, 0x08,
  0x20, 0x82, 0x04, 0x08, 0x60, 0xC3, 0x06, 0x18, 0x10, 0x81, 0x84, 0x04,
  0x60, 0x41, 0x01, 0x10, 0x10, 0x40, 0x4C, 0x04, 0x30, 0x12, 0x03, 0x0C,
  0x07, 0x00, 0xC2, 0x00, 0xC0, 0x20, 0x80, 0x20, 0x08, 0x00, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x20, 0xE0, 0x00, 0x82, 0xC0, 0x02, 0x09, 0x00, 0x18,
  0x24, 0x00, 0x60, 0x98, 0x01, 0x06, 0x20, 0x04, 0x18, 0xC0, 0x10, 0x41,
  0x00, 0xC1, 0x06, 0x03, 0x04, 0x08, 0x08, 0x30, 0x20, 0x20, 0x80, 0xC0,
  0x82, 0x01, 0x06, 0x08, 0x06, 0x10, 0x60, 0x08, 0x41, 0x80, 0x21, 0x04,
  0x00, 0x4C, 0x10, 0x01, 0x30, 0x40, 0x06, 0x83, 0x00, 0x0A, 0x0C, 0x00,
  0x38, 0x20, 0x00, 0x60, 0x80, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x1C, 0x0E,
  0x01, 0x80, 0x18, 0x10, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00,
  0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x00, 0x84,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x01, 0xC0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x01, 0x03, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x18, 0x40, 0x0C, 0x30, 0x0E, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1C, 0x0E, 0x01, 0x80, 0x18, 0x10, 0x00, 0x41, 0x80, 0x03, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00,
  0x00, 0x50, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0x30, 0x00, 0x19,
  0x80, 0x00, 0x84, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x01,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x01, 0x03,
  0xC0, 0xC0, 0x18, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x30, 0x80, 0x0C,
  0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x18, 0x30,
  0x3C, 0x0F, 0xFC, 0x02, 0x02, 0x00, 0x80, 0x80, 0x60, 0x30, 0x18, 0x04,
  0x04, 0x01, 0x81, 0x00, 0x60, 0x40, 0x08, 0x30, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x10, 0x80, 0x06, 0x00, 0x01, 0xFF, 0x03, 0x80, 0xC3, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x61, 0x80, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00,
  0xC4, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x0C, 0x00, 0x10,
  0x20, 0x01, 0x81, 0x80, 0x18, 0x06, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x01,
  0x8C, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08, 0x10, 0x04, 0x04, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x18, 0x10, 0x06, 0x0C, 0x00, 0x82, 0x00, 0x21,
  0x80, 0x08, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x24, 0x00, 0x0B, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x06, 0xC0, 0x0A, 0x00, 0x4C, 0x00, 0xA0, 0x04, 0xC0, 0x12,
  0x00, 0xCC, 0x01, 0x20, 0x08, 0x40, 0x32, 0x01, 0x84, 0x02, 0x20, 0x10,
  0x40, 0x62, 0x03, 0x04, 0x04, 0x20, 0x20, 0x40, 0xC2, 0x06, 0x04, 0x08,
  0x20, 0x40, 0x41, 0x82, 0x0C, 0x04, 0x10, 0x20, 0x80, 0x43, 0x03, 0x08,
  0x04, 0x20, 0x31, 0x80, 0x46, 0x03, 0x10, 0x04, 0x40, 0x33, 0x00, 0x4C,
  0x01, 0x20, 0x04, 0x80, 0x16, 0x00, 0x58, 0x01, 0x40, 0x05, 0x00, 0x1C,
  0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x10, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x80, 0x40, 0x03, 0x03, 0x00, 0x04, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x62,
  0x00, 0x00, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x23, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x60, 0x03, 0x00, 0x80, 0x08, 0x03, 0x00, 0x40, 0x04,
  0x03, 0x00, 0x10, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0xA0,
  0x00, 0x90, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x40, 0xC0, 0x60,
  0x20, 0x60, 0x10, 0x20, 0x08, 0x30, 0x06, 0x30, 0x01, 0x10, 0x00, 0x90,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xC1, 0x04, 0x10,
  0x41, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82,
  0x08, 0x20, 0xC1, 0x04, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xD0, 0x01, 0x90, 0x01, 0x10, 0x03, 0x08, 0x06,
  0x08, 0x04, 0x08, 0x0C, 0x0C, 0x18, 0x04, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0xFF, 0xF8, 0xC4, 0x62, 0x11, 0x01, 0xE1,
  0x07, 0x39, 0x0C, 0x09, 0x10, 0x07, 0x30, 0x06, 0x60, 0x06, 0x40, 0x06,
  0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x18, 0x80, 0x18, 0xC0, 0x28, 0xC0, 0x48, 0x61, 0x98, 0x3F, 0x10,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x7C, 0x04, 0x77, 0x02, 0xC0, 0xC3,
  0xC0, 0x31, 0x40, 0x18, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x30, 0x00,
  0x90, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x26, 0x00, 0x13, 0x00, 0x19, 0x80,
  0x08, 0xC0, 0x0C, 0x50, 0x0C, 0x6C, 0x1C, 0x23, 0xF8, 0x00, 0x01, 0xF8,
  0x1C, 0x70, 0xC0, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x01, 0xE1, 0x81, 0xCE, 0x40, 0xC0, 0xD0, 0x40, 0x14, 0x30,
  0x03, 0x18, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x00,
  0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0xC3,
  0x00, 0xF0, 0xC0, 0x68, 0x18, 0x32, 0x03, 0xF0, 0x80, 0x01, 0xF0, 0x1C,
  0x60, 0xC0, 0xC6, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00, 0xD0, 0x06, 0xC0,
  0xF3, 0xFE, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x40, 0xE7, 0x30,
  0x60, 0x68, 0x20, 0x0A, 0x18, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x10, 0x80,
  0x04, 0x60, 0x01, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x08, 0x40, 0x06,
  0x10, 0x01, 0x84, 0x00, 0xE1, 0x80, 0x78, 0x60, 0x34, 0x0C, 0x19, 0x01,
  0xF8, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x20, 0x18, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x7C, 0x08, 0xC6, 0x0B, 0x03, 0x1E, 0x01, 0x14, 0x01, 0x18, 0x01,
  0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02,
  0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0xF8, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x03,
  0x08, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x10, 0x60, 0x10, 0xC0,
  0x11, 0x80, 0x33, 0x00, 0x25, 0x00, 0x29, 0x80, 0x30, 0x80, 0x60, 0xC0,
  0x60, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x10, 0xC0, 0x18,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x00,
  0x08, 0x78, 0x0F, 0x01, 0x39, 0x87, 0x38, 0x2C, 0x19, 0x81, 0x0F, 0x01,
  0x60, 0x31, 0x40, 0x28, 0x06, 0x30, 0x06, 0x00, 0xC4, 0x00, 0xC0, 0x10,
  0x80, 0x10, 0x02, 0x30, 0x06, 0x00, 0x44, 0x00, 0xC0, 0x08, 0x80, 0x10,
  0x03, 0x10, 0x02, 0x00, 0x46, 0x00, 0x40, 0x08, 0xC0, 0x18, 0x01, 0x10,
  0x03, 0x00, 0x62, 0x00, 0x40, 0x0C, 0x40, 0x08, 0x01, 0x18, 0x01, 0x00,
  0x23, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x7C, 0x04, 0x77, 0x02, 0xC0, 0xC3,
  0xC0, 0x21, 0x40, 0x18, 0xC0, 0x08, 0x60, 0x04, 0x60, 0x02, 0x30, 0x03,
  0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x31, 0x00,
  0x18, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x30, 0x03, 0x00, 0x01, 0xF0,
  0x07, 0x1C, 0x0C, 0x06, 0x10, 0x02, 0x20, 0x03, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x60, 0x18, 0x30, 0x70, 0x1F, 0xC0,
  0x02, 0x1F, 0x00, 0x47, 0x70, 0x0B, 0x03, 0x03, 0xC0, 0x30, 0x50, 0x06,
  0x0C, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x0C,
  0x20, 0x01, 0x84, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x20,
  0xC0, 0x0C, 0x14, 0x03, 0x06, 0xC1, 0xC0, 0xCF, 0xE0, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x83, 0x9C, 0xC3, 0x03, 0x42,
  0x00, 0xA3, 0x00, 0x33, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x02,
  0x60, 0x03, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x71, 0x80, 0x78, 0xC0, 0x68, 0x30, 0x64, 0x0F, 0xC2, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x78, 0x4E, 0x42, 0xC0, 0x3C, 0x01, 0x40, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x03, 0xF0,
  0x38, 0xF1, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x33, 0x01, 0x87, 0xFC, 0x00, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x3F, 0xFF, 0xF3, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07,
  0xC0, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20,
  0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0xC0,
  0x0C, 0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x28, 0xC0, 0x68, 0x60,
  0xC8, 0x3F, 0x18, 0x80, 0x06, 0x00, 0x38, 0x00, 0xB0, 0x06, 0xC0, 0x13,
  0x00, 0xC4, 0x02, 0x10, 0x10, 0x40, 0xC1, 0x02, 0x06, 0x18, 0x18, 0x40,
  0x23, 0x00, 0x88, 0x02, 0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0xD0, 0x1B, 0x02, 0x40, 0x4C, 0x19, 0x03, 0x30, 0x44, 0x08, 0xC3,
  0x18, 0x63, 0x08, 0x61, 0x0C, 0x61, 0x8C, 0x11, 0x02, 0x20, 0x4C, 0x09,
  0x81, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x70, 0x0A, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC3, 0x00, 0x60, 0x40,
  0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0xC2, 0x00, 0x11, 0x00, 0x06, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x06, 0x20, 0x01,
  0x0C, 0x00, 0x81, 0x00, 0x40, 0x60, 0x30, 0x08, 0x18, 0x02, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x30, 0x06, 0x03,
  0x00, 0x40, 0x10, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x01, 0x00,
  0x18, 0x20, 0x01, 0x86, 0x00, 0x08, 0x40, 0x00, 0x8C, 0x00, 0x08, 0x80,
  0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x7E, 0x01, 0xC3, 0x83,
  0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 25, 8, 1, -25 },
  { 23, 8, 9, 11, 4, -25 },
  { 32, 21, 25, 22, 1, -25 },
  { 98, 16, 29, 19, 2, -27 },
  { 156, 22, 25, 27, 3, -25 },
  { 225, 20, 25, 24, 2, -25 },
  { 288, 3, 9, 6, 4, -25 },
  { 292, 10, 31, 9, 1, -25 },
  { 331, 10, 31, 9, -2, -25 },
  { 370, 15, 15, 19, 4, -27 },
  { 399, 16, 16, 20, 3, -20 },
  { 431, 6, 9, 7, -2, -4 },
  { 438, 9, 1, 11, 1, -10 },
  { 440, 2, 2, 8, 1, -2 },
  { 441, 16, 25, 11, -2, -25 },
  { 491, 17, 25, 19, 2, -25 },
  { 545, 9, 25, 19, 6, -25 },
  { 574, 18, 25, 19, 0, -25 },
  { 631, 17, 25, 19, 1, -25 },
  { 685, 19, 25, 19, 0, -25 },
  { 745, 18, 25, 19, 1, -25 },
  { 802, 17, 25, 19, 2, -25 },
  { 856, 16, 25, 19, 4, -25 },
  { 906, 17, 25, 19, 2, -25 },
  { 960, 16, 25, 19, 2, -25 },
  { 1010, 6, 19, 8, 1, -19 },
  { 1025, 9, 24, 8, -2, -19 },
  { 1052, 16, 16, 20, 3, -21 },
  { 1084, 16, 8, 20, 3, -16 },
  { 1100, 16, 16, 20, 3, -21 },
  { 1132, 12, 25, 14, 3, -25 },
  { 1170, 26, 28, 29, 2, -25 },
  { 1261, 20, 25, 19, -2, -25 },
  { 1324, 18, 25, 21, 2, -25 },
  { 1381, 19, 25, 21, 3, -25 },
  { 1441, 20, 25, 24, 2, -25 },
  { 1504, 18, 25, 19, 2, -25 },
  { 1561, 18, 25, 17, 2, -25 },
  { 1618, 20, 25, 24, 3, -25 },
  { 1681, 22, 25, 24, 2, -25 },
  { 1750, 12, 25, 10, 0, -25 },
  { 1788, 14, 31, 8, -6, -25 },
  { 1843, 20, 25, 19, 2, -25 },
  { 1906, 12, 25, 17, 2, -25 },
  { 1944, 26, 25, 28, 2, -25 },
  { 2026, 22, 25, 24, 2, -25 },
  { 2095, 21, 25, 25, 3, -25 },
  { 2161, 18, 25, 20, 2, -25 },
  { 2218, 21, 31, 25, 3, -25 },
  { 2300, 18, 25, 20, 2, -25 },
  { 2357, 17, 25, 17, 1, -25 },
  { 2411, 17, 25, 17, 3, -25 },
  { 2465, 21, 25, 24, 3, -25 },
  { 2531, 18, 25, 19, 4, -25 },
  { 2588, 28, 25, 29, 4, -25 },
  { 2676, 22, 25, 17, -2, -25 },
  { 2745, 17, 25, 17, 3, -25 },
  { 2799, 20, 25, 19, 0, -25 },
  { 2862, 13, 31, 11, 0, -25 },
  { 2913, 6, 25, 11, 3, -25 },
  { 2932, 14, 31, 11, -3, -25 },
  { 2987, 16, 15, 19, 2, -25 },
  { 3017, 13, 1, 13, -3, 4 },
  { 3019, 4, 6, 8, 5, -27 },
  { 3022, 16, 19, 19, 2, -19 },
  { 3060, 17, 27, 20, 1, -27 },
  { 3118, 14, 19, 16, 2, -19 },
  { 3152, 18, 27, 20, 2, -27 },
  { 3213, 14, 19, 17, 2, -19 },
  { 3247, 19, 35, 10, -4, -27 },
  { 3331, 18, 27, 20, 1, -19 },
  { 3392, 16, 27, 20, 1, -27 },
  { 3446, 7, 25, 8, 1, -25 },
  { 3468, 13, 33, 8, -5, -25 },
  { 3522, 16, 27, 16, 1, -27 },
  { 3576, 7, 27, 8, 1, -27 },
  { 3600, 27, 19, 30, 1, -19 },
  { 3665, 17, 19, 20, 1, -19 },
  { 3706, 16, 19, 20, 2, -19 },
  { 3744, 19, 27, 20, -1, -19 },
  { 3809, 17, 27, 20, 2, -19 },
  { 3867, 13, 19, 13, 1, -19 },
  { 3898, 14, 19, 15, 0, -19 },
  { 3932, 10, 23, 11, 2, -23 },
  { 3961, 16, 19, 20, 2, -19 },
  { 3999, 14, 19, 15, 2, -19 },
  { 4033, 22, 19, 23, 2, -19 },
  { 4086, 18, 19, 16, -1, -19 },
  { 4129, 20, 27, 15, -4, -19 },
  { 4197, 15, 19, 15, 0, -19 },
  { 4233, 13, 31, 12, 1, -25 },
  { 4284, 1, 35, 19, 10, -27 },
  { 4289, 13, 31, 12, -2, -25 },
  { 4340, 16, 3, 20, 3, -14 },
};

const GFXfont NotoSans_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRALIGHTITALIC35PT7B_H_
