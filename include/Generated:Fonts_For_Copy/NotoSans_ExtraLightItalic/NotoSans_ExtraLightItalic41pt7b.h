#ifndef _NOTOSANS_EXTRALIGHTITALIC41PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x61, 0xB0, 0xD8, 0x48, 0x24, 0x36,
  0x1B, 0x09, 0x04, 0x82, 0x43, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04,
  0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x0F, 0xFF,
  0xFF, 0xC0, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x80, 0xC0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x20, 0x10, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x08, 0x04, 0x00, 0x04, 0x06, 0x00,
  0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x1F,
  0xFE, 0x06, 0x10, 0xC1, 0x86, 0x00, 0x60, 0xC0, 0x08, 0x10, 0x03, 0x02,
  0x00, 0x60, 0x40, 0x04, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x01, 0xC8,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0B, 0x80, 0x01, 0x1C, 0x00, 0x21,
  0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x83,
  0x00, 0x30, 0xC2, 0x04, 0x30, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x60, 0xC3, 0x00, 0x30, 0x60, 0xC0, 0x18, 0x30, 0x10, 0x04,
  0x08, 0x04, 0x03, 0x02, 0x01, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x60, 0x10,
  0x20, 0x10, 0x0C, 0x18, 0x04, 0x03, 0x0C, 0x01, 0x00, 0x82, 0x00, 0xC0,
  0x21, 0x0F, 0x30, 0x18, 0xC7, 0xE4, 0x04, 0x63, 0x0D, 0x03, 0x11, 0x81,
  0x61, 0x88, 0xC0, 0x4F, 0xC6, 0x30, 0x10, 0xC3, 0x08, 0x04, 0x00, 0x86,
  0x01, 0x00, 0x61, 0x80, 0x40, 0x30, 0x40, 0x30, 0x18, 0x10, 0x0C, 0x04,
  0x04, 0x03, 0x03, 0x01, 0x00, 0x81, 0x80, 0x40, 0x60, 0xC0, 0x10, 0x10,
  0x20, 0x06, 0x0C, 0x18, 0x01, 0x86, 0x0C, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x00,
  0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x83, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x10,
  0x01, 0x18, 0x18, 0x03, 0x30, 0x0C, 0x02, 0x60, 0x06, 0x06, 0xC0, 0x02,
  0x0C, 0xC0, 0x03, 0x08, 0x80, 0x01, 0x98, 0x80, 0x00, 0xB0, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xB0, 0x60, 0x07, 0x10, 0x38, 0x1C,
  0x18, 0x1F, 0xF0, 0x0C, 0x6D, 0xA5, 0xB4, 0x90, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x0C, 0x0C, 0x07, 0x06, 0x00, 0xE2, 0x00, 0x1D, 0x01, 0x03,
  0xFF, 0x80, 0xC0, 0x00, 0xB0, 0x01, 0x88, 0x01, 0x86, 0x01, 0x81, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x30, 0x86, 0x18, 0xC3, 0x18, 0x63,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0E, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x0C,
  0x30, 0x00, 0x86, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x34, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x16,
  0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0xC8,
  0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x07, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xC0, 0xF0, 0xE8, 0x62, 0x71, 0xB0, 0x68, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x00,
  0x4F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x0E, 0x0F, 0x01, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x68, 0x00,
  0x02, 0x40, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x08,
  0x00, 0x30, 0x40, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x00, 0x10,
  0x08, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x01,
  0x80, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x86, 0x00, 0x1F, 0xFC, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x80, 0x0E, 0x0E, 0x03, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x1F, 0x80, 0xCE, 0x3C, 0x13, 0x00, 0xC6, 0x80, 0x08, 0xE0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x19, 0x00,
  0x03, 0x20, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x00,
  0x18, 0x30, 0x06, 0x03, 0x83, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01,
  0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x30,
  0x40, 0x03, 0x04, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0x40, 0x20, 0x1C,
  0x03, 0x83, 0x00, 0x0C, 0xE0, 0x00, 0x78, 0x00, 0x3D, 0x80, 0x0E, 0x0E,
  0x01, 0x80, 0x30, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00,
  0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x40,
  0x03, 0x06, 0x00, 0x60, 0x38, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0E, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x10, 0x00, 0xC6,
  0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x98,
  0x00, 0x13, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x38, 0xC0, 0x0B, 0x0C,
  0x06, 0x40, 0xFF, 0x98, 0x07, 0x83, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x08, 0x0E, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0E, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7F,
  0xE0, 0xC0, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x03, 0x18, 0x00, 0xF8, 0x06, 0x20, 0x0F, 0xFC, 0x04, 0xC0, 0x30, 0x18,
  0x09, 0x00, 0xC0, 0x30, 0x16, 0x03, 0x00, 0x40, 0x2C, 0x0C, 0x00, 0x80,
  0x50, 0x18, 0x03, 0x00, 0xA0, 0x20, 0x06, 0x03, 0xC0, 0xC0, 0x08, 0x07,
  0x81, 0x80, 0x30, 0x0B, 0x03, 0x00, 0x60, 0x36, 0x06, 0x01, 0xC0, 0x6C,
  0x0C, 0x03, 0x81, 0x98, 0x18, 0x0B, 0x06, 0x10, 0x18, 0x36, 0x1C, 0x20,
  0x1F, 0x87, 0xE0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x06,
  0x10, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x81,
  0x80, 0x06, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x04, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x18, 0x07, 0xFF, 0xF0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40,
  0x60, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0xC0, 0x08, 0x03, 0xC0, 0x20, 0x01, 0x81, 0x80,
  0x02, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x03,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x02, 0x00, 0x1C, 0x18,
  0x01, 0xC0, 0x7F, 0xFC, 0x01, 0x80, 0xF8, 0x04, 0x00, 0x30, 0x10, 0x00,
  0x60, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00,
  0x03, 0x0C, 0x00, 0x38, 0x30, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x02, 0x01, 0xF0, 0x02, 0x00, 0x38, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x60, 0x00, 0xE0, 0x40, 0x01, 0xC0, 0xC0, 0x07, 0x00, 0xC1, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x07, 0x01,
  0xC0, 0x01, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x07, 0xFE, 0xC0, 0x07, 0xFC, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x10, 0x38, 0x00, 0x10, 0x1C,
  0x00, 0x30, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18,
  0x00, 0x06, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x21, 0xC0,
  0x1F, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x04, 0x03, 0x00,
  0x04, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x1B, 0x60, 0x00, 0x1E, 0x60, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x78, 0x34, 0x00, 0x01, 0xA0, 0x68, 0x00, 0x03, 0x40, 0x90, 0x00, 0x0D,
  0x81, 0x30, 0x00, 0x13, 0x02, 0x60, 0x00, 0x66, 0x0C, 0xC0, 0x01, 0x88,
  0x18, 0x80, 0x03, 0x10, 0x21, 0x00, 0x0C, 0x60, 0x42, 0x00, 0x10, 0xC1,
  0x86, 0x00, 0x61, 0x83, 0x0C, 0x00, 0x82, 0x06, 0x18, 0x03, 0x0C, 0x08,
  0x10, 0x0C, 0x18, 0x10, 0x20, 0x10, 0x30, 0x60, 0x40, 0x60, 0x40, 0xC0,
  0xC0, 0x80, 0x81, 0x81, 0x83, 0x03, 0x02, 0x03, 0x0C, 0x06, 0x04, 0x02,
  0x18, 0x0C, 0x18, 0x04, 0x60, 0x10, 0x30, 0x08, 0x80, 0x20, 0x60, 0x1B,
  0x00, 0xC0, 0x80, 0x34, 0x01, 0x83, 0x00, 0x78, 0x03, 0x06, 0x00, 0x60,
  0x04, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0x38, 0x00, 0x08, 0x1E, 0x00, 0x06, 0x06, 0xC0, 0x01, 0x81, 0x30,
  0x00, 0x60, 0x44, 0x00, 0x10, 0x11, 0x80, 0x04, 0x0C, 0x20, 0x03, 0x03,
  0x0C, 0x00, 0xC0, 0x83, 0x00, 0x30, 0x20, 0x40, 0x08, 0x18, 0x18, 0x06,
  0x06, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x10, 0x10, 0x06,
  0x04, 0x0C, 0x01, 0x83, 0x03, 0x00, 0x20, 0xC0, 0xC0, 0x0C, 0x30, 0x20,
  0x01, 0x08, 0x08, 0x00, 0x62, 0x06, 0x00, 0x19, 0x81, 0x80, 0x02, 0x60,
  0x60, 0x00, 0xD8, 0x10, 0x00, 0x14, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x38, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x10, 0x0F, 0x00, 0x80, 0x1C, 0x0C,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x10, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x70, 0x60, 0x0F, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x10, 0x0F, 0x00, 0x80, 0x1C,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x10, 0x00, 0x61,
  0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x7E, 0x03, 0xFF, 0x80, 0x10, 0x08,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0x60, 0x10,
  0x03, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFE, 0x03, 0x80, 0x70, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x08, 0x00, 0xE0, 0xE0, 0x3C, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00, 0x38, 0x0E,
  0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x08, 0x00, 0x80, 0x40, 0x0C, 0x02,
  0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x66, 0x00, 0x03, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x02, 0x80, 0x06, 0xC0, 0x06, 0x80,
  0x04, 0xC0, 0x06, 0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x08, 0xC0, 0x0C, 0x80,
  0x18, 0xC0, 0x18, 0x80, 0x10, 0xC0, 0x18, 0x80, 0x30, 0xC0, 0x10, 0x80,
  0x30, 0xC0, 0x30, 0x80, 0x60, 0x40, 0x20, 0xC0, 0x60, 0x40, 0x60, 0xC0,
  0xC0, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0xC0, 0x80, 0x40, 0x80, 0xC1,
  0x80, 0x41, 0x80, 0xC1, 0x00, 0x41, 0x00, 0xC3, 0x00, 0x43, 0x00, 0xC2,
  0x00, 0x42, 0x00, 0x46, 0x00, 0x46, 0x00, 0x46, 0x00, 0x64, 0x00, 0x4C,
  0x00, 0x6C, 0x00, 0x4C, 0x00, 0x6C, 0x00, 0x48, 0x00, 0x78, 0x00, 0x58,
  0x00, 0x78, 0x00, 0x50, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xC0,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x40, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x40, 0x00, 0xC6,
  0x00, 0x18, 0x60, 0x01, 0x02, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x01, 0x80, 0x18, 0x30, 0x01, 0x82, 0x00, 0x08, 0x60,
  0x00, 0xCC, 0x00, 0x0C, 0x80, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFC, 0x00, 0xC1,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x04,
  0x08, 0x10, 0x30, 0x60, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20,
  0x60, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x32, 0x00, 0x04, 0x60, 0x01,
  0x84, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x06, 0x06, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x8C, 0x00, 0x33, 0x00,
  0x02, 0x40, 0x00, 0x78, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0x18,
  0x61, 0x04, 0x00, 0xFC, 0x20, 0x71, 0xC4, 0x18, 0x0D, 0x86, 0x00, 0xB1,
  0x80, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC8,
  0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x01, 0xE1, 0x00, 0x68, 0x30,
  0x19, 0x03, 0x06, 0x20, 0x3F, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x41, 0xF8, 0x04, 0x73, 0xC0, 0xCC,
  0x06, 0x0D, 0x00, 0x20, 0xA0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x33,
  0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x0C,
  0x70, 0x00, 0x85, 0x00, 0x18, 0x48, 0x03, 0x04, 0xE0, 0xE0, 0xC7, 0xF8,
  0x00, 0x00, 0xFF, 0x01, 0xE1, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x7F, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x03, 0xF0, 0xC0, 0x38, 0xF3, 0x01, 0x80, 0x48, 0x0C, 0x00, 0xA0,
  0x60, 0x02, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x41, 0x80,
  0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x02,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0C,
  0x00, 0x50, 0x10, 0x02, 0x40, 0x60, 0x1B, 0x00, 0xC1, 0x8C, 0x01, 0xFC,
  0x20, 0x00, 0x00, 0xFC, 0x01, 0xE3, 0x81, 0x80, 0xC1, 0x80, 0x31, 0x80,
  0x18, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x06, 0x30, 0x0E, 0x1F,
  0xFC, 0x0F, 0xA0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x7F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x10, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x08, 0x0E, 0x3C, 0xC0,
  0xC0, 0x24, 0x0C, 0x00, 0xA0, 0xC0, 0x05, 0x0C, 0x00, 0x38, 0x60, 0x00,
  0xC6, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x38,
  0x60, 0x01, 0xC3, 0x00, 0x14, 0x08, 0x01, 0xA0, 0x60, 0x1B, 0x01, 0x83,
  0x18, 0x07, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x1C,
  0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x83, 0xF0, 0x11, 0xC7, 0x06, 0x60, 0x30, 0xD0,
  0x02, 0x14, 0x00, 0x43, 0x80, 0x08, 0x60, 0x01, 0x18, 0x00, 0x23, 0x00,
  0x0C, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00,
  0x31, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00,
  0xC4, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x40, 0x01, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x0C, 0x10, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x30,
  0x18, 0x0C, 0x02, 0x02, 0x00, 0x41, 0x80, 0x18, 0x60, 0x03, 0x18, 0x00,
  0x46, 0x00, 0x09, 0xC0, 0x03, 0x6C, 0x00, 0x78, 0x80, 0x0E, 0x18, 0x01,
  0x81, 0x00, 0x20, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x04, 0x04,
  0x00, 0xC0, 0x80, 0x08, 0x30, 0x01, 0x80, 0x01, 0x01, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0x04, 0x3F, 0x01, 0xF8, 0x08, 0xC7, 0x06, 0x38, 0x32, 0x03,
  0x30, 0x18, 0x68, 0x06, 0x40, 0x30, 0xA0, 0x05, 0x00, 0x21, 0x80, 0x0E,
  0x00, 0x43, 0x00, 0x18, 0x00, 0x8C, 0x00, 0x60, 0x01, 0x18, 0x00, 0xC0,
  0x06, 0x30, 0x01, 0x80, 0x0C, 0x40, 0x02, 0x00, 0x19, 0x80, 0x04, 0x00,
  0x23, 0x00, 0x18, 0x00, 0x46, 0x00, 0x30, 0x01, 0x88, 0x00, 0x60, 0x03,
  0x10, 0x00, 0x80, 0x04, 0x60, 0x01, 0x00, 0x08, 0xC0, 0x06, 0x00, 0x31,
  0x80, 0x0C, 0x00, 0x62, 0x00, 0x10, 0x00, 0xC4, 0x00, 0x20, 0x01, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x04, 0x1F, 0x80, 0x47, 0x9C, 0x0C, 0xC0, 0x60,
  0xD0, 0x02, 0x0A, 0x00, 0x20, 0xE0, 0x03, 0x0C, 0x00, 0x21, 0x80, 0x02,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00,
  0x43, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x00,
  0xFE, 0x00, 0x78, 0xE0, 0x18, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x60,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x01, 0x88, 0x00, 0x21, 0x80, 0x0C, 0x18, 0x03, 0x03, 0x81,
  0xC0, 0x1F, 0xE0, 0x00, 0x01, 0x07, 0xE0, 0x04, 0x73, 0xC0, 0x33, 0x01,
  0x80, 0xD0, 0x02, 0x02, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1,
  0x80, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x1C, 0x00, 0x30, 0x70, 0x00, 0x81, 0xC0, 0x06, 0x04, 0x80, 0x30, 0x13,
  0x83, 0x80, 0xC3, 0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x38,
  0xF3, 0x06, 0x01, 0x20, 0xC0, 0x0A, 0x18, 0x00, 0xA3, 0x00, 0x0E, 0x30,
  0x00, 0x66, 0x00, 0x04, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38,
  0xC0, 0x03, 0x8C, 0x00, 0x50, 0x40, 0x09, 0x06, 0x01, 0xB0, 0x30, 0x63,
  0x01, 0xFC, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x04, 0x3E, 0x08, 0xE4, 0x33, 0x00, 0x68, 0x00,
  0xA0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0x8F, 0x0C, 0x01, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x80, 0x18, 0xE0, 0x38, 0x3F, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x07, 0xFF, 0xFF, 0xF1, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x10, 0x7F, 0x00, 0x18,
  0x00, 0x23, 0x00, 0x04, 0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60,
  0x00, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x19, 0x80,
  0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x2C, 0x30, 0x19, 0x07, 0x06,
  0x20, 0x7F, 0x8C, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xC8, 0x00,
  0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x18, 0x08, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x09, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x78, 0x01, 0x80, 0x1B, 0x00, 0x70,
  0x03, 0x60, 0x0A, 0x00, 0xCC, 0x03, 0x40, 0x18, 0x80, 0x6C, 0x06, 0x10,
  0x19, 0x80, 0xC2, 0x03, 0x30, 0x10, 0x40, 0xC6, 0x06, 0x08, 0x18, 0x40,
  0x81, 0x06, 0x08, 0x30, 0x20, 0x81, 0x04, 0x04, 0x30, 0x21, 0x80, 0xC4,
  0x04, 0x20, 0x19, 0x80, 0x8C, 0x03, 0x20, 0x19, 0x00, 0x6C, 0x03, 0x60,
  0x0D, 0x00, 0x68, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x30, 0x01, 0x00,
  0x80, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x18,
  0x00, 0x11, 0x80, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x00,
  0x0C, 0x0C, 0x00, 0x40, 0x20, 0x06, 0x01, 0x80, 0x60, 0x04, 0x06, 0x00,
  0x30, 0x60, 0x00, 0x80, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x06, 0x00, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40,
  0x60, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x61, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x22, 0x00, 0x00, 0x26, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x38, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x7F, 0x80,
  0x38, 0x1C, 0x0E, 0x00, 0xFF, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 9, 10, 13, 5, -29 },
  { 42, 25, 29, 25, 1, -29 },
  { 133, 19, 33, 23, 2, -31 },
  { 212, 26, 30, 32, 3, -30 },
  { 310, 24, 30, 28, 2, -30 },
  { 400, 3, 10, 7, 5, -29 },
  { 404, 12, 35, 10, 1, -29 },
  { 457, 12, 35, 10, -3, -29 },
  { 510, 17, 17, 22, 5, -31 },
  { 547, 19, 19, 23, 3, -24 },
  { 593, 6, 10, 8, -2, -5 },
  { 601, 10, 2, 13, 1, -12 },
  { 604, 3, 3, 9, 1, -3 },
  { 606, 18, 29, 13, -2, -29 },
  { 672, 19, 30, 23, 3, -30 },
  { 744, 10, 29, 23, 7, -29 },
  { 781, 21, 30, 23, 0, -30 },
  { 860, 21, 30, 23, 1, -30 },
  { 939, 21, 29, 23, 1, -29 },
  { 1016, 20, 29, 23, 2, -29 },
  { 1089, 19, 30, 23, 3, -30 },
  { 1161, 19, 29, 23, 4, -29 },
  { 1230, 20, 30, 23, 2, -30 },
  { 1305, 19, 30, 23, 2, -30 },
  { 1377, 7, 22, 9, 1, -22 },
  { 1397, 10, 27, 9, -2, -22 },
  { 1431, 19, 19, 23, 3, -24 },
  { 1477, 19, 9, 23, 3, -19 },
  { 1499, 19, 19, 23, 3, -24 },
  { 1545, 15, 30, 17, 3, -30 },
  { 1602, 31, 33, 34, 2, -29 },
  { 1730, 23, 29, 23, -2, -29 },
  { 1814, 22, 29, 25, 2, -29 },
  { 1894, 23, 30, 24, 3, -30 },
  { 1981, 24, 29, 28, 2, -29 },
  { 2068, 21, 29, 22, 2, -29 },
  { 2145, 21, 29, 20, 2, -29 },
  { 2222, 24, 30, 28, 3, -30 },
  { 2312, 26, 29, 28, 2, -29 },
  { 2407, 14, 29, 12, 0, -29 },
  { 2458, 17, 36, 10, -7, -29 },
  { 2535, 24, 29, 22, 2, -29 },
  { 2622, 15, 29, 20, 2, -29 },
  { 2677, 31, 29, 33, 2, -29 },
  { 2790, 26, 29, 28, 2, -29 },
  { 2885, 25, 30, 29, 3, -30 },
  { 2979, 21, 29, 23, 2, -29 },
  { 3056, 25, 37, 29, 3, -30 },
  { 3172, 21, 29, 23, 2, -29 },
  { 3249, 20, 30, 20, 1, -30 },
  { 3324, 20, 29, 20, 4, -29 },
  { 3397, 24, 29, 28, 4, -29 },
  { 3484, 21, 29, 22, 4, -29 },
  { 3561, 32, 29, 34, 5, -29 },
  { 3677, 26, 29, 20, -2, -29 },
  { 3772, 20, 29, 20, 4, -29 },
  { 3845, 23, 29, 22, 0, -29 },
  { 3929, 15, 35, 12, 0, -29 },
  { 3995, 7, 29, 13, 4, -29 },
  { 4021, 16, 35, 12, -3, -29 },
  { 4091, 19, 18, 23, 2, -29 },
  { 4134, 16, 2, 15, -4, 4 },
  { 4138, 5, 6, 10, 6, -31 },
  { 4142, 19, 22, 23, 2, -22 },
  { 4195, 20, 31, 23, 1, -31 },
  { 4273, 17, 22, 19, 2, -22 },
  { 4320, 22, 31, 23, 2, -31 },
  { 4406, 17, 22, 20, 2, -22 },
  { 4453, 22, 41, 11, -5, -31 },
  { 4566, 21, 32, 23, 1, -22 },
  { 4650, 19, 31, 23, 1, -31 },
  { 4724, 8, 30, 9, 1, -30 },
  { 4754, 15, 40, 9, -6, -30 },
  { 4829, 19, 31, 18, 1, -31 },
  { 4903, 8, 31, 9, 1, -31 },
  { 4934, 31, 22, 35, 1, -22 },
  { 5020, 20, 22, 23, 1, -22 },
  { 5075, 19, 22, 23, 2, -22 },
  { 5128, 22, 32, 23, -1, -22 },
  { 5216, 20, 32, 23, 2, -22 },
  { 5296, 15, 22, 15, 1, -22 },
  { 5338, 16, 22, 17, 0, -22 },
  { 5382, 12, 27, 13, 2, -27 },
  { 5423, 19, 22, 23, 2, -22 },
  { 5476, 17, 22, 17, 2, -22 },
  { 5523, 27, 22, 27, 2, -22 },
  { 5598, 21, 22, 19, -1, -22 },
  { 5656, 24, 32, 17, -5, -22 },
  { 5752, 19, 22, 18, -1, -22 },
  { 5805, 15, 35, 14, 1, -29 },
  { 5871, 2, 41, 22, 11, -31 },
  { 5882, 15, 36, 14, -2, -29 },
  { 5950, 19, 4, 23, 3, -16 },
};

const GFXfont NotoSans_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRALIGHTITALIC41PT7B_H_
