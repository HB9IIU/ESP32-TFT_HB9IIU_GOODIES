#ifndef _NOTOSANS_EXTRALIGHTITALIC61PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x18, 0x1C, 0xE0,
  0x73, 0x81, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE7, 0x03, 0x98, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x10, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30,
  0x10, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xC6, 0x1F, 0x00,
  0xF0, 0x60, 0x30, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0F, 0x30, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x2F, 0x80, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x1C, 0x0C,
  0x01, 0x87, 0x80, 0xFE, 0x33, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x1E, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x18,
  0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x70, 0x00, 0xC0,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x06, 0x01, 0x03, 0x00, 0x0C, 0x1C, 0x3F, 0xC6, 0x00,
  0x30, 0x70, 0xFB, 0xCC, 0x00, 0x60, 0xC3, 0x81, 0xDC, 0x01, 0x83, 0x0E,
  0x01, 0x98, 0x07, 0x0E, 0x18, 0x03, 0xB0, 0x0C, 0x38, 0x60, 0x07, 0x70,
  0x70, 0x60, 0xC0, 0x0E, 0x7F, 0xC1, 0x83, 0x80, 0x0C, 0x3F, 0x07, 0x06,
  0x00, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x0E, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x03, 0x80, 0x30, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x70, 0x00, 0x07, 0x9E, 0x01, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF1, 0x80,
  0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x0C,
  0x70, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x00, 0xE0, 0x18, 0xE0, 0x00, 0x06,
  0x03, 0x0C, 0x00, 0x00, 0x70, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x0C, 0x00,
  0x00, 0x18, 0xC0, 0xC0, 0x00, 0x01, 0xD8, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x03,
  0xB8, 0x07, 0x00, 0x00, 0x71, 0xC0, 0x78, 0x00, 0x1E, 0x0C, 0x03, 0xC0,
  0x07, 0x80, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x18,
  0x8C, 0x63, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0xE0, 0x18, 0x00, 0x3C, 0x06, 0x00,
  0x03, 0xC1, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xB0, 0x1F, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0,
  0x1E, 0xC0, 0xF1, 0x83, 0xC3, 0x1E, 0x0E, 0x78, 0x1D, 0xC0, 0x31, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x01, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xF8, 0x02, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0x0E, 0x0F,
  0xFE, 0x00, 0x61, 0xF0, 0x7C, 0x03, 0x3C, 0x00, 0xF0, 0x3B, 0x80, 0x01,
  0x81, 0xF8, 0x00, 0x0E, 0x0D, 0x80, 0x00, 0x30, 0x78, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0x0E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0xD8, 0x38, 0x00, 0x0D, 0xC0, 0xE0, 0x01, 0xCC, 0x03, 0xC0,
  0x3C, 0x60, 0x0F, 0xFF, 0xC7, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x04,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x20, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x01, 0xFE,
  0x00, 0x0C, 0x38, 0x00, 0x1F, 0xFF, 0x80, 0x30, 0xC0, 0x01, 0xE0, 0x1C,
  0x00, 0xC6, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x0C, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0xCC, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0D,
  0x80, 0x1C, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x60, 0x00, 0x30, 0x00, 0xD8,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x80,
  0x30, 0x00, 0x18, 0x00, 0x6E, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xB8, 0x03,
  0x00, 0x03, 0x80, 0x0E, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x33, 0x80, 0x30,
  0x00, 0x78, 0x01, 0xCE, 0x00, 0xC0, 0x03, 0x40, 0x0E, 0x18, 0x03, 0x80,
  0x0D, 0x80, 0x30, 0x60, 0x06, 0x00, 0x66, 0x01, 0xC1, 0x80, 0x1C, 0x07,
  0x1C, 0x1E, 0x06, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x1C, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x07, 0x80, 0x60, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x78, 0x00, 0x60, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x78, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x06, 0x3F, 0x00, 0x00, 0x00, 0x67, 0x30, 0x00, 0x00, 0x0E, 0xE3, 0x80,
  0x00, 0x00, 0xF8, 0x18, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x0D, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x37, 0x00, 0x00, 0x00, 0xE6, 0x01,
  0xCC, 0x00, 0x00, 0x03, 0x38, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xE0, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x63, 0x00, 0x00, 0x03, 0x8C, 0x01, 0x8E,
  0x00, 0x00, 0x0C, 0x70, 0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x38, 0x60,
  0x00, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x03, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x80, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x1C, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x98, 0x00, 0x38, 0x06, 0x00, 0x06, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x1B,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x00,
  0x00, 0x1C, 0x03, 0x60, 0x00, 0x00, 0x60, 0x0D, 0xC0, 0x00, 0x01, 0x80,
  0x33, 0x00, 0x00, 0x06, 0x01, 0xCE, 0x00, 0x00, 0x38, 0x07, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x60, 0x00, 0x03, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x01,
  0x83, 0x00, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x60, 0x00, 0x18, 0x0C,
  0x01, 0x80, 0x00, 0x70, 0x30, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x38, 0x00,
  0x03, 0x87, 0x00, 0xE0, 0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x18, 0x60,
  0x0C, 0x00, 0x00, 0x71, 0x80, 0x70, 0x00, 0x00, 0xCE, 0x01, 0xC0, 0x00,
  0x03, 0xB8, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xF0, 0x07,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0,
  0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x00, 0x60, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x73, 0x00, 0x00, 0x33, 0x80, 0x00, 0x73, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x37, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE1, 0xC1, 0x83, 0x83, 0x03, 0x07, 0x06, 0x06, 0x04, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x1F, 0x07, 0x0C, 0x03, 0xC0, 0x0C, 0x60,
  0x3C, 0x00, 0x33, 0x01, 0xC0, 0x01, 0x98, 0x1C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x3C, 0x0C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0D, 0x80, 0xC0,
  0x00, 0xCC, 0x07, 0x00, 0x0E, 0x60, 0x1C, 0x00, 0xE3, 0x00, 0xF0, 0x1E,
  0x30, 0x03, 0xFF, 0xC1, 0x80, 0x07, 0xFC, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x3F, 0x00, 0x06, 0x0F, 0xFE, 0x00, 0x70, 0xF0, 0x78, 0x03,
  0x0E, 0x00, 0xE0, 0x18, 0xC0, 0x03, 0x80, 0xCC, 0x00, 0x0C, 0x0E, 0xC0,
  0x00, 0x70, 0x6C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x0C, 0x1E, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0D, 0x00,
  0x00, 0x70, 0x6C, 0x00, 0x03, 0x83, 0x60, 0x00, 0x38, 0x19, 0x80, 0x07,
  0x81, 0x87, 0x00, 0x78, 0x0C, 0x1F, 0xFF, 0x00, 0x60, 0x7F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0x83, 0xE0, 0x1E, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0xE0, 0x00, 0xFF, 0xF0, 0x60, 0x00, 0xF8, 0x3C, 0x30, 0x01, 0xE0, 0x07,
  0x18, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x36, 0x00,
  0x60, 0x00, 0x33, 0x00, 0x38, 0x00, 0x31, 0x80, 0x0E, 0x00, 0x31, 0x80,
  0x07, 0x80, 0x70, 0xC0, 0x01, 0xFF, 0xF0, 0x60, 0x00, 0x3F, 0xE0, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x3C, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x07, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x78, 0xE0,
  0x03, 0xF0, 0xE1, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x10, 0x1E,
  0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0xF8, 0x3C, 0x30, 0x07,
  0x80, 0x1C, 0x60, 0x1E, 0x00, 0x0C, 0xC0, 0x38, 0x00, 0x19, 0x80, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x36, 0x01, 0x80, 0x00, 0xCC, 0x03,
  0x80, 0x03, 0x38, 0x03, 0x80, 0x0C, 0x70, 0x07, 0x80, 0x70, 0xC0, 0x07,
  0xFF, 0xC1, 0x80, 0x03, 0xFE, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x07, 0xE0, 0x01, 0x81, 0xFF, 0x80, 0x38, 0x7C,
  0x3E, 0x03, 0x0E, 0x00, 0xE0, 0x31, 0x80, 0x07, 0x03, 0x30, 0x00, 0x30,
  0x76, 0x00, 0x03, 0x06, 0xC0, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x30,
  0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x0C, 0x78, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x19, 0xCC, 0x00, 0x01,
  0xB8, 0xE0, 0x00, 0x1F, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x06, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x30, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xC7, 0x00, 0xE0, 0xF0, 0x0E,
  0x03, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x0D, 0xC0, 0x03, 0x18, 0x00, 0x70,
  0x36, 0x00, 0x0C, 0xC0, 0x00, 0xC1, 0xB0, 0x00, 0x36, 0x00, 0x03, 0x07,
  0x80, 0x00, 0xD8, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x0C, 0x1F, 0xFE, 0x00, 0xC1, 0xF1, 0xF8, 0x06, 0x1C,
  0x01, 0xC0, 0x31, 0x80, 0x07, 0x01, 0x98, 0x00, 0x18, 0x1D, 0x80, 0x00,
  0xC0, 0xD8, 0x00, 0x06, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x60, 0xF0, 0x78, 0x00, 0x61,
  0xC0, 0x1C, 0x00, 0x63, 0x00, 0x0E, 0x00, 0x66, 0x00, 0x06, 0x00, 0x6C,
  0x00, 0x07, 0x00, 0xD8, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x03, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0D, 0x00, 0x00, 0x70, 0x0D, 0x80,
  0x00, 0x70, 0x0D, 0x80, 0x00, 0xE0, 0x0C, 0xC0, 0x03, 0xC0, 0x1C, 0x70,
  0x07, 0x80, 0x1C, 0x3F, 0xFE, 0x00, 0x18, 0x1F, 0xF8, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x30, 0x07, 0xC1, 0xE1, 0x80, 0x78, 0x01, 0xC6, 0x03, 0xC0, 0x01,
  0x98, 0x0E, 0x00, 0x06, 0x60, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xB0, 0x18,
  0x00, 0x0C, 0xC0, 0x70, 0x00, 0x67, 0x00, 0xE0, 0x03, 0x1C, 0x03, 0xC0,
  0x38, 0x60, 0x07, 0xFF, 0xC1, 0x80, 0x07, 0xFC, 0x06, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0x07, 0xF8, 0x0C, 0x1F, 0x30,
  0x18, 0xF0, 0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x07,
  0x80, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x80, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x0D, 0x80, 0xC0, 0x01, 0xCC, 0x07, 0x00,
  0x1C, 0x60, 0x1C, 0x03, 0xC3, 0x00, 0xFF, 0xFC, 0x30, 0x01, 0xFF, 0x81,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x06, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x60,
  0x00, 0x78, 0x00, 0x0C, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x60, 0x00, 0xF8,
  0x00, 0x18, 0x60, 0x00, 0xD8, 0x00, 0x38, 0x60, 0x01, 0xDC, 0x00, 0x30,
  0x60, 0x01, 0x8C, 0x00, 0x70, 0x60, 0x03, 0x8C, 0x00, 0x60, 0x60, 0x03,
  0x0C, 0x00, 0xE0, 0x60, 0x07, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x01,
  0xC0, 0x60, 0x0E, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x60,
  0x1C, 0x0C, 0x03, 0x80, 0x70, 0x18, 0x0C, 0x03, 0x00, 0x70, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x30, 0x0E, 0x06, 0x00, 0x70, 0x70, 0x06, 0x0E, 0x00,
  0x70, 0x60, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0x31, 0x80, 0x06, 0x38, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0x33, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x06,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x17, 0xFF, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 45, 13, 2, -44 },
  { 69, 14, 16, 20, 7, -44 },
  { 97, 36, 44, 38, 2, -44 },
  { 295, 28, 50, 34, 3, -46 },
  { 470, 39, 45, 47, 5, -44 },
  { 690, 36, 45, 41, 3, -44 },
  { 893, 5, 16, 11, 7, -44 },
  { 903, 18, 54, 15, 2, -44 },
  { 1025, 18, 54, 15, -4, -44 },
  { 1147, 26, 26, 33, 7, -46 },
  { 1232, 28, 29, 35, 5, -36 },
  { 1334, 9, 15, 12, -3, -7 },
  { 1351, 15, 3, 19, 2, -18 },
  { 1357, 4, 5, 13, 2, -4 },
  { 1360, 28, 44, 19, -3, -44 },
  { 1514, 28, 45, 34, 4, -44 },
  { 1672, 15, 44, 34, 10, -44 },
  { 1755, 30, 44, 34, 1, -44 },
  { 1920, 31, 45, 34, 1, -44 },
  { 2095, 31, 44, 34, 1, -44 },
  { 2266, 31, 45, 34, 2, -44 },
  { 2441, 29, 45, 34, 4, -44 },
  { 2605, 27, 44, 34, 7, -44 },
  { 2754, 30, 45, 34, 3, -44 },
  { 2923, 29, 45, 34, 3, -44 },
  { 3087, 10, 34, 13, 2, -33 },
  { 3130, 15, 41, 13, -3, -33 },
  { 3207, 28, 28, 35, 5, -36 },
  { 3305, 28, 15, 35, 5, -29 },
  { 3358, 28, 28, 35, 5, -36 },
  { 3456, 21, 45, 25, 5, -44 },
  { 3575, 46, 48, 51, 3, -43 },
  { 3851, 34, 44, 34, -3, -44 },
  { 4038, 33, 44, 36, 3, -44 },
  { 4220, 34, 45, 36, 5, -44 },
  { 4412, 36, 44, 41, 3, -44 },
  { 4610, 31, 44, 32, 3, -44 },
  { 4781, 31, 44, 30, 3, -44 },
  { 4952, 36, 45, 42, 5, -44 },
  { 5155, 38, 44, 42, 3, -44 },
  { 5364, 20, 44, 18, 0, -44 },
  { 5474, 25, 55, 15, -10, -44 },
  { 5646, 36, 44, 33, 3, -44 },
  { 5844, 22, 44, 30, 3, -44 },
  { 5965, 46, 44, 50, 3, -44 },
  { 6218, 38, 44, 42, 3, -44 },
  { 6427, 36, 45, 44, 5, -44 },
  { 6630, 31, 44, 34, 3, -44 },
  { 6801, 36, 54, 44, 5, -44 },
  { 7044, 31, 44, 34, 3, -44 },
  { 7215, 30, 45, 30, 1, -44 },
  { 7384, 29, 44, 30, 6, -44 },
  { 7544, 37, 45, 42, 5, -44 },
  { 7753, 32, 44, 33, 6, -44 },
  { 7929, 48, 44, 51, 7, -44 },
  { 8193, 39, 44, 30, -4, -44 },
  { 8408, 30, 44, 30, 6, -44 },
  { 8573, 35, 44, 33, 0, -44 },
  { 8766, 24, 54, 18, -1, -44 },
  { 8928, 10, 44, 19, 6, -44 },
  { 8983, 23, 54, 18, -4, -44 },
  { 9139, 28, 27, 34, 3, -44 },
  { 9234, 23, 2, 23, -5, 6 },
  { 9240, 7, 10, 14, 9, -47 },
  { 9249, 29, 34, 34, 3, -33 },
  { 9373, 29, 47, 35, 2, -46 },
  { 9544, 25, 34, 28, 3, -33 },
  { 9651, 33, 47, 35, 3, -46 },
  { 9845, 24, 34, 30, 4, -33 },
  { 9947, 34, 62, 17, -8, -47 },
  { 10211, 31, 48, 35, 2, -33 },
  { 10397, 28, 46, 34, 2, -46 },
  { 10558, 12, 44, 13, 2, -44 },
  { 10624, 22, 59, 13, -8, -44 },
  { 10787, 28, 46, 27, 2, -46 },
  { 10948, 12, 46, 13, 2, -46 },
  { 11017, 46, 33, 52, 2, -33 },
  { 11207, 29, 33, 34, 2, -33 },
  { 11327, 28, 34, 34, 3, -33 },
  { 11446, 32, 47, 35, -1, -33 },
  { 11634, 30, 47, 35, 3, -33 },
  { 11811, 23, 33, 23, 2, -33 },
  { 11906, 24, 34, 26, 1, -33 },
  { 12008, 18, 41, 19, 3, -40 },
  { 12101, 29, 33, 34, 3, -32 },
  { 12221, 26, 32, 26, 3, -32 },
  { 12325, 40, 32, 41, 3, -32 },
  { 12485, 31, 32, 28, -2, -32 },
  { 12609, 36, 47, 26, -7, -32 },
  { 12821, 28, 32, 27, -1, -32 },
  { 12933, 23, 54, 20, 1, -44 },
  { 13089, 2, 61, 33, 17, -46 },
  { 13105, 22, 54, 20, -3, -44 },
  { 13254, 28, 5, 35, 5, -24 },
};

const GFXfont NotoSans_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRALIGHTITALIC61PT7B_H_
