#ifndef _NOTOSANS_EXTRALIGHTITALIC65PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0x00, 0x00, 0x1C, 0x0E, 0x30, 0x1C, 0x60, 0x38,
  0xC0, 0x63, 0x80, 0xC7, 0x01, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xF6, 0xFF, 0x00, 0x7C, 0x18, 0x1C, 0x03, 0xC0, 0xC0, 0x10, 0x1E,
  0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00,
  0x1F, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x6F, 0x80, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x02, 0x00, 0x30, 0x3C, 0x0F, 0x01,
  0x83, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0xFF, 0x80,
  0x00, 0x0E, 0x01, 0xE1, 0xE0, 0x00, 0x06, 0x01, 0xE0, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x00, 0x60, 0x70, 0x7F, 0x0C, 0x00,
  0x30, 0x70, 0x7F, 0xE6, 0x00, 0x38, 0x30, 0x70, 0x73, 0x00, 0x18, 0x30,
  0x70, 0x1D, 0x80, 0x1C, 0x38, 0x70, 0x06, 0xE0, 0x1C, 0x38, 0x70, 0x03,
  0x70, 0x1C, 0x18, 0x30, 0x01, 0xDE, 0x1C, 0x18, 0x38, 0x00, 0xE7, 0xFC,
  0x1C, 0x18, 0x00, 0x71, 0xF8, 0x1C, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x01, 0x80,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x04, 0x1E, 0x00, 0xE0, 0x00, 0x30, 0x70, 0x01,
  0xC0, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x01, 0x87, 0x00, 0x01, 0xC0, 0x07,
  0x1C, 0x00, 0x01, 0x80, 0x1C, 0x38, 0x00, 0x03, 0x80, 0x38, 0x60, 0x00,
  0x03, 0x80, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x83, 0x80, 0x00, 0x07, 0x06,
  0x06, 0x00, 0x00, 0x07, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x70, 0x18, 0x00,
  0x00, 0x07, 0xC0, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x03, 0xCC, 0x01, 0xC0,
  0x00, 0x0E, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x03, 0xE0,
  0x1C, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC6,
  0x18, 0x61, 0x8C, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x10, 0x01, 0xC0, 0x07, 0x80, 0x30, 0x00, 0xF8, 0x06, 0x00,
  0x07, 0xC0, 0xC0, 0x00, 0x3E, 0x18, 0x00, 0x01, 0xE2, 0x00, 0x00, 0x0F,
  0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x60, 0x1E,
  0x70, 0x1E, 0x38, 0x3C, 0x1C, 0x3C, 0x0C, 0xF8, 0x0E, 0x38, 0x07, 0x10,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x00,
  0x38, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x20, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE3,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x08,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x40, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x18, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00,
  0xC0, 0xFF, 0xF0, 0x01, 0x87, 0xFF, 0xF0, 0x07, 0x1E, 0x00, 0xF0, 0x0C,
  0xF0, 0x00, 0x70, 0x1B, 0x80, 0x00, 0x70, 0x76, 0x00, 0x00, 0xE0, 0xF8,
  0x00, 0x00, 0xC1, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1B, 0x07, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x01, 0xDC, 0x07, 0x00,
  0x0F, 0x30, 0x07, 0x80, 0x78, 0xE0, 0x07, 0xFF, 0xE1, 0xC0, 0x03, 0xFE,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x05,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x20, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0xFC, 0x00, 0x18, 0x30, 0x00, 0x1F, 0xFF, 0xC0, 0x0C, 0x38,
  0x00, 0x1F, 0x03, 0xE0, 0x06, 0x18, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x9C,
  0x00, 0x38, 0x00, 0x30, 0x01, 0xCC, 0x00, 0x38, 0x00, 0x18, 0x00, 0xEE,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3B,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x0D,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xB0, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xD8, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xCC, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x66, 0x00, 0x60, 0x00, 0x38, 0x00, 0x73, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x31, 0x80, 0x18, 0x00, 0x1E, 0x00, 0x38, 0xC0, 0x0C, 0x00, 0x1F, 0x00,
  0x38, 0x60, 0x07, 0x00, 0x0D, 0x80, 0x1C, 0x30, 0x03, 0x80, 0x0C, 0xC0,
  0x1C, 0x18, 0x00, 0xE0, 0x1C, 0x60, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x3C,
  0x3C, 0x07, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x30, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x06, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00,
  0x1F, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x06,
  0x00, 0x01, 0xF8, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xFF, 0xE1, 0x80, 0x00, 0x3F, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x20, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x00, 0x03, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0xEE, 0x00, 0x00,
  0x00, 0x77, 0x1C, 0x00, 0x00, 0x01, 0xB8, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x1B, 0x80, 0x00,
  0x00, 0x0E, 0xC0, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x30, 0x03, 0x98, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x07, 0x1C,
  0x00, 0x00, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x61,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x06,
  0x0C, 0x00, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0xC0,
  0x0C, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03,
  0x80, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x38, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x07, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x03, 0x00,
  0x03, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x33, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x06,
  0x00, 0x03, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x06, 0xC0,
  0x00, 0x00, 0x30, 0x03, 0x70, 0x00, 0x00, 0x38, 0x03, 0xB8, 0x00, 0x00,
  0x1C, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x00,
  0x61, 0x80, 0x00, 0x07, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x30,
  0x00, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x00, 0x70, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x1C,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x70,
  0x00, 0x06, 0x03, 0x80, 0x38, 0x00, 0x03, 0x01, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x70,
  0x07, 0x00, 0x00, 0x0C, 0x30, 0x03, 0x80, 0x00, 0x07, 0x18, 0x01, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x18, 0x00, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x03, 0xE0, 0x0C, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0x98, 0x00, 0x01, 0x87, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x61, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06,
  0x00, 0x0E, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x30, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x01, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x03,
  0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC3, 0x83,
  0x83, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x08, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x1C, 0x00, 0xF8, 0x3C, 0x30, 0x07, 0x80, 0x1C, 0x60, 0x1E,
  0x00, 0x18, 0xC0, 0x78, 0x00, 0x1B, 0x81, 0xE0, 0x00, 0x36, 0x03, 0x80,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x01, 0xE0, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x01, 0x98, 0x0E,
  0x00, 0x07, 0x70, 0x0E, 0x00, 0x1C, 0xC0, 0x1C, 0x00, 0x71, 0x80, 0x1E,
  0x03, 0xC3, 0x00, 0x1F, 0xFE, 0x06, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x3F, 0x80, 0x01, 0xC1, 0xFF, 0xE0, 0x01, 0x83, 0xC1, 0xF0, 0x01,
  0x87, 0x00, 0x78, 0x03, 0x9C, 0x00, 0x1C, 0x03, 0x98, 0x00, 0x1C, 0x03,
  0x30, 0x00, 0x0E, 0x03, 0x60, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x06, 0x07,
  0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0xE0, 0x66, 0x00, 0x01, 0xC0, 0x66,
  0x00, 0x03, 0x80, 0x63, 0x00, 0x0F, 0x00, 0x63, 0xC0, 0x1E, 0x00, 0xC1,
  0xFF, 0xFC, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x02,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x1F, 0x00, 0x38, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE,
  0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x38, 0x00, 0x3E, 0x0F, 0x86, 0x00, 0x1E,
  0x00, 0x38, 0xC0, 0x07, 0x80, 0x03, 0x38, 0x01, 0xE0, 0x00, 0x37, 0x00,
  0x78, 0x00, 0x06, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xD8, 0x01,
  0xC0, 0x00, 0x33, 0x00, 0x38, 0x00, 0x0C, 0xE0, 0x03, 0x80, 0x03, 0x98,
  0x00, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x80, 0x70, 0x60, 0x00, 0x7F, 0xFC,
  0x0C, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE1, 0xF0, 0x03, 0xC0, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x0E, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xE1,
  0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x20, 0x1F, 0x00, 0x38, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0xC0, 0x07, 0xC1, 0xF0, 0xC0, 0x0F, 0x00,
  0x1C, 0x60, 0x0F, 0x00, 0x06, 0x30, 0x0F, 0x00, 0x01, 0x98, 0x0F, 0x00,
  0x00, 0xDC, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x81, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x6C, 0x03, 0x80, 0x00, 0x6E, 0x01, 0xC0, 0x00, 0x77,
  0x00, 0x70, 0x00, 0x73, 0x00, 0x38, 0x00, 0xF1, 0x80, 0x0F, 0x00, 0xE1,
  0xC0, 0x03, 0xFF, 0xE0, 0xE0, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x02, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0x70, 0x3F, 0xF8, 0x01, 0x83, 0xE1, 0xF8, 0x06, 0x1C, 0x00, 0xE0,
  0x38, 0xC0, 0x01, 0xC0, 0xE6, 0x00, 0x07, 0x03, 0x30, 0x00, 0x0C, 0x0D,
  0x80, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x70, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xF0, 0x06, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x03, 0x1F, 0x80, 0x00, 0x1C, 0xE6,
  0x00, 0x00, 0x76, 0x1C, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x61,
  0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x31, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x19,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x19, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x06, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC1,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0x03, 0xFF, 0xE0, 0x06, 0x0F, 0x87, 0xE0, 0x0C, 0x38, 0x01,
  0xC0, 0x39, 0xE0, 0x01, 0xC0, 0x73, 0x00, 0x03, 0x80, 0xCC, 0x00, 0x03,
  0x01, 0xB0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x18,
  0x1E, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x07, 0xFF, 0x80, 0x00, 0xC1, 0xE0,
  0xF8, 0x00, 0x18, 0x70, 0x07, 0x80, 0x03, 0x38, 0x00, 0x38, 0x00, 0xE6,
  0x00, 0x07, 0x00, 0x19, 0x80, 0x00, 0x70, 0x03, 0x60, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x1D, 0x80, 0x00, 0x70, 0x03,
  0x30, 0x00, 0x1C, 0x00, 0x63, 0x00, 0x0F, 0x00, 0x0C, 0x78, 0x03, 0xC0,
  0x03, 0x87, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0x00,
  0x3E, 0x0F, 0x86, 0x00, 0xF0, 0x01, 0xC6, 0x01, 0xE0, 0x00, 0xC6, 0x03,
  0xC0, 0x00, 0x66, 0x07, 0x80, 0x00, 0x6E, 0x07, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x18,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x03, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x0D, 0xC0, 0x70,
  0x00, 0x19, 0xC0, 0x38, 0x00, 0x39, 0x80, 0x38, 0x00, 0xF1, 0x80, 0x1E,
  0x01, 0xC1, 0x80, 0x0F, 0xFF, 0x83, 0x80, 0x07, 0xFE, 0x03, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0x81, 0xFF, 0x01, 0x83, 0xE3, 0x01, 0x8F, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x78, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1, 0x00, 0x00, 0xE0,
  0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x3E, 0x0C,
  0x00, 0x01, 0xB0, 0x30, 0x00, 0x0E, 0xC0, 0xC0, 0x00, 0x33, 0x03, 0x80,
  0x03, 0x9C, 0x0F, 0x00, 0x1C, 0x60, 0x1E, 0x01, 0xE1, 0x80, 0x3F, 0xFF,
  0x06, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x01,
  0xD8, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0xE6, 0x00,
  0x07, 0x60, 0x00, 0x73, 0x00, 0x03, 0x30, 0x00, 0x71, 0x80, 0x03, 0x98,
  0x00, 0x38, 0xE0, 0x01, 0x8C, 0x00, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x1C,
  0x38, 0x00, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0x60, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x30, 0x07, 0x03, 0x80, 0x30, 0x18,
  0x03, 0x01, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x1C, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0E,
  0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x07, 0x00, 0x38,
  0x70, 0x01, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00,
  0x63, 0x80, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x19, 0xC0,
  0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x37,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF0,
  0x00, 0x17, 0x81, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1E, 0x80, 0x01, 0xFF,
  0xF2, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 47, 14, 2, -46 },
  { 78, 15, 16, 21, 7, -46 },
  { 108, 39, 46, 40, 2, -46 },
  { 333, 30, 53, 36, 3, -49 },
  { 532, 41, 48, 50, 6, -47 },
  { 778, 39, 48, 44, 3, -47 },
  { 1012, 6, 16, 12, 7, -46 },
  { 1024, 19, 56, 16, 2, -46 },
  { 1157, 19, 56, 16, -4, -46 },
  { 1290, 27, 28, 35, 8, -49 },
  { 1385, 30, 30, 37, 5, -38 },
  { 1498, 10, 16, 13, -3, -8 },
  { 1518, 16, 3, 20, 2, -19 },
  { 1524, 4, 5, 14, 2, -4 },
  { 1527, 29, 46, 21, -3, -46 },
  { 1694, 30, 48, 36, 4, -47 },
  { 1874, 17, 46, 36, 10, -46 },
  { 1972, 32, 47, 36, 1, -47 },
  { 2160, 33, 48, 36, 1, -47 },
  { 2358, 33, 47, 36, 1, -47 },
  { 2552, 33, 47, 36, 2, -46 },
  { 2746, 31, 48, 36, 4, -47 },
  { 2932, 30, 46, 36, 7, -46 },
  { 3105, 32, 48, 36, 3, -47 },
  { 3297, 31, 48, 36, 3, -47 },
  { 3483, 11, 36, 14, 2, -35 },
  { 3533, 16, 43, 14, -3, -35 },
  { 3619, 30, 29, 37, 5, -38 },
  { 3728, 30, 16, 37, 5, -31 },
  { 3788, 30, 29, 37, 5, -38 },
  { 3897, 23, 48, 27, 5, -47 },
  { 4035, 49, 52, 54, 4, -46 },
  { 4354, 36, 47, 36, -3, -47 },
  { 4566, 35, 46, 39, 3, -46 },
  { 4768, 36, 48, 39, 5, -47 },
  { 4984, 38, 46, 44, 3, -46 },
  { 5203, 33, 46, 35, 3, -46 },
  { 5393, 33, 46, 32, 3, -46 },
  { 5583, 38, 48, 45, 5, -47 },
  { 5811, 41, 46, 44, 3, -46 },
  { 6047, 21, 46, 19, 0, -46 },
  { 6168, 27, 58, 16, -11, -46 },
  { 6364, 38, 46, 36, 3, -46 },
  { 6583, 24, 46, 32, 3, -46 },
  { 6721, 50, 46, 53, 3, -46 },
  { 7009, 41, 46, 44, 3, -46 },
  { 7245, 39, 48, 47, 5, -47 },
  { 7479, 33, 46, 36, 3, -46 },
  { 7669, 39, 58, 47, 5, -47 },
  { 7952, 33, 46, 37, 3, -46 },
  { 8142, 32, 48, 32, 1, -47 },
  { 8334, 32, 46, 32, 6, -46 },
  { 8518, 39, 47, 45, 6, -46 },
  { 8748, 33, 46, 35, 7, -46 },
  { 8938, 51, 46, 54, 8, -46 },
  { 9232, 41, 46, 32, -4, -46 },
  { 9468, 32, 46, 32, 6, -46 },
  { 9652, 38, 46, 35, -1, -46 },
  { 9871, 25, 56, 20, -1, -46 },
  { 10046, 11, 46, 21, 6, -46 },
  { 10110, 25, 56, 20, -5, -46 },
  { 10285, 30, 29, 36, 3, -47 },
  { 10394, 25, 2, 24, -6, 7 },
  { 10401, 7, 11, 15, 10, -50 },
  { 10411, 31, 36, 36, 3, -35 },
  { 10551, 32, 50, 37, 2, -49 },
  { 10751, 26, 36, 29, 4, -35 },
  { 10868, 35, 50, 37, 3, -49 },
  { 11087, 26, 36, 32, 4, -35 },
  { 11204, 35, 66, 18, -8, -50 },
  { 11493, 33, 51, 37, 2, -35 },
  { 11704, 30, 49, 36, 2, -49 },
  { 11888, 13, 47, 14, 2, -47 },
  { 11965, 24, 63, 14, -9, -47 },
  { 12154, 30, 49, 29, 2, -49 },
  { 12338, 13, 49, 14, 2, -49 },
  { 12418, 49, 35, 55, 2, -35 },
  { 12633, 31, 35, 36, 2, -35 },
  { 12769, 29, 36, 37, 4, -35 },
  { 12900, 35, 50, 37, -1, -35 },
  { 13119, 32, 50, 37, 3, -35 },
  { 13319, 24, 35, 24, 2, -35 },
  { 13424, 25, 36, 28, 1, -35 },
  { 13537, 19, 44, 20, 3, -43 },
  { 13642, 30, 35, 36, 4, -34 },
  { 13774, 28, 34, 27, 3, -34 },
  { 13893, 41, 34, 43, 4, -34 },
  { 14068, 33, 34, 30, -2, -34 },
  { 14209, 38, 50, 27, -7, -34 },
  { 14447, 29, 34, 28, -1, -34 },
  { 14571, 23, 56, 22, 2, -46 },
  { 14732, 2, 65, 35, 18, -49 },
  { 14749, 23, 56, 22, -3, -46 },
  { 14910, 30, 6, 37, 5, -26 },
};

const GFXfont NotoSans_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRALIGHTITALIC65PT7B_H_
