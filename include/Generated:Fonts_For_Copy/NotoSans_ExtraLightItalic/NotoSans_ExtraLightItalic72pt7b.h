#ifndef _NOTOSANS_EXTRALIGHTITALIC72PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x18, 0x06,
  0x1C, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0x61, 0xC0,
  0x30, 0xC0, 0x18, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xE1, 0x87, 0xF0,
  0x03, 0xE0, 0x60, 0x18, 0x01, 0xE0, 0x18, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x03, 0xF7, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x00, 0xC1,
  0xE0, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x08, 0x00, 0x70, 0x1E,
  0x03, 0x80, 0x18, 0x1F, 0x00, 0xFF, 0x06, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x03, 0x81, 0xC0, 0xFF, 0x0E, 0x00,
  0x0C, 0x0E, 0x07, 0xFE, 0x38, 0x00, 0x70, 0x30, 0x7C, 0x3C, 0xE0, 0x01,
  0x81, 0xC3, 0xC0, 0x3B, 0x80, 0x0E, 0x0E, 0x0E, 0x00, 0xE6, 0x00, 0x70,
  0x70, 0x70, 0x01, 0x9C, 0x01, 0xC1, 0xC1, 0x80, 0x07, 0x78, 0x0E, 0x0E,
  0x0E, 0x00, 0x1C, 0xF9, 0xF0, 0x70, 0x30, 0x00, 0x71, 0xFF, 0x83, 0x81,
  0xC0, 0x01, 0xC3, 0xF8, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x1C,
  0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x87, 0x00, 0x00, 0x38, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x38, 0x00, 0x00, 0x78, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x38, 0x00, 0x00,
  0x07, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE3, 0x80, 0xE0, 0x00, 0x00, 0x0E,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x38, 0x01, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8C,
  0x30, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x06, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x07,
  0x8C, 0x00, 0x00, 0x07, 0xA0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x0C, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0xFF, 0xFF,
  0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0xF3, 0x80, 0xF8, 0xE0, 0x78, 0x30, 0x7C, 0x1C, 0x3C, 0x07,
  0x3E, 0x01, 0xCE, 0x00, 0x71, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x08, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x87, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xF8, 0x00, 0x06, 0x03, 0xFF, 0xC0, 0x03, 0x83, 0xFF, 0xFC,
  0x00, 0xE3, 0xE0, 0x0F, 0x80, 0x31, 0xE0, 0x00, 0xF0, 0x1C, 0xE0, 0x00,
  0x1E, 0x07, 0x70, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xC3, 0xC0,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x01, 0xB0, 0x0E, 0x00, 0x00, 0xEE, 0x01,
  0xE0, 0x00, 0x39, 0xC0, 0x1E, 0x00, 0x1E, 0x38, 0x01, 0xF0, 0x1F, 0x86,
  0x00, 0x1F, 0xFF, 0xC1, 0xC0, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x0F, 0xF8, 0xFE, 0x03, 0xC0, 0x07, 0x81, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x71, 0xC0, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0xC7, 0x00, 0x07, 0x80, 0x01, 0x80, 0x03, 0x38, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x0C, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x33, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xDC, 0x00, 0x38, 0x00, 0x03, 0x00, 0x03,
  0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0D, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x76, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x03, 0xB8,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x73, 0x80, 0x0C, 0x00, 0x03, 0xC0, 0x01, 0xCE, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x0E, 0x38, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x38, 0xE0, 0x03, 0x00,
  0x01, 0xF0, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x0D, 0xC0, 0x0F, 0x0E, 0x00,
  0x38, 0x00, 0x67, 0x00, 0x78, 0x38, 0x00, 0x70, 0x07, 0x8E, 0x03, 0xC0,
  0x60, 0x00, 0xF0, 0x7C, 0x3C, 0x3E, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xE3, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x08,
  0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00,
  0x00, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0x70, 0x00, 0x00, 0x00, 0x77, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x07, 0x60, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x98, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x06, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x71, 0x80, 0x00, 0x00,
  0x70, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x70, 0x01,
  0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x73, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x0F, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0xC0, 0x07, 0xFF, 0xE0, 0x60, 0x0F, 0x80, 0x38, 0x70,
  0x0F, 0x00, 0x0E, 0x38, 0x0F, 0x00, 0x03, 0x98, 0x0F, 0x00, 0x00, 0xCC,
  0x0F, 0x00, 0x00, 0x6E, 0x07, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1F, 0x03, 0x80,
  0x00, 0x0D, 0x81, 0xC0, 0x00, 0x0D, 0xC0, 0xF0, 0x00, 0x0C, 0xE0, 0x38,
  0x00, 0x0E, 0x60, 0x1E, 0x00, 0x0E, 0x30, 0x07, 0x80, 0x1E, 0x18, 0x01,
  0xE0, 0x3E, 0x1C, 0x00, 0x7F, 0xFC, 0x0E, 0x00, 0x1F, 0xF8, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0x00, 0x03,
  0x83, 0xFF, 0xF8, 0x00, 0x70, 0xF0, 0x0F, 0x80, 0x0C, 0x38, 0x00, 0x78,
  0x03, 0x8E, 0x00, 0x07, 0x00, 0x73, 0x00, 0x00, 0x70, 0x0E, 0xC0, 0x00,
  0x0E, 0x01, 0xB0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x1C, 0x0F, 0x80,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xB0, 0x00, 0x00, 0xE0, 0x36, 0x00,
  0x00, 0x38, 0x0E, 0x60, 0x00, 0x0F, 0x01, 0xCE, 0x00, 0x03, 0xC0, 0x30,
  0xE0, 0x01, 0xF0, 0x06, 0x1F, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xFE, 0x00,
  0x38, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x70,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x00, 0xFC, 0x01, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0x00,
  0x01, 0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x00,
  0x71, 0xC0, 0x07, 0x80, 0x00, 0xE6, 0x00, 0x3C, 0x00, 0x01, 0x98, 0x01,
  0xE0, 0x00, 0x03, 0x60, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x0E, 0x00, 0x00, 0x1B, 0x00, 0x38, 0x00, 0x00, 0xDC, 0x00, 0xF0, 0x00,
  0x06, 0x70, 0x01, 0xC0, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x01, 0xC6, 0x00,
  0x0F, 0x00, 0x1E, 0x18, 0x00, 0x1E, 0x01, 0xE0, 0x60, 0x00, 0x3F, 0xFF,
  0x03, 0x80, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x83, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x00, 0x0F, 0xFF,
  0x01, 0x80, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x3E, 0x00, 0x70, 0x60, 0x03,
  0xC0, 0x01, 0xC7, 0x00, 0x3C, 0x00, 0x07, 0x38, 0x03, 0xC0, 0x00, 0x19,
  0x80, 0x3C, 0x00, 0x00, 0x6C, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1C, 0x00,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x01, 0xB0, 0x07, 0x00, 0x00, 0x1B, 0x80, 0x3C, 0x00, 0x01, 0xDC,
  0x00, 0xE0, 0x00, 0x1C, 0xE0, 0x07, 0x80, 0x03, 0xC6, 0x00, 0x1E, 0x00,
  0x3C, 0x70, 0x00, 0x78, 0x07, 0x83, 0x80, 0x01, 0xFF, 0xF8, 0x1C, 0x00,
  0x07, 0xFF, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00,
  0x38, 0x0F, 0xFF, 0x00, 0x0E, 0x0F, 0xFF, 0xE0, 0x03, 0x07, 0x80, 0x3C,
  0x00, 0xC3, 0x80, 0x07, 0x80, 0x71, 0xC0, 0x00, 0xE0, 0x1C, 0xE0, 0x00,
  0x1C, 0x07, 0x70, 0x00, 0x07, 0x01, 0xB8, 0x00, 0x01, 0xC0, 0xFC, 0x00,
  0x00, 0x70, 0x3E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x3E,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x18, 0x07, 0x80,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x03, 0x07, 0x80, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01, 0xC7, 0x70,
  0x00, 0x00, 0xE7, 0x38, 0x00, 0x00, 0x67, 0x0E, 0x00, 0x00, 0x37, 0x07,
  0x00, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x06, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x0C, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x77, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x80, 0xCC, 0x00, 0x03, 0x38, 0x00, 0x07, 0x01,
  0xB0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x0C, 0x0F, 0xFF, 0xE0, 0x03, 0x07,
  0xC0, 0x3C, 0x00, 0xC3, 0x80, 0x07, 0x80, 0x71, 0xC0, 0x00, 0xE0, 0x1C,
  0xE0, 0x00, 0x1C, 0x06, 0x70, 0x00, 0x07, 0x01, 0xB8, 0x00, 0x01, 0xC0,
  0xEC, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x1F,
  0xFC, 0x00, 0x01, 0x81, 0xFF, 0xFC, 0x00, 0x06, 0x0F, 0x00, 0xF8, 0x00,
  0x18, 0x70, 0x00, 0xF0, 0x00, 0xE3, 0x80, 0x01, 0xC0, 0x03, 0x9C, 0x00,
  0x03, 0x80, 0x0C, 0xE0, 0x00, 0x0E, 0x00, 0x37, 0x00, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xB0, 0x00, 0x00, 0xE0,
  0x06, 0xC0, 0x00, 0x07, 0x00, 0x39, 0x80, 0x00, 0x3C, 0x00, 0xE7, 0x00,
  0x01, 0xE0, 0x03, 0x8E, 0x00, 0x1F, 0x00, 0x0E, 0x1E, 0x01, 0xF8, 0x00,
  0x30, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x3F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00,
  0xFF, 0xF0, 0x18, 0x00, 0x7F, 0xFF, 0x03, 0x00, 0x3E, 0x00, 0xF0, 0x60,
  0x0F, 0x00, 0x07, 0x1C, 0x03, 0xC0, 0x00, 0x73, 0x80, 0xF0, 0x00, 0x06,
  0x60, 0x3C, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00,
  0x1B, 0x80, 0xF0, 0x00, 0x06, 0x70, 0x0E, 0x00, 0x01, 0xCE, 0x01, 0xE0,
  0x00, 0x71, 0x80, 0x1E, 0x00, 0x3C, 0x70, 0x01, 0xE0, 0x1E, 0x0E, 0x00,
  0x1F, 0xFF, 0x81, 0xC0, 0x01, 0xFF, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x1C, 0x07, 0xFC, 0x03, 0x03, 0xFF, 0x80, 0x60, 0xF0,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x20, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x08, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xF0, 0x38, 0x00,
  0x00, 0xD8, 0x0E, 0x00, 0x00, 0x76, 0x03, 0x80, 0x00, 0x3B, 0x80, 0xE0,
  0x00, 0x1C, 0xE0, 0x1C, 0x00, 0x0E, 0x38, 0x07, 0x80, 0x0F, 0x0C, 0x00,
  0xF0, 0x0F, 0x83, 0x00, 0x1F, 0xFF, 0x81, 0xC0, 0x03, 0xFF, 0xC0, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x60, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x73, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC6, 0x00,
  0x07, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x60, 0x00,
  0xE0, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x01, 0x80, 0x06, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x80,
  0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x31, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x13, 0xFF, 0xFC, 0x00, 0x1D, 0xE0, 0x0F,
  0xC0, 0x0E, 0xE0, 0x00, 0xFE, 0x1F, 0x20, 0x00, 0x0F, 0xFF, 0x88, 0x00,
  0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 15, 52, 16, 2, -51 },
  { 99, 17, 18, 24, 8, -51 },
  { 138, 43, 51, 45, 2, -51 },
  { 413, 34, 59, 40, 3, -55 },
  { 664, 46, 53, 55, 6, -52 },
  { 969, 43, 53, 49, 3, -52 },
  { 1254, 6, 18, 13, 8, -51 },
  { 1268, 21, 62, 18, 2, -51 },
  { 1431, 21, 62, 18, -5, -51 },
  { 1594, 30, 31, 39, 9, -55 },
  { 1711, 34, 33, 41, 5, -42 },
  { 1852, 10, 17, 14, -3, -8 },
  { 1874, 17, 3, 22, 3, -21 },
  { 1881, 5, 6, 16, 2, -5 },
  { 1885, 32, 51, 23, -3, -51 },
  { 2089, 33, 53, 40, 5, -52 },
  { 2308, 18, 51, 40, 12, -51 },
  { 2423, 36, 52, 40, 1, -52 },
  { 2657, 36, 53, 40, 2, -52 },
  { 2896, 37, 52, 40, 1, -52 },
  { 3137, 36, 52, 40, 3, -51 },
  { 3371, 34, 53, 40, 5, -52 },
  { 3597, 32, 51, 40, 8, -51 },
  { 3801, 35, 53, 40, 3, -52 },
  { 4033, 35, 53, 40, 3, -52 },
  { 4265, 12, 40, 16, 2, -39 },
  { 4325, 17, 48, 16, -3, -39 },
  { 4427, 34, 32, 41, 5, -42 },
  { 4563, 34, 17, 41, 5, -34 },
  { 4636, 34, 32, 41, 5, -42 },
  { 4772, 25, 53, 29, 6, -52 },
  { 4938, 54, 57, 60, 4, -51 },
  { 5323, 40, 52, 40, -4, -52 },
  { 5583, 39, 51, 43, 3, -51 },
  { 5832, 40, 53, 43, 6, -52 },
  { 6097, 43, 51, 49, 3, -51 },
  { 6372, 37, 51, 38, 3, -51 },
  { 6608, 37, 51, 35, 3, -51 },
  { 6844, 42, 53, 50, 6, -52 },
  { 7123, 46, 51, 49, 3, -51 },
  { 7417, 24, 51, 21, 0, -51 },
  { 7570, 29, 64, 17, -12, -51 },
  { 7802, 43, 51, 39, 3, -51 },
  { 8077, 27, 51, 35, 3, -51 },
  { 8250, 55, 51, 59, 3, -51 },
  { 8601, 46, 51, 49, 3, -51 },
  { 8895, 43, 53, 52, 6, -52 },
  { 9180, 37, 51, 40, 3, -51 },
  { 9416, 43, 64, 52, 6, -52 },
  { 9760, 37, 51, 41, 3, -51 },
  { 9996, 36, 53, 36, 1, -52 },
  { 10235, 35, 51, 35, 7, -51 },
  { 10459, 44, 52, 50, 6, -51 },
  { 10745, 37, 51, 39, 7, -51 },
  { 10981, 56, 51, 60, 9, -51 },
  { 11338, 45, 51, 36, -4, -51 },
  { 11625, 35, 51, 35, 7, -51 },
  { 11849, 42, 51, 39, -1, -51 },
  { 12117, 28, 62, 22, -1, -51 },
  { 12334, 12, 51, 23, 7, -51 },
  { 12411, 27, 62, 22, -5, -51 },
  { 12621, 34, 32, 40, 3, -52 },
  { 12757, 27, 2, 27, -6, 8 },
  { 12764, 8, 11, 17, 11, -55 },
  { 12775, 33, 40, 40, 4, -39 },
  { 12940, 35, 56, 41, 2, -55 },
  { 13185, 29, 40, 33, 4, -39 },
  { 13330, 38, 56, 41, 4, -55 },
  { 13596, 29, 40, 36, 4, -39 },
  { 13741, 39, 72, 20, -9, -55 },
  { 14092, 37, 56, 41, 2, -39 },
  { 14351, 34, 55, 40, 2, -55 },
  { 14585, 14, 52, 16, 2, -52 },
  { 14676, 26, 69, 16, -10, -52 },
  { 14901, 33, 55, 32, 2, -55 },
  { 15128, 15, 55, 16, 2, -55 },
  { 15232, 55, 39, 61, 2, -39 },
  { 15501, 34, 39, 40, 2, -39 },
  { 15667, 33, 40, 41, 4, -39 },
  { 15832, 38, 56, 41, -1, -39 },
  { 16098, 35, 56, 41, 4, -39 },
  { 16343, 27, 39, 27, 2, -39 },
  { 16475, 28, 40, 31, 1, -39 },
  { 16615, 20, 48, 23, 4, -47 },
  { 16735, 34, 39, 40, 4, -38 },
  { 16901, 30, 38, 30, 4, -38 },
  { 17044, 46, 38, 48, 4, -38 },
  { 17263, 36, 38, 33, -2, -38 },
  { 17434, 42, 55, 30, -8, -38 },
  { 17723, 32, 38, 32, -1, -38 },
  { 17875, 26, 62, 24, 2, -51 },
  { 18077, 2, 72, 39, 20, -55 },
  { 18095, 26, 62, 24, -3, -51 },
  { 18297, 34, 7, 41, 5, -29 },
};

const GFXfont NotoSans_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRALIGHTITALIC72PT7B_H_
