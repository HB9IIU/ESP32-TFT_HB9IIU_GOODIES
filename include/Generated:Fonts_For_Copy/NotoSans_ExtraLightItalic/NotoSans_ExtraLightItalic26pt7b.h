#ifndef _NOTOSANS_EXTRALIGHTITALIC26PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x00, 0x06,
  0x20, 0x45, 0x14, 0xA2, 0x8A, 0x28, 0x80, 0x01, 0x04, 0x02, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x1F, 0xFF, 0x82, 0x08, 0x04, 0x20,
  0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC2, 0x08, 0x04, 0x10, 0x08,
  0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x00, 0x00, 0x80, 0x08, 0x01, 0x80,
  0xEF, 0x19, 0x01, 0x10, 0x21, 0x03, 0x10, 0x11, 0x00, 0xA0, 0x07, 0x00,
  0x3C, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x04, 0x4C, 0x58, 0x3E, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x01, 0x19, 0x01, 0x08, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x84, 0x08, 0x82, 0x08, 0x81, 0x04, 0x40, 0x82, 0x4F, 0x42,
  0x48, 0x93, 0x48, 0x26, 0x24, 0x10, 0x22, 0x08, 0x22, 0x08, 0x21, 0x04,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x21, 0x10, 0x0F, 0x00, 0x01, 0xC0, 0x06,
  0x30, 0x04, 0x10, 0x08, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x20, 0x04,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x11, 0x01, 0x60, 0x82, 0x40, 0x42, 0x80,
  0x44, 0x80, 0x28, 0x80, 0x10, 0x80, 0x38, 0x40, 0xC8, 0x3F, 0x04, 0x56,
  0xA8, 0x02, 0x08, 0x30, 0x41, 0x06, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x18, 0x00, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x40,
  0x08, 0x62, 0x03, 0x40, 0x1F, 0xC3, 0x00, 0x90, 0x22, 0x08, 0x40, 0x04,
  0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x32, 0x24, 0x48, 0xFC, 0xE0,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x00, 0x07, 0x80, 0x86, 0x10, 0x22, 0x03, 0x20, 0x14, 0x01,
  0x40, 0x1C, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x0C, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x02, 0x1C, 0x53, 0x28,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x80, 0x01, 0xE0, 0x30, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0x61, 0x84,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x78,
  0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x44,
  0x06, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x1A, 0x00, 0xD0,
  0x06, 0x40, 0x11, 0x00, 0x84, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x08,
  0x40, 0x23, 0xFF, 0xF0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x07, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x01, 0xF0, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x20, 0x5D, 0x8A, 0x04, 0xC0,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x18, 0x3E,
  0x00, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x21, 0x82, 0x06, 0x20,
  0x11, 0x00, 0x88, 0x0C, 0x40, 0x41, 0x04, 0x06, 0xC0, 0x38, 0x06, 0x30,
  0x40, 0xC4, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x40, 0x23, 0x06, 0x0F,
  0xE0, 0x03, 0xC0, 0x61, 0x04, 0x04, 0x60, 0x22, 0x01, 0x10, 0x04, 0x80,
  0x24, 0x02, 0x20, 0x11, 0x01, 0x84, 0x34, 0x1E, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x18, 0x3F, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC8, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x20, 0x84, 0x10, 0x80, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x08,
  0x00, 0x1E, 0x30, 0x80, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x06, 0x06,
  0x04, 0x04, 0x02, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xFF, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x12,
  0x07, 0xE1, 0x40, 0x82, 0x14, 0x10, 0x41, 0x42, 0x04, 0x14, 0x20, 0x41,
  0x84, 0x04, 0x18, 0x40, 0x82, 0x84, 0x08, 0x24, 0x21, 0x84, 0x43, 0xE7,
  0x84, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x20, 0x00, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x90, 0x06, 0x40,
  0x11, 0x00, 0x84, 0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0xFE, 0x18, 0x08,
  0x40, 0x22, 0x00, 0x88, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x40, 0x0F,
  0x80, 0x20, 0xE0, 0x80, 0xC2, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x02, 0x30, 0x70, 0xFF, 0x02, 0x03, 0x08, 0x06, 0x20, 0x09, 0x00, 0x24,
  0x00, 0x90, 0x04, 0x40, 0x31, 0x01, 0x8F, 0xF8, 0x00, 0x00, 0xF8, 0x1C,
  0x10, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x08, 0x78, 0x08,
  0x0C, 0x08, 0x06, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x03, 0x30,
  0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40,
  0x0C, 0x40, 0x18, 0x40, 0x30, 0x40, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xFF, 0x82, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x03, 0xFE, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x0E, 0x0C, 0x30, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x03, 0xF4, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x60, 0x30, 0x7F, 0x80, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x02,
  0x1F, 0xFF, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x00, 0x0F, 0x81,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x3E, 0x00, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x0B,
  0x83, 0x00, 0x08, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x81, 0x02, 0x02,
  0x18, 0x04, 0x60, 0x09, 0x80, 0x36, 0x00, 0x54, 0x00, 0xC4, 0x01, 0x08,
  0x02, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x60, 0x80, 0x42,
  0x00, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0F, 0xFC, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x50, 0xC0, 0x06,
  0x14, 0x00, 0xA1, 0x40, 0x1A, 0x12, 0x01, 0x21, 0x20, 0x22, 0x22, 0x02,
  0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20, 0x84, 0x21, 0x10, 0xC4, 0x11,
  0x08, 0x41, 0x20, 0x84, 0x12, 0x08, 0x41, 0x40, 0x84, 0x08, 0x10, 0x80,
  0x81, 0x00, 0x08, 0x00, 0x86, 0x00, 0x83, 0x00, 0x42, 0x80, 0x21, 0x20,
  0x10, 0x90, 0x08, 0x44, 0x08, 0x22, 0x04, 0x21, 0x02, 0x10, 0x41, 0x08,
  0x21, 0x84, 0x08, 0x82, 0x04, 0x42, 0x03, 0x21, 0x00, 0x90, 0x80, 0x50,
  0x40, 0x18, 0x20, 0x0C, 0x20, 0x02, 0x00, 0x01, 0xF0, 0x06, 0x18, 0x18,
  0x04, 0x10, 0x02, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0xC0,
  0x04, 0x40, 0x08, 0x60, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x0F, 0x80, 0x21,
  0xC0, 0x80, 0x82, 0x02, 0x10, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x02, 0x30,
  0x18, 0x80, 0xC3, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x18, 0x18,
  0x04, 0x10, 0x02, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0xC0,
  0x04, 0x40, 0x08, 0x60, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x0F, 0x80, 0x21, 0xC0, 0x80, 0x82, 0x02,
  0x10, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x02, 0x30, 0x10, 0x81, 0x83, 0xF8,
  0x08, 0x20, 0x20, 0x81, 0x03, 0x04, 0x04, 0x10, 0x10, 0x40, 0x21, 0x00,
  0x88, 0x03, 0x00, 0x01, 0xF0, 0x30, 0xC2, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x64, 0x06, 0x1F, 0xE0, 0x7F, 0xFC,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x10, 0x40, 0x30, 0x60, 0x60, 0x3F, 0x80, 0x80, 0x0C, 0x00, 0xA0, 0x05,
  0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10,
  0xC0, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20, 0x05, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x42, 0x20,
  0x84, 0x62, 0x10, 0x44, 0x21, 0x04, 0x41, 0x20, 0x48, 0x12, 0x04, 0x81,
  0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x10,
  0xC0, 0x08, 0x40, 0x04, 0x40, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x28, 0x00, 0x22, 0x00, 0x21, 0x00, 0x20, 0x40, 0x30, 0x20,
  0x10, 0x10, 0x10, 0x04, 0x30, 0x02, 0x00, 0xC0, 0x0A, 0x00, 0x90, 0x0C,
  0x80, 0x42, 0x04, 0x10, 0x60, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x88, 0x44, 0x44,
  0x44, 0x22, 0x22, 0x21, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F, 0x80, 0x00, 0x80,
  0x18, 0x02, 0x80, 0x24, 0x04, 0x40, 0x84, 0x08, 0x21, 0x02, 0x30, 0x22,
  0x01, 0x40, 0x1C, 0x01, 0xFF, 0xC0, 0x99, 0x10, 0x07, 0x88, 0xC2, 0x8C,
  0x0C, 0x40, 0x64, 0x03, 0x20, 0x11, 0x00, 0x98, 0x04, 0x80, 0x24, 0x03,
  0x20, 0x10, 0x81, 0x84, 0x14, 0x1F, 0x20, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x13, 0xC2, 0x42, 0x28, 0x13, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x03, 0x40, 0x2C, 0x04, 0xA0, 0xC9,
  0xF0, 0x07, 0xE3, 0x04, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x78, 0x86, 0x1A, 0x30,
  0x30, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x61, 0x02, 0x84, 0x14, 0x0F, 0x90, 0x0F, 0x84, 0x32, 0x05,
  0x01, 0xC0, 0x60, 0x69, 0xE3, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x8F, 0xC0, 0x00, 0x3C, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0xFE, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x03, 0x80, 0x00,
  0x07, 0xC8, 0xC3, 0x4C, 0x0C, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x18, 0x81, 0x44, 0x14, 0x1F, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x20, 0x41, 0xFC, 0x00, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x13, 0xE2, 0x43, 0x28, 0x13, 0x01,
  0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x08, 0xC0, 0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x08, 0x84, 0x20, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0xF0, 0x00, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x32, 0x04, 0x20,
  0x82, 0x10, 0x22, 0x02, 0x40, 0x4C, 0x05, 0x40, 0x66, 0x04, 0x20, 0x43,
  0x08, 0x10, 0x81, 0x88, 0x08, 0x08, 0x46, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x00, 0x13, 0xC3, 0xC2, 0x46, 0x42, 0x28,
  0x28, 0x23, 0x03, 0x01, 0x20, 0x20, 0x22, 0x02, 0x02, 0x40, 0x20, 0x24,
  0x04, 0x02, 0x40, 0x40, 0x24, 0x04, 0x04, 0x40, 0x40, 0x48, 0x04, 0x04,
  0x80, 0x80, 0x48, 0x08, 0x0C, 0x13, 0xE2, 0x43, 0x28, 0x13, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x80,
  0x48, 0x04, 0x07, 0xC1, 0x82, 0x30, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x40, 0x24, 0x04, 0x60, 0xC3, 0xF0, 0x09,
  0xE0, 0x90, 0x85, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0xC8, 0x04, 0xC0, 0x45, 0x06, 0x27, 0xC1, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x07, 0xC8, 0xC3, 0x4C,
  0x0C, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x18, 0x81, 0x44, 0x14, 0x1F, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x13, 0x92, 0x0A, 0x06, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xC4, 0x12,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x81, 0x1F, 0x80, 0x10, 0x10, 0x10, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xC0, 0x78, 0x30, 0x09, 0x00, 0x88,
  0x04, 0x40, 0x22, 0x01, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x03,
  0x20, 0x11, 0x01, 0x84, 0x14, 0x3F, 0x20, 0x80, 0x30, 0x0D, 0x01, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x46, 0x04, 0x80, 0xA0, 0x14, 0x03,
  0x00, 0x60, 0x00, 0x80, 0x80, 0xC0, 0x40, 0xD0, 0x60, 0x48, 0x28, 0x24,
  0x24, 0x22, 0x12, 0x11, 0x11, 0x10, 0x88, 0x88, 0x48, 0x48, 0x24, 0x24,
  0x14, 0x14, 0x0A, 0x0A, 0x06, 0x06, 0x03, 0x01, 0x00, 0x10, 0x08, 0x40,
  0x82, 0x08, 0x08, 0xC0, 0x4C, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x05, 0x00,
  0x44, 0x04, 0x20, 0x40, 0x86, 0x04, 0x60, 0x30, 0x08, 0x02, 0x10, 0x0C,
  0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10, 0x02,
  0x20, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x07, 0x80, 0x00, 0x1F, 0xE0,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x83, 0x81, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x08, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x30, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x01,
  0x83, 0x80, 0xFC, 0x18, 0x3E,
};

const GFXglyph NotoSans_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 9, 3, -19 },
  { 19, 15, 19, 16, 1, -19 },
  { 55, 12, 22, 14, 1, -20 },
  { 88, 17, 19, 20, 2, -19 },
  { 129, 16, 19, 18, 1, -19 },
  { 167, 2, 7, 5, 3, -19 },
  { 169, 7, 23, 7, 1, -19 },
  { 190, 8, 23, 7, -2, -19 },
  { 213, 11, 11, 14, 3, -20 },
  { 229, 12, 12, 15, 2, -15 },
  { 247, 4, 6, 5, -1, -3 },
  { 250, 6, 1, 8, 1, -8 },
  { 251, 2, 2, 6, 1, -2 },
  { 252, 11, 19, 8, -1, -19 },
  { 279, 12, 19, 14, 2, -19 },
  { 308, 7, 19, 14, 4, -19 },
  { 325, 13, 19, 14, 0, -19 },
  { 356, 13, 19, 14, 1, -19 },
  { 387, 14, 19, 14, 0, -19 },
  { 421, 13, 19, 14, 1, -19 },
  { 452, 12, 19, 14, 2, -19 },
  { 481, 12, 19, 14, 3, -19 },
  { 510, 13, 19, 14, 1, -19 },
  { 541, 13, 19, 14, 1, -19 },
  { 572, 4, 14, 6, 1, -14 },
  { 579, 6, 17, 6, -1, -14 },
  { 592, 12, 12, 15, 2, -15 },
  { 610, 12, 6, 15, 2, -12 },
  { 619, 12, 12, 15, 2, -15 },
  { 637, 9, 19, 11, 2, -19 },
  { 659, 20, 20, 22, 1, -18 },
  { 709, 14, 19, 14, -1, -19 },
  { 743, 14, 19, 16, 1, -19 },
  { 777, 14, 19, 15, 2, -19 },
  { 811, 16, 19, 18, 1, -19 },
  { 849, 14, 19, 14, 1, -19 },
  { 883, 14, 19, 13, 1, -19 },
  { 917, 15, 19, 18, 2, -19 },
  { 953, 17, 19, 18, 1, -19 },
  { 994, 9, 19, 7, 0, -19 },
  { 1016, 10, 24, 6, -4, -19 },
  { 1046, 15, 19, 14, 1, -19 },
  { 1082, 10, 19, 13, 1, -19 },
  { 1106, 20, 19, 21, 1, -19 },
  { 1154, 17, 19, 18, 1, -19 },
  { 1195, 16, 19, 19, 2, -19 },
  { 1233, 14, 19, 15, 1, -19 },
  { 1267, 16, 23, 19, 2, -19 },
  { 1313, 14, 19, 15, 1, -19 },
  { 1347, 13, 19, 13, 0, -19 },
  { 1378, 13, 19, 13, 2, -19 },
  { 1409, 16, 19, 18, 2, -19 },
  { 1447, 13, 19, 14, 3, -19 },
  { 1478, 20, 19, 22, 3, -19 },
  { 1526, 17, 19, 13, -2, -19 },
  { 1567, 13, 19, 13, 2, -19 },
  { 1598, 15, 19, 14, 0, -19 },
  { 1634, 10, 23, 8, 0, -19 },
  { 1663, 4, 19, 8, 3, -19 },
  { 1673, 10, 23, 8, -2, -19 },
  { 1702, 12, 12, 14, 1, -19 },
  { 1720, 10, 1, 10, -2, 3 },
  { 1722, 3, 4, 6, 4, -20 },
  { 1724, 13, 14, 14, 1, -14 },
  { 1747, 12, 20, 15, 1, -20 },
  { 1777, 11, 14, 12, 1, -14 },
  { 1797, 14, 20, 15, 1, -20 },
  { 1832, 10, 14, 13, 2, -14 },
  { 1850, 14, 26, 7, -3, -20 },
  { 1896, 13, 20, 15, 1, -14 },
  { 1929, 12, 20, 15, 1, -20 },
  { 1959, 5, 19, 6, 1, -19 },
  { 1971, 10, 25, 6, -4, -19 },
  { 2003, 12, 20, 12, 1, -20 },
  { 2033, 5, 20, 6, 1, -20 },
  { 2046, 20, 14, 22, 1, -14 },
  { 2081, 12, 14, 15, 1, -14 },
  { 2102, 12, 14, 15, 1, -14 },
  { 2123, 13, 20, 15, 0, -14 },
  { 2156, 13, 20, 15, 1, -14 },
  { 2189, 9, 14, 10, 1, -14 },
  { 2205, 10, 14, 11, 0, -14 },
  { 2223, 8, 17, 8, 1, -17 },
  { 2240, 13, 14, 15, 1, -14 },
  { 2263, 11, 14, 11, 1, -14 },
  { 2283, 17, 14, 17, 1, -14 },
  { 2313, 13, 14, 12, -1, -14 },
  { 2336, 15, 20, 11, -3, -14 },
  { 2374, 11, 14, 11, 0, -14 },
  { 2394, 9, 23, 9, 1, -19 },
  { 2420, 1, 26, 14, 7, -20 },
  { 2424, 9, 23, 9, -1, -19 },
  { 2450, 12, 2, 15, 2, -10 },
};

const GFXfont NotoSans_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRALIGHTITALIC26PT7B_H_
