#ifndef _NOTOSANS_EXTRALIGHTITALIC19PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x4A, 0x01, 0x00, 0x4A, 0xA5, 0x29, 0x00, 0x04,
  0x41, 0x10, 0x22, 0x04, 0x40, 0x88, 0xEE, 0xC4, 0x40, 0x88, 0x22, 0x1F,
  0xF8, 0x88, 0x11, 0x04, 0x40, 0x88, 0x00, 0x04, 0x0F, 0x89, 0x24, 0x84,
  0x41, 0x40, 0x60, 0x18, 0x0A, 0x04, 0x84, 0x42, 0x4F, 0xC0, 0x80, 0x80,
  0x30, 0x24, 0x84, 0x88, 0x48, 0x88, 0x89, 0x08, 0xA0, 0x92, 0xE9, 0x51,
  0x69, 0x11, 0x21, 0x12, 0x22, 0x22, 0x42, 0x28, 0x1C, 0x0F, 0x02, 0x10,
  0x42, 0x08, 0x41, 0x10, 0x24, 0x03, 0x01, 0xA0, 0x44, 0x30, 0x4A, 0x05,
  0x40, 0x48, 0x38, 0xF8, 0x80, 0x5A, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0xC0, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x21, 0x10, 0x88, 0x80, 0x08, 0x88, 0x68, 0x17, 0x18, 0x28, 0x44,
  0x04, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x29, 0x40, 0xF0, 0x80, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x00, 0x0E, 0x08, 0x88, 0x28,
  0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0x23, 0xE0,
  0x09, 0xD3, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x20, 0x07, 0x06, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x3F, 0xC0, 0x07, 0x06, 0x30, 0x04, 0x01, 0x00, 0x40, 0x20, 0xF0,
  0x4C, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x3F, 0x80, 0x00, 0x40, 0x20,
  0x18, 0x0A, 0x04, 0x82, 0x21, 0x08, 0x84, 0x41, 0x10, 0x4B, 0xFC, 0x08,
  0x02, 0x00, 0x80, 0x1F, 0x88, 0x08, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x27, 0xE0, 0x07, 0x84, 0x04, 0x04, 0x04,
  0x02, 0x61, 0xC8, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x24, 0x21, 0xE0, 0xFF,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x12, 0x08, 0x88, 0x38, 0x6C,
  0x41, 0x40, 0xA0, 0x50, 0x28, 0x23, 0xE0, 0x0E, 0x18, 0x88, 0x28, 0x14,
  0x0A, 0x05, 0x06, 0x85, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x47, 0xC0, 0x60,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00, 0x00, 0x22, 0x11, 0x00, 0x01,
  0x83, 0x06, 0x0C, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x30, 0x61, 0xC0, 0x7A,
  0x10, 0x41, 0x04, 0x21, 0x08, 0x42, 0x08, 0x00, 0x02, 0x00, 0x0F, 0xF0,
  0x40, 0x22, 0x00, 0x50, 0x71, 0x46, 0x26, 0x21, 0x18, 0x84, 0x62, 0x11,
  0x90, 0x46, 0x22, 0x28, 0xF7, 0x10, 0x00, 0x40, 0x00, 0xC1, 0x00, 0xF8,
  0x00, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x48, 0x09, 0x02, 0x10, 0x42,
  0x1F, 0xC2, 0x08, 0x81, 0x20, 0x24, 0x05, 0x00, 0x40, 0x1F, 0x08, 0x22,
  0x04, 0x81, 0x20, 0x48, 0x27, 0xF1, 0x04, 0x40, 0x90, 0x24, 0x0A, 0x02,
  0x81, 0x3F, 0x80, 0x07, 0x86, 0x12, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x0F, 0xC0, 0x1E, 0x04, 0x30,
  0x81, 0x10, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01,
  0x40, 0x48, 0x31, 0xF8, 0x00, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x07, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x3F, 0x80, 0x1F,
  0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0x83, 0x0C, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x3E, 0x80, 0x50, 0x12, 0x02, 0x40, 0x44, 0x08, 0x7E,
  0x00, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x7F, 0xE4,
  0x02, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x88, 0x08, 0x1C, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0xC0, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0xF0, 0x10, 0x24, 0x08, 0x82, 0x10, 0x82, 0x60, 0x50, 0x16, 0x03,
  0x40, 0x44, 0x08, 0x81, 0x08, 0x41, 0x08, 0x11, 0x02, 0x00, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x1F, 0xC0, 0x10,
  0x04, 0x40, 0x13, 0x00, 0xCC, 0x05, 0x28, 0x14, 0xA0, 0xA4, 0x82, 0x92,
  0x12, 0x48, 0x89, 0x22, 0x24, 0x51, 0x21, 0x44, 0x86, 0x12, 0x10, 0x40,
  0x10, 0x11, 0x01, 0x30, 0x12, 0x82, 0x28, 0x22, 0x42, 0x44, 0x24, 0x42,
  0x42, 0x44, 0x24, 0x41, 0x48, 0x14, 0x80, 0x88, 0x08, 0x0F, 0x06, 0x19,
  0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01,
  0x40, 0x44, 0x10, 0x7C, 0x00, 0x1E, 0x08, 0x62, 0x04, 0x81, 0x20, 0x48,
  0x24, 0x09, 0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F,
  0x06, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x40, 0x44, 0x10, 0x7C, 0x01, 0x00, 0x20, 0x02, 0x00, 0x1E,
  0x08, 0x62, 0x04, 0x81, 0x20, 0x48, 0x24, 0x19, 0xF8, 0x44, 0x10, 0x84,
  0x22, 0x08, 0x81, 0x20, 0x40, 0x07, 0x86, 0x12, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x3F, 0x80, 0xFF,
  0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x00, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48, 0x10, 0xFC, 0x00, 0x80,
  0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x84, 0x21, 0x10, 0x48, 0x12, 0x05,
  0x01, 0x40, 0x60, 0x08, 0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x18,
  0x28, 0x48, 0x90, 0x91, 0x22, 0x24, 0x44, 0x48, 0x50, 0x90, 0xA1, 0x41,
  0x82, 0x83, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x00, 0x10, 0x11, 0x02, 0x08,
  0x40, 0x88, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60, 0x0A, 0x01, 0x10, 0x11,
  0x02, 0x10, 0x40, 0x88, 0x08, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x42, 0x21,
  0x20, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1F, 0xE0, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0xFE, 0x00, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x92, 0x48, 0x92, 0x49,
  0x12, 0x40, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0xE0, 0x04, 0x02, 0x02, 0x82, 0x41, 0x11, 0x09,
  0x04, 0x82, 0x80, 0x80, 0xFF, 0xA4, 0x1E, 0x90, 0xD0, 0x50, 0x28, 0x14,
  0x0A, 0x05, 0x04, 0x86, 0x3D, 0x00, 0x20, 0x10, 0x08, 0x04, 0x05, 0xF3,
  0x05, 0x02, 0x81, 0x40, 0xC0, 0x60, 0x50, 0x2C, 0x25, 0xE0, 0x1F, 0x20,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x1E, 0x88, 0x64, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x85,
  0x1E, 0x80, 0x1E, 0x21, 0x41, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x40, 0x7C,
  0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x07, 0xC0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x03,
  0x00, 0x0F, 0x44, 0x32, 0x05, 0x02, 0x40, 0x90, 0x24, 0x09, 0x06, 0x43,
  0x0F, 0x40, 0x10, 0x04, 0x02, 0x31, 0x03, 0x80, 0x20, 0x20, 0x20, 0x20,
  0x5F, 0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x24, 0x04,
  0x92, 0x52, 0x49, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x43, 0x00, 0x20, 0x20, 0x20,
  0x20, 0x41, 0x42, 0x44, 0x48, 0x70, 0xD0, 0x88, 0x88, 0x84, 0x86, 0x24,
  0x94, 0x92, 0x52, 0x49, 0x00, 0x5E, 0x79, 0x86, 0x14, 0x10, 0x50, 0x41,
  0x41, 0x06, 0x08, 0x18, 0x20, 0xA0, 0x82, 0x82, 0x0A, 0x08, 0x20, 0x5F,
  0x30, 0x50, 0x28, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x00, 0x1E,
  0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x82, 0x3E, 0x00, 0x2F,
  0x8C, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0x02, 0x61, 0x17, 0x88,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x90, 0xD0, 0x30, 0x18, 0x14, 0x0A,
  0x05, 0x06, 0x86, 0x3D, 0x00, 0x80, 0x40, 0x20, 0x20, 0x5E, 0xC1, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F, 0x20, 0x40, 0x20, 0x10, 0x0C,
  0x02, 0x02, 0x04, 0xFC, 0x21, 0x09, 0xF4, 0x21, 0x08, 0x84, 0x21, 0x0E,
  0x00, 0x40, 0xA0, 0x50, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x86, 0x3D,
  0x00, 0x81, 0x82, 0x82, 0x84, 0x88, 0x48, 0x50, 0x50, 0x60, 0x40, 0x86,
  0x18, 0x61, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0x43,
  0x04, 0x10, 0x10, 0x44, 0x20, 0x90, 0x28, 0x04, 0x03, 0x01, 0x20, 0x88,
  0x21, 0x30, 0x40, 0x10, 0x22, 0x08, 0x41, 0x08, 0x40, 0x90, 0x12, 0x02,
  0x80, 0x50, 0x0C, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00,
  0x3F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0xFE, 0x02, 0x18,
  0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x30, 0xFF, 0xFF, 0xE0, 0x18, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x06,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0xC0, 0x70, 0x47, 0xC0,
};

const GFXglyph NotoSans_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 4, 1, -14 },
  { 7, 5, 5, 6, 2, -14 },
  { 11, 11, 14, 12, 1, -14 },
  { 31, 9, 15, 10, 1, -14 },
  { 48, 12, 14, 15, 2, -14 },
  { 69, 11, 14, 13, 1, -14 },
  { 89, 2, 5, 3, 2, -14 },
  { 91, 5, 17, 5, 1, -14 },
  { 102, 5, 17, 5, -1, -14 },
  { 113, 8, 8, 10, 2, -14 },
  { 121, 9, 9, 11, 1, -11 },
  { 132, 3, 4, 4, -1, -2 },
  { 134, 4, 1, 6, 1, -6 },
  { 135, 1, 1, 4, 1, -1 },
  { 136, 9, 14, 6, -1, -14 },
  { 152, 9, 14, 10, 1, -14 },
  { 168, 5, 14, 10, 3, -14 },
  { 177, 10, 14, 10, 0, -14 },
  { 195, 10, 14, 10, 0, -14 },
  { 213, 10, 14, 10, 0, -14 },
  { 231, 9, 14, 10, 1, -14 },
  { 247, 9, 14, 10, 1, -14 },
  { 263, 9, 14, 10, 2, -14 },
  { 279, 9, 14, 10, 1, -14 },
  { 295, 9, 14, 10, 1, -14 },
  { 311, 3, 10, 4, 1, -10 },
  { 315, 5, 12, 4, -1, -10 },
  { 323, 9, 8, 11, 1, -11 },
  { 332, 9, 5, 11, 1, -9 },
  { 338, 9, 8, 11, 1, -11 },
  { 347, 6, 14, 8, 2, -14 },
  { 358, 14, 15, 16, 1, -13 },
  { 385, 11, 14, 10, -1, -14 },
  { 405, 10, 14, 11, 1, -14 },
  { 423, 10, 14, 11, 2, -14 },
  { 441, 11, 14, 13, 1, -14 },
  { 461, 10, 14, 10, 1, -14 },
  { 479, 10, 14, 9, 1, -14 },
  { 497, 11, 14, 13, 2, -14 },
  { 517, 12, 14, 13, 1, -14 },
  { 538, 6, 14, 5, 0, -14 },
  { 549, 8, 17, 5, -3, -14 },
  { 566, 11, 14, 10, 1, -14 },
  { 586, 7, 14, 9, 1, -14 },
  { 599, 14, 14, 15, 1, -14 },
  { 624, 12, 14, 13, 1, -14 },
  { 645, 11, 14, 14, 2, -14 },
  { 665, 10, 14, 11, 1, -14 },
  { 683, 11, 17, 14, 2, -14 },
  { 707, 10, 14, 11, 1, -14 },
  { 725, 10, 14, 9, 0, -14 },
  { 743, 9, 14, 9, 2, -14 },
  { 759, 11, 14, 13, 2, -14 },
  { 779, 10, 14, 10, 2, -14 },
  { 797, 15, 14, 16, 2, -14 },
  { 824, 12, 14, 9, -1, -14 },
  { 845, 9, 14, 9, 2, -14 },
  { 861, 11, 14, 10, 0, -14 },
  { 881, 7, 17, 6, 0, -14 },
  { 896, 3, 14, 6, 2, -14 },
  { 902, 7, 17, 6, -1, -14 },
  { 917, 9, 9, 11, 1, -14 },
  { 928, 8, 1, 7, -2, 2 },
  { 929, 2, 3, 5, 3, -15 },
  { 930, 9, 10, 10, 1, -10 },
  { 942, 9, 14, 11, 1, -14 },
  { 958, 8, 10, 9, 1, -10 },
  { 968, 10, 14, 11, 1, -14 },
  { 986, 8, 10, 9, 1, -10 },
  { 996, 10, 20, 5, -2, -15 },
  { 1021, 10, 15, 11, 0, -10 },
  { 1040, 8, 14, 11, 1, -14 },
  { 1054, 3, 14, 4, 1, -14 },
  { 1060, 7, 19, 4, -3, -14 },
  { 1077, 8, 14, 9, 1, -14 },
  { 1091, 3, 14, 4, 1, -14 },
  { 1097, 14, 10, 16, 1, -10 },
  { 1115, 9, 10, 11, 1, -10 },
  { 1127, 9, 10, 11, 1, -10 },
  { 1139, 10, 14, 11, 0, -10 },
  { 1157, 9, 14, 11, 1, -10 },
  { 1173, 7, 10, 7, 1, -10 },
  { 1182, 8, 10, 8, 0, -10 },
  { 1192, 5, 13, 6, 1, -13 },
  { 1201, 9, 10, 11, 1, -10 },
  { 1213, 8, 10, 8, 1, -10 },
  { 1223, 12, 10, 13, 1, -10 },
  { 1238, 10, 10, 9, -1, -10 },
  { 1251, 11, 15, 8, -2, -10 },
  { 1272, 8, 10, 8, 0, -10 },
  { 1282, 7, 17, 6, 0, -14 },
  { 1297, 1, 19, 10, 5, -14 },
  { 1300, 7, 17, 6, -1, -14 },
  { 1315, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRALIGHTITALIC19PT7B_H_
