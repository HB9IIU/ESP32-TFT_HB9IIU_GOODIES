#ifndef _NOTOSANS_EXTRALIGHTITALIC66PT7B_H_
#define _NOTOSANS_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x08, 0x00, 0x1C, 0x07, 0x1C, 0x06, 0x1C,
  0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60,
  0x30, 0x40, 0x30, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3E, 0x18, 0x3E, 0x00,
  0xF0, 0x30, 0x08, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x3E, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x19, 0xF0, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x00, 0xC0, 0xF0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x02, 0x00, 0x30, 0x3C, 0x07, 0x80,
  0x61, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x03,
  0x80, 0x60, 0x03, 0x00, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x70, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x00, 0x70, 0x38, 0x1F,
  0x0C, 0x00, 0x38, 0x38, 0x3F, 0xE6, 0x00, 0x18, 0x38, 0x3E, 0xFB, 0x00,
  0x1C, 0x18, 0x38, 0x1D, 0x80, 0x0C, 0x1C, 0x38, 0x07, 0xE0, 0x0E, 0x1C,
  0x38, 0x03, 0xF0, 0x0E, 0x1C, 0x18, 0x00, 0xDC, 0x0E, 0x0C, 0x1C, 0x00,
  0x6F, 0xBE, 0x0E, 0x0C, 0x00, 0x33, 0xFE, 0x0E, 0x0E, 0x00, 0x18, 0x78,
  0x06, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x03,
  0x80, 0x38, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x00, 0x30, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x0F,
  0x03, 0x80, 0x70, 0x00, 0x03, 0xEF, 0x80, 0x70, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x18, 0x38, 0x01, 0xC0, 0x00, 0x70, 0xE0,
  0x01, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x03, 0x80,
  0x06, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x70, 0x00, 0x03, 0x80, 0x70, 0xC0,
  0x00, 0x03, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x03, 0x87, 0x00, 0x00, 0x07,
  0x0E, 0x0E, 0x00, 0x00, 0x07, 0x38, 0x18, 0x00, 0x00, 0x0E, 0xE0, 0x30,
  0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x9C, 0x03,
  0xC0, 0x00, 0x1E, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x03, 0xE0, 0x07,
  0xC0, 0x38, 0x03, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30,
  0xC7, 0x18, 0x61, 0x86, 0x10, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xF8, 0x03, 0x00, 0x03, 0xC0, 0x60,
  0x00, 0x0F, 0x06, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xF6, 0x01, 0xF0,
  0x03, 0xDF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xF7, 0x01, 0xE6, 0x07,
  0xC6, 0x0F, 0x0E, 0x3E, 0x0E, 0x78, 0x0E, 0xF0, 0x0C, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x83, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xFC, 0x00, 0x18, 0x3F, 0xFF, 0x00, 0x38, 0x7C, 0x0F, 0x80, 0x39, 0xE0,
  0x03, 0xC0, 0x33, 0x80, 0x01, 0xE0, 0x37, 0x00, 0x00, 0xE0, 0x7E, 0x00,
  0x00, 0x70, 0x7C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFC, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x7C, 0x07,
  0x00, 0x00, 0xEC, 0x07, 0x80, 0x01, 0xDC, 0x03, 0xC0, 0x07, 0x9C, 0x01,
  0xF8, 0x7E, 0x18, 0x00, 0x7F, 0xF8, 0x38, 0x00, 0x1F, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xC0,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0xF0, 0x03, 0xC1, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x0E, 0x38, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0x1C, 0x00, 0x1F, 0x00, 0x30, 0x01, 0x9C, 0x00, 0x1E,
  0x00, 0x18, 0x00, 0xCE, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x37, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x0D, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03,
  0x00, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x70, 0x00, 0xF8, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x6C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x36, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x3B, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x19, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x1C, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x0C, 0x60,
  0x07, 0x00, 0x07, 0x80, 0x0E, 0x30, 0x03, 0x80, 0x06, 0xC0, 0x0E, 0x18,
  0x00, 0xE0, 0x07, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x07, 0x18, 0x0F, 0x07,
  0x00, 0x1F, 0x1F, 0x0F, 0x1E, 0x01, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x03, 0xFC, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x18, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xF0, 0x06, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x07,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x06, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xE1,
  0x80, 0x00, 0x1F, 0xFF, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0x30, 0xF8, 0x00, 0x00, 0x00,
  0x63, 0xF0, 0x00, 0x00, 0x01, 0xCE, 0x70, 0x00, 0x00, 0x03, 0xB8, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x1B, 0x80, 0x00, 0x00, 0x07, 0x60, 0x06, 0x60, 0x00, 0x00, 0x03, 0xB8,
  0x01, 0x98, 0x00, 0x00, 0x00, 0xEE, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x39, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x70, 0x00, 0x00, 0x0E,
  0x30, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x01, 0xC3, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x01, 0x83, 0x80, 0x00,
  0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x38, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80,
  0x00, 0x38, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x60, 0x06, 0x01,
  0xC0, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x30, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x07, 0x03, 0x80, 0x06, 0x00, 0x60, 0x01, 0xC1, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC7, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x80, 0x1B, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x60, 0x00, 0x00, 0x30, 0x01,
  0x9C, 0x00, 0x00, 0x0C, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0xC0, 0x0C, 0x38, 0x00, 0x00, 0x70, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80,
  0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x03, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x70, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x00, 0x30, 0x38, 0x01, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x60, 0x00, 0x01, 0x83, 0x00, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x70, 0x03, 0x80, 0x00, 0x03, 0x9C, 0x00, 0xC0,
  0x00, 0x00, 0xE6, 0x00, 0x30, 0x00, 0x00, 0x19, 0x80, 0x1C, 0x00, 0x00,
  0x07, 0x60, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00,
  0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0C, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x18, 0x38, 0x00, 0x03, 0x0E,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x03,
  0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0xE0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xFC, 0x0C, 0x00, 0xFF, 0xFC, 0x18, 0x03, 0xE0, 0x1C, 0x30, 0x0F,
  0x00, 0x1C, 0xE0, 0x38, 0x00, 0x19, 0x80, 0xE0, 0x00, 0x1B, 0x03, 0x80,
  0x00, 0x36, 0x07, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0xD8, 0x0E,
  0x00, 0x03, 0xB0, 0x1C, 0x00, 0x06, 0x60, 0x1C, 0x00, 0x38, 0xC0, 0x3C,
  0x00, 0xE3, 0x80, 0x3C, 0x07, 0x86, 0x00, 0x3F, 0xFE, 0x0C, 0x00, 0x3F,
  0xF0, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x01,
  0xC1, 0xFF, 0xF0, 0x01, 0x87, 0x80, 0x78, 0x01, 0x8E, 0x00, 0x3C, 0x03,
  0x9C, 0x00, 0x1E, 0x03, 0xB8, 0x00, 0x0E, 0x03, 0x30, 0x00, 0x06, 0x03,
  0x60, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x3C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x7C,
  0x00, 0x00, 0xE0, 0x66, 0x00, 0x01, 0xC0, 0x66, 0x00, 0x03, 0xC0, 0x63,
  0x00, 0x07, 0x80, 0x63, 0xC0, 0x1F, 0x00, 0xE1, 0xFF, 0xFC, 0x00, 0xC0,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x07, 0xC0, 0x0E, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x1F, 0xFF, 0x87, 0x00, 0x0F,
  0x80, 0x78, 0xE0, 0x03, 0xC0, 0x03, 0x9C, 0x00, 0xE0, 0x00, 0x33, 0x00,
  0x38, 0x00, 0x03, 0x60, 0x0E, 0x00, 0x00, 0x6C, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x7C, 0x01,
  0x80, 0x00, 0x1B, 0x00, 0x38, 0x00, 0x07, 0x60, 0x07, 0x00, 0x01, 0xCC,
  0x00, 0x70, 0x00, 0x71, 0x80, 0x0F, 0x00, 0x1C, 0x70, 0x00, 0xF0, 0x0F,
  0x0C, 0x00, 0x0F, 0xFF, 0x81, 0x80, 0x00, 0xFF, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0x60, 0x03, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x04, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x07,
  0xFF, 0xF0, 0x60, 0x07, 0xC0, 0x3C, 0x30, 0x07, 0x80, 0x07, 0x38, 0x07,
  0x00, 0x01, 0x98, 0x07, 0x00, 0x00, 0x6C, 0x07, 0x00, 0x00, 0x36, 0x03,
  0x80, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x00,
  0x36, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0xE0, 0x00, 0x39, 0x80, 0x38, 0x00,
  0x39, 0xC0, 0x1E, 0x00, 0x38, 0xE0, 0x07, 0x80, 0x78, 0x60, 0x01, 0xFF,
  0xF0, 0x30, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xE0, 0x3F, 0xF0, 0x01, 0xC1, 0xFF, 0xF8, 0x03, 0x0F, 0x00, 0xF0, 0x06,
  0x38, 0x00, 0x70, 0x1C, 0xE0, 0x00, 0xE0, 0x3B, 0x80, 0x00, 0xE0, 0x66,
  0x00, 0x01, 0xC0, 0xD8, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x07, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xEF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x06, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x0C, 0x76, 0x00,
  0x00, 0x33, 0x1C, 0x00, 0x01, 0xD8, 0x30, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x70, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x18, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x06, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0x8E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x66,
  0x00, 0x1C, 0x30, 0x00, 0x70, 0x3B, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x0D,
  0x80, 0x00, 0xEE, 0x00, 0x07, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xC0,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x06, 0x07, 0xFF, 0xE0,
  0x0C, 0x3E, 0x03, 0xC0, 0x18, 0xF0, 0x01, 0xC0, 0x73, 0x80, 0x03, 0x80,
  0xEE, 0x00, 0x03, 0x81, 0x98, 0x00, 0x07, 0x03, 0x60, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xFF, 0x80,
  0x00, 0xC0, 0xFF, 0xF8, 0x00, 0x18, 0x78, 0x07, 0x80, 0x03, 0x1C, 0x00,
  0x78, 0x00, 0x67, 0x00, 0x07, 0x80, 0x1D, 0xC0, 0x00, 0x70, 0x03, 0x30,
  0x00, 0x06, 0x00, 0x6C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x03,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x1F, 0x00,
  0x00, 0x38, 0x03, 0xB0, 0x00, 0x0E, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x0C,
  0x60, 0x00, 0xF0, 0x01, 0x87, 0x00, 0x78, 0x00, 0x70, 0x7F, 0xFE, 0x00,
  0x0E, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0x00, 0x3F, 0xFF, 0x83, 0x00,
  0x7C, 0x03, 0xC3, 0x00, 0xF0, 0x00, 0xE7, 0x01, 0xC0, 0x00, 0x66, 0x03,
  0x80, 0x00, 0x36, 0x07, 0x00, 0x00, 0x36, 0x07, 0x00, 0x00, 0x3E, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x03, 0xE0, 0x60, 0x00, 0x06, 0xC0, 0x70, 0x00, 0x0E, 0xC0, 0x70,
  0x00, 0x1C, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x3C, 0x00, 0x71, 0xC0, 0x1E,
  0x01, 0xE1, 0x80, 0x0F, 0xFF, 0x81, 0x80, 0x07, 0xFF, 0x03, 0x80, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0xE0, 0x7F, 0xC0, 0x60, 0x7F, 0xC0, 0x30, 0xF0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x0F, 0x80, 0x1E, 0x03, 0x80, 0x00, 0x81, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x01, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x36,
  0x06, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x01, 0xB8, 0x1C, 0x00, 0x06, 0x60,
  0x38, 0x00, 0x18, 0xC0, 0x78, 0x00, 0xE1, 0x80, 0x78, 0x07, 0x87, 0x00,
  0x7F, 0xFE, 0x0C, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x01,
  0x80, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x30, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00,
  0x0E, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0x38, 0x00, 0x63, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x03,
  0x83, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x38,
  0x01, 0x81, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x06, 0x03, 0x80, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x0E, 0x00,
  0x60, 0x70, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0E,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0,
  0x01, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x05, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0xFE, 0x3E, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph NotoSans_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 48, 15, 2, -47 },
  { 79, 16, 17, 22, 7, -47 },
  { 113, 40, 47, 41, 2, -47 },
  { 348, 31, 54, 36, 3, -50 },
  { 558, 41, 49, 51, 6, -48 },
  { 810, 39, 49, 45, 3, -48 },
  { 1049, 6, 17, 12, 7, -47 },
  { 1062, 19, 57, 17, 2, -47 },
  { 1198, 19, 57, 17, -4, -47 },
  { 1334, 28, 28, 35, 8, -50 },
  { 1432, 30, 31, 38, 5, -39 },
  { 1549, 10, 17, 13, -3, -8 },
  { 1571, 16, 2, 21, 2, -19 },
  { 1575, 4, 5, 14, 2, -4 },
  { 1578, 30, 47, 21, -3, -47 },
  { 1755, 31, 49, 36, 4, -48 },
  { 1945, 16, 47, 36, 11, -47 },
  { 2039, 33, 48, 36, 1, -48 },
  { 2237, 34, 49, 36, 1, -48 },
  { 2446, 34, 47, 36, 1, -47 },
  { 2646, 32, 48, 36, 3, -47 },
  { 2838, 32, 49, 36, 4, -48 },
  { 3034, 30, 47, 36, 7, -47 },
  { 3211, 32, 49, 36, 3, -48 },
  { 3407, 32, 49, 36, 3, -48 },
  { 3603, 11, 36, 14, 2, -35 },
  { 3653, 16, 44, 14, -3, -35 },
  { 3741, 30, 30, 38, 5, -39 },
  { 3854, 30, 15, 38, 5, -31 },
  { 3911, 30, 30, 38, 5, -39 },
  { 4024, 23, 49, 27, 5, -48 },
  { 4165, 49, 53, 55, 4, -47 },
  { 4490, 36, 47, 36, -3, -47 },
  { 4702, 35, 47, 39, 3, -47 },
  { 4908, 37, 49, 39, 5, -48 },
  { 5135, 39, 47, 45, 3, -47 },
  { 5365, 34, 47, 35, 3, -47 },
  { 5565, 34, 47, 32, 3, -47 },
  { 5765, 39, 49, 45, 5, -48 },
  { 6004, 42, 47, 45, 3, -47 },
  { 6251, 22, 47, 19, 0, -47 },
  { 6381, 27, 59, 16, -11, -47 },
  { 6581, 39, 47, 36, 3, -47 },
  { 6811, 24, 47, 32, 3, -47 },
  { 6952, 50, 47, 54, 3, -47 },
  { 7246, 42, 47, 45, 3, -47 },
  { 7493, 40, 49, 47, 5, -48 },
  { 7738, 34, 47, 37, 3, -47 },
  { 7938, 40, 59, 47, 5, -48 },
  { 8233, 34, 47, 37, 3, -47 },
  { 8433, 33, 49, 33, 1, -48 },
  { 8636, 32, 47, 32, 6, -47 },
  { 8824, 40, 48, 45, 6, -47 },
  { 9064, 34, 47, 36, 7, -47 },
  { 9264, 52, 47, 55, 8, -47 },
  { 9570, 42, 47, 33, -4, -47 },
  { 9817, 32, 47, 32, 6, -47 },
  { 10005, 39, 47, 35, -1, -47 },
  { 10235, 25, 57, 20, -1, -47 },
  { 10414, 10, 47, 21, 7, -47 },
  { 10473, 25, 57, 20, -5, -47 },
  { 10652, 31, 29, 37, 3, -47 },
  { 10765, 26, 2, 25, -6, 7 },
  { 10772, 8, 11, 16, 10, -51 },
  { 10783, 31, 37, 36, 3, -36 },
  { 10927, 32, 51, 38, 2, -50 },
  { 11131, 26, 37, 30, 4, -36 },
  { 11252, 35, 51, 38, 3, -50 },
  { 11476, 26, 37, 33, 4, -36 },
  { 11597, 36, 66, 18, -8, -50 },
  { 11894, 33, 52, 38, 2, -36 },
  { 12109, 31, 50, 37, 2, -50 },
  { 12303, 13, 48, 14, 2, -48 },
  { 12381, 24, 64, 14, -9, -48 },
  { 12573, 30, 50, 30, 2, -50 },
  { 12761, 13, 50, 14, 2, -50 },
  { 12843, 50, 36, 56, 2, -36 },
  { 13068, 31, 36, 37, 2, -36 },
  { 13208, 30, 37, 37, 4, -36 },
  { 13347, 35, 51, 38, -1, -36 },
  { 13571, 32, 51, 38, 3, -36 },
  { 13775, 25, 36, 25, 2, -36 },
  { 13888, 26, 37, 28, 1, -36 },
  { 14009, 19, 45, 21, 3, -44 },
  { 14116, 31, 36, 37, 4, -35 },
  { 14256, 28, 35, 28, 3, -35 },
  { 14379, 42, 35, 44, 4, -35 },
  { 14563, 33, 35, 30, -2, -35 },
  { 14708, 38, 51, 28, -7, -35 },
  { 14951, 30, 35, 29, -1, -35 },
  { 15083, 23, 57, 22, 2, -47 },
  { 15247, 3, 66, 36, 18, -50 },
  { 15272, 24, 58, 22, -3, -47 },
  { 15446, 30, 6, 38, 5, -26 },
};

const GFXfont NotoSans_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRALIGHTITALIC66PT7B_H_
