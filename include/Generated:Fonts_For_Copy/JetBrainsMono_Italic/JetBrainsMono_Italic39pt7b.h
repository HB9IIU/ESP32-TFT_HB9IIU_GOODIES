#ifndef _JETBRAINSMONO_ITALIC39PT7B_H_
#define _JETBRAINSMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0,
  0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0xF7, 0x87, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x23, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07,
  0x83, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFB, 0xE0, 0xF1, 0x8F, 0x0F, 0x18, 0xF1, 0xE1, 0x8F, 0x1E, 0x38, 0xF1,
  0xE3, 0x80, 0x1E, 0x30, 0x01, 0xE3, 0x00, 0x1F, 0x30, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x67,
  0xC0, 0x06, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xCF, 0x0C,
  0x3C, 0xF0, 0xC3, 0xCF, 0x0C, 0x78, 0x78, 0xCF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x7F, 0x00, 0x38,
  0x1F, 0xF0, 0x0E, 0x07, 0x8E, 0x03, 0x80, 0xE0, 0xE0, 0xE0, 0x1C, 0x18,
  0x1C, 0x07, 0x07, 0x07, 0x00, 0xE0, 0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03,
  0x83, 0x9C, 0x00, 0x78, 0xE7, 0x00, 0x07, 0xFD, 0xC0, 0x00, 0x7E, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0xF8, 0x00, 0x0E, 0x3F, 0x80, 0x01, 0xCF, 0xF8, 0x00, 0x73, 0x87,
  0x00, 0x1C, 0x70, 0xE0, 0x07, 0x1C, 0x1C, 0x01, 0xC3, 0x83, 0x80, 0x70,
  0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x3F, 0xF0,
  0x38, 0x03, 0xFC, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xC7, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x9E,
  0x0F, 0x38, 0xF0, 0x73, 0xC3, 0xC7, 0x9E, 0x0E, 0x78, 0xE0, 0x7F, 0x87,
  0x01, 0xF8, 0x38, 0x0F, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F,
  0x87, 0xC3, 0xFC, 0x1F, 0xFE, 0xF0, 0xFF, 0xC3, 0xC3, 0xFC, 0x1E, 0x00,
  0x7B, 0xDE, 0xF7, 0x7B, 0xDE, 0xF7, 0x38, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x02,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC1, 0xC0, 0xCF, 0x8E, 0x3E,
  0xFF, 0x67, 0xF9, 0xFD, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x01,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3C, 0xFF, 0xFF,
  0xFF, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x01, 0xF0,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x60, 0xE3, 0x8F, 0x0E, 0x38, 0xF9,
  0xE3, 0x8F, 0x1E, 0x78, 0x71, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00, 0x38, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x1F, 0x9E, 0x07,
  0x87, 0x81, 0xC1, 0xC0, 0x40, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C,
  0x7E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x3C,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0,
  0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x1E, 0x03, 0x87,
  0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x1C, 0xFF,
  0x01, 0xDF, 0xF8, 0x1F, 0x9F, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x70, 0x07, 0xFF, 0x81,
  0xFF, 0xF8, 0x7F, 0x1F, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xEE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xBC,
  0x00, 0xE3, 0xC0, 0x3C, 0x7C, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x01, 0xEF,
  0x00, 0x39, 0xE0, 0x0F, 0x38, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x0E, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x07, 0xDF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x70,
  0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87,
  0x80, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xCF, 0xC3, 0xC0, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x0F,
  0x70, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x07, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFB, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xCF, 0xC3, 0xE0, 0x00, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x07, 0xCE, 0x1C, 0x0F, 0xEE, 0x1C, 0x1F, 0xEE, 0x3C, 0x3C, 0x1E, 0x38,
  0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x78, 0x1C, 0x38,
  0x70, 0x1C, 0x38, 0x70, 0x1C, 0x78, 0x70, 0x38, 0x70, 0x70, 0x38, 0x70,
  0x70, 0x38, 0x70, 0x70, 0x78, 0x70, 0x7F, 0xF8, 0x70, 0x3F, 0xB8, 0xF0,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x7B, 0xC0, 0x07,
  0x3C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01,
  0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x1C, 0x07, 0x81, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1E, 0x00, 0xE1, 0xE0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00,
  0xFF, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0,
  0x1E, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C,
  0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x03, 0xC1, 0xC0, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0x80, 0x7C, 0x38, 0x03, 0xC3, 0x80, 0x1C,
  0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03,
  0xC7, 0x00, 0x78, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE7, 0xE1, 0xF0,
  0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x0F,
  0x1F, 0x03, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xE0, 0x3E, 0x0E, 0x01, 0xE1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE7,
  0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x3F, 0xF3, 0x87, 0xFE, 0x70, 0xFF, 0x8E, 0x1F, 0xF3, 0xC0, 0x0E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xF0, 0x0F, 0x1F, 0x03, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E,
  0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0,
  0x0E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80,
  0x3C, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0x80, 0x7C, 0x3F, 0x01,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xD8, 0x3F, 0x07, 0x60,
  0xCC, 0x3B, 0x87, 0x38, 0xEE, 0x1C, 0xE7, 0x38, 0x73, 0x9C, 0xE1, 0xCE,
  0xE7, 0x87, 0x3B, 0x9C, 0x1C, 0x6C, 0x70, 0x71, 0xF1, 0xC3, 0xC7, 0x8F,
  0x0F, 0x1E, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x7C, 0x03, 0x83, 0xF0, 0x1C, 0x1F, 0x80, 0xE0, 0xFC,
  0x07, 0x0F, 0xE0, 0x78, 0x77, 0x03, 0xC3, 0xBC, 0x1C, 0x1C, 0xE0, 0xE0,
  0xE7, 0x07, 0x07, 0x38, 0x38, 0x79, 0xC3, 0xC3, 0xCF, 0x1E, 0x1C, 0x38,
  0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0xDE, 0x1E,
  0x0E, 0xF0, 0xF0, 0x77, 0x87, 0x03, 0xB8, 0x38, 0x1D, 0xC1, 0xC0, 0xFE,
  0x1E, 0x03, 0xF0, 0xF0, 0x1F, 0x87, 0x80, 0xFC, 0x38, 0x07, 0xC1, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xE7, 0xE1,
  0xE0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xE7,
  0x00, 0x38, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0,
  0x0E, 0x1F, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01, 0xF0, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0,
  0x03, 0xC7, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x0F,
  0x01, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x1E,
  0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00,
  0x78, 0x78, 0x07, 0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1C, 0x03, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x3C,
  0x78, 0x03, 0xC3, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x87,
  0x80, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xE0, 0x1E, 0x0F,
  0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01,
  0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xF0, 0x70, 0x1E, 0x0E,
  0x03, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0xF0,
  0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x78, 0x1D, 0xC1,
  0xE0, 0x77, 0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70, 0xF8, 0x3B, 0xC3, 0x61,
  0xEF, 0x0D, 0x87, 0x3C, 0x76, 0x1C, 0xF1, 0x98, 0x73, 0x86, 0x63, 0x8E,
  0x19, 0x8E, 0x38, 0xE6, 0x38, 0xE3, 0x18, 0xE3, 0x8C, 0x67, 0x0E, 0x71,
  0x9C, 0x39, 0x8E, 0x70, 0xE6, 0x39, 0xC3, 0x98, 0xEE, 0x0E, 0xE3, 0xB8,
  0x3B, 0x0E, 0xE0, 0xEC, 0x3F, 0x03, 0xF0, 0xDC, 0x0F, 0x83, 0x70, 0x3E,
  0x0D, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F,
  0x80, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xC7, 0x00, 0x03, 0xC7,
  0x80, 0x07, 0x87, 0x80, 0x07, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x01,
  0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0x7B, 0x80, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0x83,
  0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x81, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF7, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7B, 0x00, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x1C,
  0x1E, 0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x8F, 0x00, 0xE7, 0x00, 0x77, 0x80,
  0x3B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0xF0, 0xE1, 0xE1, 0xE1, 0xC0, 0x00, 0xF8, 0x10, 0x3F, 0xCE, 0x07, 0xFE,
  0xE0, 0xF8, 0x6E, 0x1E, 0x03, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xF7, 0x01, 0xFC, 0x70,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x8F, 0x80, 0xF7, 0xFC, 0x1D, 0xFF, 0xC3, 0xB0, 0xF8,
  0x7C, 0x0F, 0x1F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xFC, 0x0F, 0x1F,
  0xFF, 0xC3, 0xDF, 0xF0, 0x71, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF8, 0x7E, 0x3E, 0x3C, 0x07, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x0F, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1E, 0xE0, 0x07, 0x3C, 0x03, 0xCF,
  0x81, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0xE3, 0xC0, 0x7F, 0x9C, 0x07, 0xFE, 0xE0, 0x7C, 0x37, 0x07,
  0x80, 0xF8, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x01, 0xF0,
  0x7C, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFD, 0xC0, 0x3F, 0x8E, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3C, 0x07, 0x8E, 0x00,
  0xE7, 0x80, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x20, 0xFF, 0x38, 0x3F, 0xF7, 0x0F, 0x86, 0xE3, 0xC0, 0x7C,
  0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7,
  0x80, 0x78, 0xF8, 0x17, 0x0F, 0xDF, 0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0x80,
  0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x8F, 0x80, 0xF7, 0xFC, 0x1D, 0xFF, 0xC3, 0xB0, 0xF8, 0x78, 0x0F, 0x1F,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1C, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x23, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xF0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xF0, 0xE0, 0xEF, 0xDF, 0x87, 0xFE, 0xFE,
  0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x9E, 0x1C, 0x3C, 0xF0, 0xE1, 0xE7, 0x07,
  0x0E, 0x38, 0x38, 0x71, 0xC1, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0xE0, 0xE7,
  0x87, 0x0F, 0x38, 0x38, 0x71, 0xC1, 0xC3, 0x8E, 0x0C, 0x1C, 0x70, 0xE0,
  0xE3, 0x87, 0x07, 0x3C, 0x38, 0x79, 0xE1, 0xC3, 0xCE, 0x0E, 0x1C, 0x70,
  0x60, 0xE0, 0x00, 0x3E, 0x03, 0xDF, 0xF0, 0x77, 0xFF, 0x0E, 0xC3, 0xE1,
  0xE0, 0x3C, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7E, 0x7E, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80, 0x3D, 0xE0,
  0x0F, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0x8F,
  0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xF7, 0xFC, 0x0E, 0xFF, 0xE0, 0xEC, 0x3E, 0x0F, 0x81, 0xE1, 0xF0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0,
  0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7E, 0x07, 0x87, 0xFF, 0xF0, 0x7B,
  0xFE, 0x07, 0x1F, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0x9C, 0x1F, 0xFB, 0x87, 0xC3, 0xF1, 0xE0, 0x3E, 0x38, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C,
  0x70, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7E, 0x3F, 0xFB, 0x83, 0xFF, 0x70,
  0x3F, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x9F, 0xE0,
  0x77, 0xFE, 0x0F, 0xC3, 0xE3, 0xE0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xC3, 0xE1, 0xE0, 0x1E,
  0x38, 0x03, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x3E, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1E, 0x00,
  0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x80, 0x78, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xB8, 0x3C,
  0x1D, 0xC3, 0xE0, 0xCE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC3, 0x1C,
  0x66, 0x38, 0xE3, 0x31, 0xC7, 0x39, 0x8C, 0x39, 0x8C, 0xE1, 0xCC, 0x67,
  0x0E, 0xE3, 0x38, 0x76, 0x1B, 0x83, 0xB0, 0xDC, 0x1D, 0x86, 0xE0, 0xF8,
  0x36, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x0F, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C,
  0x03, 0xC7, 0xC0, 0xB8, 0x7F, 0xFF, 0x0F, 0xFD, 0xE0, 0xFF, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x71, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0x9F, 0x0E, 0x70, 0xF0,
  0xE7, 0x07, 0xFE, 0x70, 0x3F, 0xCF, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 13, 11, 23, 7, -28 },
  { 54, 23, 28, 23, 1, -28 },
  { 135, 20, 39, 23, 2, -34 },
  { 233, 27, 29, 23, -1, -29 },
  { 331, 21, 29, 23, 1, -29 },
  { 408, 5, 11, 23, 11, -28 },
  { 415, 16, 38, 23, 6, -33 },
  { 491, 16, 38, 23, 2, -33 },
  { 567, 21, 20, 23, 2, -24 },
  { 620, 18, 18, 23, 3, -22 },
  { 661, 10, 12, 23, 4, -6 },
  { 676, 13, 3, 23, 6, -14 },
  { 681, 7, 6, 23, 7, -6 },
  { 687, 23, 36, 23, 1, -32 },
  { 791, 20, 29, 23, 2, -29 },
  { 864, 18, 28, 23, 2, -28 },
  { 927, 20, 29, 23, 2, -29 },
  { 1000, 20, 28, 23, 2, -28 },
  { 1070, 19, 28, 23, 2, -28 },
  { 1137, 20, 28, 23, 2, -28 },
  { 1207, 19, 28, 23, 2, -28 },
  { 1274, 19, 28, 23, 5, -28 },
  { 1341, 20, 29, 23, 2, -29 },
  { 1414, 19, 29, 23, 4, -29 },
  { 1483, 9, 22, 23, 7, -22 },
  { 1508, 13, 28, 23, 4, -22 },
  { 1554, 19, 20, 23, 3, -23 },
  { 1602, 18, 12, 23, 3, -19 },
  { 1629, 19, 20, 23, 2, -23 },
  { 1677, 16, 28, 23, 5, -28 },
  { 1733, 24, 36, 23, 0, -29 },
  { 1841, 20, 28, 23, 0, -28 },
  { 1911, 20, 28, 23, 2, -28 },
  { 1981, 19, 29, 23, 3, -29 },
  { 2050, 20, 28, 23, 2, -28 },
  { 2120, 21, 28, 23, 2, -28 },
  { 2194, 21, 29, 23, 2, -29 },
  { 2271, 19, 29, 23, 3, -29 },
  { 2340, 21, 28, 23, 2, -28 },
  { 2414, 20, 28, 23, 2, -28 },
  { 2484, 21, 28, 23, 1, -28 },
  { 2558, 22, 28, 23, 2, -28 },
  { 2635, 17, 28, 23, 3, -28 },
  { 2695, 22, 28, 23, 1, -28 },
  { 2772, 21, 28, 23, 2, -28 },
  { 2846, 19, 29, 23, 3, -29 },
  { 2915, 21, 28, 23, 2, -28 },
  { 2989, 20, 36, 23, 2, -29 },
  { 3079, 21, 28, 23, 2, -28 },
  { 3153, 20, 29, 23, 2, -29 },
  { 3226, 20, 29, 23, 4, -29 },
  { 3299, 21, 28, 23, 2, -28 },
  { 3373, 19, 28, 23, 5, -28 },
  { 3440, 22, 28, 23, 3, -28 },
  { 3517, 24, 28, 23, 0, -28 },
  { 3601, 21, 28, 23, 4, -28 },
  { 3675, 21, 28, 23, 2, -28 },
  { 3749, 15, 36, 23, 6, -32 },
  { 3817, 12, 36, 23, 6, -32 },
  { 3871, 16, 36, 23, 3, -32 },
  { 3943, 17, 15, 23, 4, -28 },
  { 3975, 19, 3, 23, 0, 1 },
  { 3983, 7, 6, 23, 10, -31 },
  { 3989, 20, 22, 23, 2, -22 },
  { 4044, 19, 28, 23, 2, -28 },
  { 4111, 18, 22, 23, 3, -22 },
  { 4161, 21, 28, 23, 2, -28 },
  { 4235, 18, 22, 23, 3, -22 },
  { 4285, 27, 35, 23, -2, -28 },
  { 4404, 19, 29, 23, 3, -22 },
  { 4473, 19, 28, 23, 2, -28 },
  { 4540, 19, 30, 23, 1, -30 },
  { 4612, 21, 37, 23, 0, -30 },
  { 4710, 21, 28, 23, 2, -28 },
  { 4784, 16, 28, 23, 4, -28 },
  { 4840, 21, 22, 23, 1, -22 },
  { 4898, 19, 22, 23, 2, -22 },
  { 4951, 18, 22, 23, 3, -22 },
  { 5001, 20, 29, 23, 1, -22 },
  { 5074, 19, 29, 23, 2, -22 },
  { 5143, 19, 22, 23, 3, -22 },
  { 5196, 19, 22, 23, 2, -22 },
  { 5249, 19, 27, 23, 3, -27 },
  { 5314, 20, 21, 23, 2, -21 },
  { 5367, 19, 21, 23, 4, -21 },
  { 5417, 21, 21, 23, 3, -21 },
  { 5473, 23, 21, 23, 0, -21 },
  { 5534, 19, 28, 23, 3, -21 },
  { 5601, 19, 21, 23, 2, -21 },
  { 5651, 19, 36, 23, 4, -32 },
  { 5737, 9, 36, 23, 8, -32 },
  { 5778, 20, 36, 23, 1, -32 },
  { 5868, 20, 8, 23, 2, -18 },
};

const GFXfont JetBrainsMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_ITALIC39PT7B_H_
