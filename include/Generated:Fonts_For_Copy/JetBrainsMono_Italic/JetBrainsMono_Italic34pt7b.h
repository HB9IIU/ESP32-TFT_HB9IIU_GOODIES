#ifndef _JETBRAINSMONO_ITALIC34PT7B_H_
#define _JETBRAINSMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x38, 0x7C,
  0xF8, 0x78, 0x78, 0xF7, 0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xE6, 0x1C, 0x61, 0xCE, 0x1C, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xC0,
  0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x30, 0x70, 0x07, 0x07, 0x00, 0x60, 0x60, 0x06,
  0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x18, 0x38, 0x03, 0x83, 0x00, 0x30, 0x30, 0x07, 0x07, 0x00,
  0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x0E, 0x67, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x03, 0xC6, 0x01,
  0xE7, 0x00, 0x7B, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x18, 0xE0, 0x0C, 0x78, 0x06, 0x3C, 0x03, 0x1C, 0xE1,
  0x8E, 0x70, 0xC7, 0x3C, 0xC7, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xE0, 0x06, 0x0F, 0xE0, 0x18, 0x39, 0xE0, 0x60, 0x61, 0xC1, 0xC1, 0xC3,
  0x87, 0x03, 0x87, 0x1C, 0x07, 0x0C, 0x70, 0x0C, 0x18, 0xC0, 0x1C, 0x73,
  0x00, 0x3F, 0xCE, 0x00, 0x3F, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x77, 0xF8, 0x01, 0xCE, 0x70,
  0x07, 0x38, 0x60, 0x1C, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0xC1, 0x83, 0x03,
  0x83, 0x0E, 0x0E, 0x07, 0x38, 0x38, 0x0F, 0xF0, 0xE0, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x02, 0x73, 0x83, 0x9C, 0x78, 0xE3, 0x87,
  0x3C, 0x70, 0x77, 0x0E, 0x0F, 0xC3, 0x80, 0xF0, 0x70, 0x1E, 0x0E, 0x03,
  0xC1, 0xC0, 0xFC, 0x3E, 0x7B, 0x83, 0xFE, 0x38, 0x3F, 0x87, 0x80, 0x77,
  0xFF, 0xEE, 0xEE, 0xEC, 0x00, 0x02, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x02,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0,
  0x3C, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x18, 0x30, 0x2F, 0x8C, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF,
  0x01, 0xFC, 0x00, 0x1C, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x07, 0x9E, 0x03,
  0xC7, 0x81, 0xE0, 0xF0, 0x70, 0x18, 0x04, 0x04, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1,
  0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xF7, 0xC3, 0xC0,
  0xF1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xDC, 0x21, 0xCE, 0x38, 0xE7, 0x1E, 0x73, 0x8F, 0x39, 0xC2, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xE7, 0x81, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xE0, 0x7D, 0xC1, 0xE3, 0x83, 0x8E, 0x0C, 0x1C, 0x10,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7,
  0x81, 0xE1, 0xF3, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x07, 0x1C, 0x0F, 0x38,
  0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0xFE, 0x0E, 0xFF, 0x87, 0xE7,
  0xC3, 0xC0, 0xE1, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xCE, 0x01, 0xC7, 0x81, 0xE1, 0xF3, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1D, 0xFC, 0x3F, 0xFE, 0x3E, 0x1E, 0x78, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0,
  0x3C, 0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCE, 0x00, 0xEF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0xF1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0x0F, 0x03, 0xCF,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0xF0, 0xF0, 0x70, 0x3C, 0x70,
  0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x80, 0xE1,
  0xF3, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x87, 0x81, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E,
  0xF0, 0x07, 0x78, 0x03, 0xBC, 0x03, 0xCE, 0x03, 0xC7, 0x83, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0C, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x1F, 0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0x78, 0x01, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x80, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x04, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0xC1, 0xFC, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x71, 0xC0, 0xFB,
  0x8E, 0x0F, 0xFC, 0x70, 0xE1, 0xE3, 0x87, 0x07, 0x1C, 0x70, 0x30, 0xC3,
  0x83, 0x86, 0x1C, 0x1C, 0x70, 0xE0, 0xE3, 0x87, 0x07, 0x1C, 0x30, 0x38,
  0xE1, 0x83, 0x86, 0x0E, 0x3C, 0x30, 0x7F, 0x63, 0x81, 0xF7, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x03, 0x98, 0x01,
  0xCC, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0x00,
  0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0,
  0x03, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xF1, 0xC0,
  0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x8E,
  0x07, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0x83, 0xF1, 0xC0, 0x38, 0xE0, 0x1E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xCE, 0x01, 0xE7, 0x01,
  0xE3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xC0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03,
  0x9E, 0x01, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0,
  0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x8E,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x01,
  0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0xF1, 0xC0,
  0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x8F, 0xF3, 0x87, 0xF9, 0xC3, 0xFC, 0xE0, 0x0E,
  0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xC7, 0x01, 0xE3, 0x81,
  0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0E, 0x01, 0xC7, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xF0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x0F,
  0x07, 0xCF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0xE3, 0x80,
  0x38, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x07,
  0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x78,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x38, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x0F, 0x8F, 0xC1, 0xB1, 0xF8, 0x7E, 0x3F, 0x0D, 0x87, 0x63, 0xB0,
  0xCC, 0x66, 0x19, 0x9D, 0xC3, 0x33, 0x38, 0xE7, 0xE7, 0x1C, 0xF8, 0xC3,
  0x8F, 0x38, 0x71, 0xC7, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x00, 0x1F, 0x01, 0xC7, 0xC0, 0x71,
  0xF0, 0x38, 0x7C, 0x0E, 0x1F, 0x03, 0x86, 0xE0, 0xE3, 0xB8, 0x38, 0xEE,
  0x0E, 0x39, 0x87, 0x0E, 0x61, 0xC3, 0x9C, 0x70, 0xE7, 0x1C, 0x39, 0xC7,
  0x1C, 0x31, 0xC7, 0x0C, 0x71, 0xC3, 0xB8, 0x70, 0xEE, 0x1C, 0x3B, 0x87,
  0x06, 0xE3, 0x81, 0xB8, 0xE0, 0x7E, 0x38, 0x1F, 0x0E, 0x07, 0xC3, 0x81,
  0xF0, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xC0,
  0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xC7, 0x01,
  0xC3, 0x81, 0xE1, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x70, 0x1F, 0x1C, 0x03, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xE0,
  0x3C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xDE, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x70, 0x1E, 0x1C, 0x03,
  0x87, 0x00, 0xF1, 0xC0, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3,
  0x80, 0x70, 0xE0, 0x7C, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0x0F, 0x01, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x3C,
  0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x1E, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x38, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x07,
  0xEF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x1C,
  0x1C, 0x0F, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x78, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x77, 0x07, 0x07, 0x70, 0xF0, 0x67,
  0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xB0, 0xC7, 0x1B, 0x1C,
  0x71, 0xB1, 0xC7, 0x33, 0x18, 0x73, 0x33, 0x87, 0x33, 0x38, 0x63, 0x33,
  0x86, 0x63, 0x30, 0x66, 0x37, 0x06, 0x63, 0x70, 0x6C, 0x36, 0x06, 0xC3,
  0x60, 0xEC, 0x3E, 0x0E, 0xC2, 0xE0, 0xF8, 0x6C, 0x0F, 0x86, 0xC0, 0xF8,
  0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x38, 0x03,
  0x81, 0xC0, 0x38, 0x0F, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xE1, 0xC0, 0x07,
  0x1E, 0x00, 0x38, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3B,
  0x80, 0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01,
  0xE0, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0xF0, 0x03,
  0xC0, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E,
  0x1C, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x01,
  0xCE, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0xE7, 0x03, 0x8E, 0x07,
  0x0C, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x33, 0x80, 0x6F, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xC7, 0x8E, 0x1C, 0x03, 0xE3, 0x87, 0xF9,
  0xC7, 0xFF, 0xC3, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x78, 0xE0, 0x78, 0x7C, 0xFC, 0x3F, 0xEE, 0x0F, 0xE7,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0xF8, 0x39, 0xFE, 0x3B, 0xFE, 0x3E, 0x0F, 0x3C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x1C, 0xF0, 0x3C, 0xFC, 0xF8, 0xEF,
  0xF0, 0xE7, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xC1, 0xE3,
  0x80, 0x71, 0xC0, 0x39, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x71, 0xC0, 0x78, 0xE0,
  0x38, 0x7C, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3E, 0x38,
  0x3F, 0xCE, 0x1F, 0xFF, 0x07, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x1C, 0x78,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x1C, 0x0F, 0x07, 0xCF, 0xC1,
  0xFF, 0x70, 0x3F, 0x9C, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1C,
  0x0F, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x7F, 0xFF, 0x7F,
  0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x70,
  0x1C, 0x7C, 0x78, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xFD, 0xC7, 0xFF, 0xC3, 0x81,
  0xE3, 0x80, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0xB8,
  0xFF, 0xF8, 0x3F, 0xDC, 0x07, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xF8,
  0x3B, 0xFE, 0x3B, 0xFE, 0x3C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x78, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0xF0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3C,
  0xF0, 0x1E, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x38,
  0x78, 0x0E, 0x3C, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1C, 0x38,
  0x07, 0x0F, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x0E, 0x03, 0xC3,
  0x80, 0x70, 0xE0, 0x1E, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0x87, 0xFE, 0x07, 0xFC, 0x19, 0xC7, 0x8E, 0xFB, 0xF3, 0xCF, 0xBC, 0xE1,
  0xC7, 0x38, 0x61, 0xCE, 0x18, 0x73, 0x8E, 0x1C, 0xC3, 0x86, 0x70, 0xE3,
  0x9C, 0x30, 0xE7, 0x0C, 0x39, 0xC3, 0x0E, 0x71, 0xC3, 0x98, 0x70, 0xEE,
  0x1C, 0x33, 0x86, 0x1C, 0xE1, 0x87, 0x38, 0x61, 0xCE, 0x38, 0x70, 0x1C,
  0xF8, 0x3B, 0xFE, 0x3B, 0xFE, 0x3C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x78, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1C, 0x0F, 0x38, 0x07, 0x38,
  0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0x70, 0x1C, 0x70, 0x3C, 0x7C, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0E, 0x7C, 0x0E, 0x7F, 0x87, 0x7F, 0xC3, 0xE0, 0xF1,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x38, 0xF0,
  0x3C, 0x7E, 0x7C, 0x3B, 0xFC, 0x1C, 0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE3, 0x87,
  0xFB, 0xC7, 0xFF, 0xC3, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x39, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE7, 0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x78, 0x7C, 0xFC, 0x3F, 0xEE, 0x0F,
  0xE7, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x7C, 0x0E, 0xFF, 0x07, 0xFF, 0xC3, 0xC0, 0xE1,
  0xC0, 0x79, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0xE0, 0x0E, 0xF0, 0x1C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x3C, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE7, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x78, 0x7C, 0xF8, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC1, 0xC1, 0xF0, 0x70,
  0x6C, 0x3C, 0x3B, 0x0F, 0x0E, 0xC3, 0xC3, 0x31, 0xB1, 0xCC, 0x6C, 0x73,
  0x1B, 0x18, 0xC4, 0xC6, 0x33, 0x33, 0x8C, 0xCC, 0xC3, 0x23, 0x30, 0xD8,
  0xDC, 0x36, 0x36, 0x0D, 0x8D, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C,
  0x0E, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x03, 0xC0, 0x78,
  0x38, 0x03, 0x87, 0x00, 0x3C, 0xE0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00,
  0x71, 0xC0, 0x0F, 0x1E, 0x01, 0xE0, 0xE0, 0x3C, 0x0F, 0x03, 0x80, 0x70,
  0xF0, 0x07, 0x80, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0xF8, 0xFF,
  0xF8, 0x3F, 0xDC, 0x03, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x3F,
  0x03, 0xBF, 0xC1, 0xDC, 0xF0, 0xEC, 0x3C, 0xEE, 0x0F, 0xF7, 0x03, 0xF0,
  0x00, 0x40,
};

const GFXglyph JetBrainsMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 25, 20, 6, -25 },
  { 26, 12, 10, 20, 6, -25 },
  { 41, 20, 25, 20, 1, -25 },
  { 104, 17, 35, 20, 2, -30 },
  { 179, 23, 25, 20, -1, -25 },
  { 251, 19, 25, 20, 1, -25 },
  { 311, 4, 10, 20, 10, -25 },
  { 316, 15, 33, 20, 5, -29 },
  { 378, 14, 33, 20, 2, -29 },
  { 436, 18, 18, 20, 2, -21 },
  { 477, 17, 16, 20, 2, -19 },
  { 511, 9, 10, 20, 3, -5 },
  { 523, 11, 3, 20, 5, -13 },
  { 528, 6, 5, 20, 6, -5 },
  { 532, 21, 32, 20, 0, -28 },
  { 616, 17, 25, 20, 2, -25 },
  { 670, 15, 25, 20, 2, -25 },
  { 717, 17, 25, 20, 2, -25 },
  { 771, 17, 25, 20, 2, -25 },
  { 825, 16, 25, 20, 2, -25 },
  { 875, 17, 25, 20, 2, -25 },
  { 929, 16, 25, 20, 2, -25 },
  { 979, 17, 25, 20, 4, -25 },
  { 1033, 17, 25, 20, 2, -25 },
  { 1087, 17, 25, 20, 3, -25 },
  { 1141, 8, 19, 20, 6, -19 },
  { 1160, 11, 24, 20, 3, -19 },
  { 1193, 16, 18, 20, 3, -20 },
  { 1229, 17, 11, 20, 2, -17 },
  { 1253, 16, 18, 20, 2, -20 },
  { 1289, 13, 25, 20, 5, -25 },
  { 1330, 21, 31, 20, 0, -25 },
  { 1412, 17, 25, 20, 0, -25 },
  { 1466, 17, 25, 20, 2, -25 },
  { 1520, 17, 25, 20, 2, -25 },
  { 1574, 17, 25, 20, 2, -25 },
  { 1628, 18, 25, 20, 2, -25 },
  { 1685, 18, 25, 20, 2, -25 },
  { 1742, 17, 25, 20, 2, -25 },
  { 1796, 18, 25, 20, 2, -25 },
  { 1853, 17, 25, 20, 2, -25 },
  { 1907, 18, 25, 20, 1, -25 },
  { 1964, 19, 25, 20, 2, -25 },
  { 2024, 15, 25, 20, 2, -25 },
  { 2071, 19, 25, 20, 1, -25 },
  { 2131, 18, 25, 20, 2, -25 },
  { 2188, 17, 25, 20, 2, -25 },
  { 2242, 18, 25, 20, 2, -25 },
  { 2299, 17, 31, 20, 2, -25 },
  { 2365, 18, 25, 20, 2, -25 },
  { 2422, 18, 25, 20, 2, -25 },
  { 2479, 17, 25, 20, 4, -25 },
  { 2533, 18, 25, 20, 2, -25 },
  { 2590, 17, 25, 20, 4, -25 },
  { 2644, 20, 25, 20, 2, -25 },
  { 2707, 21, 25, 20, 0, -25 },
  { 2773, 18, 25, 20, 4, -25 },
  { 2830, 19, 25, 20, 1, -25 },
  { 2890, 13, 32, 20, 5, -28 },
  { 2942, 10, 32, 20, 6, -28 },
  { 2982, 13, 32, 20, 3, -28 },
  { 3034, 15, 13, 20, 3, -25 },
  { 3059, 17, 2, 20, 0, 1 },
  { 3064, 6, 5, 20, 9, -27 },
  { 3068, 17, 19, 20, 2, -19 },
  { 3109, 16, 25, 20, 2, -25 },
  { 3159, 17, 19, 20, 2, -19 },
  { 3200, 18, 25, 20, 2, -25 },
  { 3257, 16, 19, 20, 2, -19 },
  { 3295, 24, 31, 20, -2, -25 },
  { 3388, 17, 25, 20, 2, -19 },
  { 3442, 16, 25, 20, 2, -25 },
  { 3492, 17, 26, 20, 1, -26 },
  { 3548, 18, 32, 20, 0, -26 },
  { 3620, 18, 25, 20, 2, -25 },
  { 3677, 15, 25, 20, 3, -25 },
  { 3724, 18, 19, 20, 1, -19 },
  { 3767, 16, 19, 20, 2, -19 },
  { 3805, 16, 19, 20, 2, -19 },
  { 3843, 17, 25, 20, 1, -19 },
  { 3897, 17, 25, 20, 2, -19 },
  { 3951, 17, 19, 20, 2, -19 },
  { 3992, 16, 19, 20, 2, -19 },
  { 4030, 16, 24, 20, 3, -24 },
  { 4078, 17, 19, 20, 2, -19 },
  { 4119, 17, 19, 20, 3, -19 },
  { 4160, 18, 19, 20, 3, -19 },
  { 4203, 20, 19, 20, 0, -19 },
  { 4251, 17, 25, 20, 2, -19 },
  { 4305, 16, 19, 20, 2, -19 },
  { 4343, 17, 32, 20, 3, -28 },
  { 4411, 8, 32, 20, 7, -28 },
  { 4443, 17, 32, 20, 1, -28 },
  { 4511, 17, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_ITALIC34PT7B_H_
