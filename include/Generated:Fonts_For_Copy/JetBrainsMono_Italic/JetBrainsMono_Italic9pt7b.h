#ifndef _JETBRAINSMONO_ITALIC9PT7B_H_
#define _JETBRAINSMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x29, 0x5E, 0xAF, 0xAA, 0x80, 0x11, 0x96,
  0xA3, 0x16, 0xAE, 0x20, 0x66, 0xAB, 0x14, 0x39, 0xA9, 0x80, 0x32, 0x50,
  0xCA, 0xCB, 0xE0, 0xE0, 0x12, 0x44, 0x44, 0x84, 0x20, 0x43, 0x11, 0x11,
  0x12, 0xC0, 0x16, 0xC8, 0xA0, 0x24, 0xF4, 0x60, 0xE0, 0x80, 0x0C, 0x21,
  0x08, 0x21, 0x04, 0x20, 0x69, 0x9D, 0x99, 0xE0, 0x13, 0x84, 0x22, 0x13,
  0xE0, 0x32, 0x42, 0x22, 0x23, 0xC0, 0x78, 0x4C, 0x60, 0xC5, 0xC0, 0x12,
  0x49, 0x9E, 0x20, 0x78, 0x8F, 0x11, 0xE0, 0x10, 0x88, 0xE4, 0xC5, 0xC0,
  0xF9, 0x12, 0x24, 0x80, 0x32, 0x52, 0x64, 0xC5, 0xC0, 0x69, 0x99, 0x64,
  0xC0, 0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C, 0x86, 0xFF, 0x60, 0xC7, 0xC0,
  0x61, 0x12, 0x40, 0xC0, 0x32, 0x57, 0x5A, 0xD6, 0x50, 0x60, 0x11, 0x8C,
  0xA7, 0x26, 0x20, 0x72, 0x52, 0xE4, 0xA7, 0xC0, 0x69, 0x88, 0x89, 0xE0,
  0x72, 0x52, 0x94, 0xAB, 0xC0, 0x3A, 0x10, 0xF4, 0x23, 0xC0, 0x7A, 0x10,
  0xF4, 0x22, 0x00, 0x69, 0x88, 0xB9, 0xE0, 0x4A, 0x52, 0xF4, 0xAA, 0x40,
  0x7A, 0x24, 0x44, 0xE0, 0x18, 0x42, 0x10, 0xC9, 0xC0, 0x45, 0x25, 0x1C,
  0x51, 0x48, 0x80, 0x48, 0x88, 0x88, 0xF0, 0x4B, 0x5E, 0xF4, 0xC6, 0x40,
  0x6B, 0x5A, 0xD6, 0xAA, 0x40, 0x69, 0x99, 0x99, 0xE0, 0x72, 0x52, 0xF4,
  0x22, 0x00, 0x69, 0x99, 0x99, 0xE2, 0x20, 0x72, 0x52, 0xF5, 0x2A, 0x60,
  0x32, 0x50, 0x60, 0xC5, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x00, 0x99, 0x99,
  0x99, 0xE0, 0x8C, 0xA5, 0x4A, 0x51, 0x00, 0xAD, 0x7D, 0xEB, 0x52, 0x80,
  0x45, 0x23, 0x08, 0x31, 0x49, 0x80, 0x8C, 0x98, 0xC4, 0x21, 0x00, 0x78,
  0x44, 0x42, 0x23, 0xC0, 0x74, 0x44, 0x44, 0x8E, 0xC9, 0x24, 0x49, 0x64,
  0x92, 0x96, 0x26, 0x69, 0xF0, 0xC0, 0x79, 0x9A, 0xE0, 0x42, 0x1E, 0x94,
  0xA7, 0xC0, 0x79, 0x89, 0xE0, 0x11, 0x79, 0x99, 0xE0, 0x69, 0xF8, 0xE0,
  0x1C, 0x87, 0x88, 0x20, 0x82, 0x10, 0x80, 0x79, 0x9A, 0xE2, 0xC0, 0x42,
  0x1E, 0x94, 0xA6, 0x40, 0x10, 0x1C, 0x22, 0x13, 0xE0, 0x18, 0x1C, 0x21,
  0x08, 0x44, 0xC0, 0x42, 0x12, 0xA6, 0x2A, 0x60, 0xC4, 0x44, 0x44, 0x70,
  0x7B, 0x6B, 0x5A, 0x80, 0x7A, 0x52, 0x99, 0x00, 0x69, 0x99, 0xE0, 0x7A,
  0x52, 0x97, 0x42, 0x00, 0x79, 0x9A, 0xE2, 0x20, 0xF9, 0x88, 0x80, 0xF8,
  0xE1, 0xE0, 0x4F, 0x44, 0x46, 0x99, 0x99, 0xE0, 0x99, 0xAA, 0x40, 0xDD,
  0xBA, 0xA0, 0x49, 0x88, 0xA9, 0x80, 0x99, 0x9A, 0xE2, 0xC0, 0x78, 0x88,
  0x8F, 0x00, 0x32, 0x2C, 0x24, 0x46, 0x56, 0xAA, 0x61, 0x08, 0x72, 0x10,
  0x98, 0xDA,
};

const GFXglyph JetBrainsMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 5, 0, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 3, 5, 3, -7 },
  { 28, 4, 9, 5, 1, -8 },
  { 33, 4, 9, 5, 0, -8 },
  { 38, 5, 4, 5, 0, -5 },
  { 41, 4, 4, 5, 1, -5 },
  { 43, 2, 2, 5, 1, -1 },
  { 44, 3, 1, 5, 1, -3 },
  { 45, 1, 1, 5, 2, -1 },
  { 46, 6, 8, 5, 0, -7 },
  { 52, 4, 7, 5, 1, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 1, -7 },
  { 75, 4, 7, 5, 1, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 4, 7, 5, 1, -7 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 4, 7, 5, 1, -7 },
  { 97, 2, 5, 5, 2, -5 },
  { 99, 3, 6, 5, 1, -5 },
  { 102, 4, 4, 5, 1, -5 },
  { 104, 4, 2, 5, 1, -4 },
  { 105, 5, 4, 5, 0, -5 },
  { 108, 4, 7, 5, 1, -7 },
  { 112, 5, 9, 5, 0, -7 },
  { 118, 5, 7, 5, 0, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 4, 7, 5, 1, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 4, 7, 5, 1, -7 },
  { 151, 5, 7, 5, 0, -7 },
  { 156, 4, 7, 5, 1, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 6, 7, 5, 0, -7 },
  { 171, 4, 7, 5, 1, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 4, 7, 5, 1, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 4, 9, 5, 1, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 5, 7, 5, 0, -7 },
  { 209, 5, 7, 5, 1, -7 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 5, 7, 5, 1, -7 },
  { 223, 5, 7, 5, 1, -7 },
  { 228, 6, 7, 5, 0, -7 },
  { 234, 5, 7, 5, 1, -7 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 4, 8, 5, 1, -7 },
  { 248, 3, 8, 5, 1, -7 },
  { 251, 3, 8, 5, 1, -7 },
  { 254, 4, 4, 5, 1, -7 },
  { 256, 4, 1, 5, 0, 0 },
  { 257, 2, 1, 5, 2, -7 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 5, 7, 5, 0, -7 },
  { 266, 4, 5, 5, 1, -5 },
  { 269, 4, 7, 5, 1, -7 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 6, 9, 5, 0, -7 },
  { 283, 4, 7, 5, 1, -5 },
  { 287, 5, 7, 5, 0, -7 },
  { 292, 5, 7, 5, 0, -7 },
  { 297, 5, 9, 5, 0, -7 },
  { 303, 5, 7, 5, 0, -7 },
  { 308, 4, 7, 5, 1, -7 },
  { 312, 5, 5, 5, 0, -5 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 4, 5, 5, 1, -5 },
  { 323, 5, 7, 5, 0, -5 },
  { 328, 4, 7, 5, 1, -5 },
  { 332, 4, 5, 5, 1, -5 },
  { 335, 4, 5, 5, 1, -5 },
  { 338, 4, 6, 5, 1, -6 },
  { 341, 4, 5, 5, 1, -5 },
  { 344, 4, 5, 5, 1, -5 },
  { 347, 4, 5, 5, 1, -5 },
  { 350, 5, 5, 5, 0, -5 },
  { 354, 4, 7, 5, 1, -5 },
  { 358, 5, 5, 5, 0, -5 },
  { 362, 4, 8, 5, 1, -7 },
  { 366, 2, 8, 5, 2, -7 },
  { 368, 5, 8, 5, 0, -7 },
  { 373, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_ITALIC9PT7B_H_
