#ifndef _JETBRAINSMONO_ITALIC27PT7B_H_
#define _JETBRAINSMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC0,
  0x00, 0x01, 0xCF, 0x3C, 0x73, 0xB1, 0xD8, 0xEC, 0x7E, 0x37, 0x1B, 0x0D,
  0x8E, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x61, 0x80, 0xC3,
  0x0F, 0xFF, 0x86, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x61, 0x80, 0xC3, 0x01,
  0x86, 0x1F, 0xFF, 0x3F, 0xFE, 0x18, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86,
  0x06, 0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x7C, 0x07, 0xF8,
  0x3B, 0xF1, 0xC8, 0xC6, 0x23, 0x18, 0x80, 0x66, 0x01, 0xD8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xCE, 0x03, 0x38, 0x0C, 0xEE, 0x33,
  0x98, 0x8C, 0x72, 0x71, 0xFF, 0x81, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x03, 0x80, 0x61, 0xF8, 0x18, 0x63, 0x06, 0x0C, 0x61,
  0x81, 0x8C, 0x60, 0x31, 0x98, 0x0E, 0x33, 0x00, 0xFC, 0xC0, 0x1F, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xCF, 0x00, 0x3B, 0xF0, 0x06, 0xC6,
  0x01, 0x98, 0xC0, 0x63, 0x18, 0x18, 0x63, 0x06, 0x0C, 0x61, 0xC1, 0xF8,
  0x70, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x38, 0xE0, 0xE1, 0xC1, 0x83,
  0x83, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xDC, 0x3B,
  0x18, 0xEE, 0x3B, 0x9C, 0x36, 0x38, 0x78, 0x60, 0x70, 0xC1, 0xE1, 0xC7,
  0xE3, 0xFC, 0xC3, 0xF1, 0xC0, 0x7F, 0xFF, 0xB6, 0x00, 0x30, 0x0E, 0x01,
  0xE0, 0x78, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x0C,
  0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x02, 0x0C, 0x27, 0x99, 0xFF, 0xAF, 0xC7, 0xFC,
  0x01, 0x80, 0x07, 0x80, 0x19, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x07, 0x00,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xE0,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x78, 0xE1, 0xC7,
  0x0C, 0x38, 0x60, 0xFF, 0xFF, 0xC0, 0x77, 0xBD, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x1E, 0x70, 0x73, 0x01, 0xB8,
  0x0D, 0x80, 0x6C, 0x07, 0x62, 0x3B, 0x39, 0xF9, 0xCD, 0xC4, 0x6E, 0x03,
  0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x0F, 0x1F, 0xF0, 0x7E, 0x00,
  0x00, 0xE0, 0x1F, 0x03, 0xF8, 0x3D, 0xC1, 0x8E, 0x18, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x1F,
  0xE1, 0xE3, 0xC7, 0x07, 0x38, 0x0C, 0xC0, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x38, 0x0C,
  0x60, 0x71, 0xC3, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC1, 0x9C,
  0x1C, 0xC0, 0xEE, 0x07, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0xF8, 0x7F, 0xE3, 0xC7, 0x9C, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xF0, 0x7E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x1F, 0xE1, 0xFF, 0x8E, 0x0E, 0xE0, 0x76, 0x01, 0xB0, 0x0D,
  0x80, 0x7C, 0x07, 0x60, 0x33, 0x87, 0x8F, 0xF8, 0x3F, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xC0, 0x7E, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE3,
  0xC7, 0x07, 0x18, 0x1C, 0x60, 0x71, 0x81, 0x87, 0x0E, 0x0E, 0xF0, 0x1F,
  0x00, 0xFE, 0x07, 0x1C, 0x30, 0x31, 0xC0, 0xE6, 0x03, 0x98, 0x0E, 0x60,
  0x31, 0xC1, 0xC7, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x0E, 0x3C, 0xE0,
  0xEE, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x07, 0x3E, 0xF8,
  0xFF, 0x80, 0x98, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xF3, 0xCF, 0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x01, 0xC0, 0x1C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x10, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x10, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x07, 0x00, 0x60, 0x00, 0x3C, 0x0F, 0xF1,
  0xFF, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x81, 0xF0, 0xFC,
  0x1C, 0x03, 0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xF8, 0x03, 0xFE, 0x0F, 0x07, 0x0C, 0x07, 0x18, 0x03, 0x18,
  0x03, 0x30, 0x03, 0x30, 0x7B, 0x30, 0xFB, 0x31, 0x87, 0x71, 0x86, 0x71,
  0x86, 0x63, 0x86, 0x63, 0x06, 0x63, 0x06, 0x63, 0x0E, 0x63, 0x9C, 0xE1,
  0xFC, 0xE0, 0x40, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x01, 0xB0,
  0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x06,
  0x1C, 0x18, 0x7F, 0xE3, 0xFF, 0x8E, 0x06, 0x30, 0x19, 0xC0, 0x66, 0x01,
  0xF8, 0x07, 0x1F, 0xC0, 0x7F, 0xE1, 0x87, 0xC6, 0x07, 0x18, 0x0C, 0x60,
  0x33, 0x81, 0xCE, 0x06, 0x38, 0x70, 0xFF, 0x83, 0xFF, 0x0C, 0x0E, 0x30,
  0x39, 0xC0, 0x67, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x83, 0xC7, 0xFE, 0x3F,
  0xE0, 0x07, 0xE0, 0x7F, 0x87, 0x1E, 0x70, 0x73, 0x01, 0xB8, 0x0D, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x58, 0x0C, 0xE0, 0x67, 0x0F, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7F, 0xC1, 0xCF, 0x86, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x18, 0x0C, 0x60, 0x71, 0x83, 0x87, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCE, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFF, 0xC7, 0xFE, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0xF0, 0xFF, 0xE1, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0x1E, 0x70, 0x73, 0x01, 0xB8, 0x0D, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0xFC, 0xC7, 0xEE, 0x03, 0x70, 0x3B, 0x81, 0xD8, 0x0C,
  0xE0, 0x67, 0x07, 0x1F, 0xF0, 0x7E, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0x70,
  0x30, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x18,
  0x7F, 0xF0, 0xFF, 0xE1, 0x81, 0xC3, 0x03, 0x8E, 0x07, 0x1C, 0x0C, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0xE1, 0x81, 0xC7, 0x03, 0x80, 0x1F, 0xF8, 0xFF,
  0xCF, 0xFE, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x71, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0x70, 0x30, 0xE0, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x1C, 0x07, 0x1C, 0x0E,
  0x1C, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x30, 0x38, 0x70, 0x38, 0xE0,
  0x38, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x31, 0xC0, 0x70, 0xC0, 0x70, 0xE0,
  0x70, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x60, 0x70, 0x60, 0x30, 0xE0, 0x38,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0x1C, 0x0E, 0x38, 0x3C, 0x50, 0x79,
  0xB1, 0xB3, 0x63, 0x46, 0xCD, 0x8D, 0x9B, 0x1B, 0x66, 0x32, 0xCC, 0x67,
  0xB9, 0xCE, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x1C,
  0xE0, 0x39, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x80, 0x1E, 0x0E, 0x3C, 0x1C,
  0x78, 0x30, 0xF0, 0x61, 0xE0, 0xC3, 0xE1, 0x8E, 0xC7, 0x1D, 0x8E, 0x33,
  0x18, 0x66, 0x30, 0xCE, 0x61, 0x8C, 0xC7, 0x1B, 0x8E, 0x37, 0x18, 0x6C,
  0x30, 0xF8, 0x60, 0xF0, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x80, 0x07, 0xE0,
  0x7F, 0x87, 0x1E, 0x70, 0x73, 0x01, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x60,
  0x33, 0x01, 0x98, 0x0C, 0xC0, 0x6E, 0x07, 0x70, 0x3B, 0x81, 0xD8, 0x0C,
  0xE0, 0xE7, 0x0E, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x71,
  0xF0, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C,
  0x60, 0x70, 0xFF, 0xC1, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0x1E, 0x70, 0x73, 0x01, 0xB8, 0x0D, 0xC0, 0x6C, 0x07, 0x60, 0x3B,
  0x01, 0xF8, 0x0D, 0xC0, 0x6E, 0x03, 0x60, 0x3B, 0x01, 0xD8, 0x0C, 0xC0,
  0xE7, 0x0F, 0x1F, 0xF0, 0x7E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x71, 0xF0, 0xC0, 0xE1, 0x80, 0xE3,
  0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE,
  0x07, 0x1C, 0x0E, 0x18, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xE1,
  0x81, 0xC7, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x38, 0xF0, 0xE0, 0x61,
  0x80, 0xC3, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x70, 0x1C, 0x60, 0x30,
  0xE0, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0x8C, 0x06,
  0x30, 0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0x80, 0xC6, 0x03,
  0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xE0, 0xE3, 0x87,
  0x07, 0xFC, 0x0F, 0xC0, 0xE0, 0x1F, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60,
  0x31, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xC1, 0xC3, 0x07, 0x1C, 0x1C,
  0x60, 0x73, 0x80, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x61, 0x86, 0xC7, 0x0D, 0x8E, 0x1F, 0x14, 0x7E, 0x28,
  0xDC, 0xD1, 0xB9, 0xA3, 0x62, 0x4C, 0xCD, 0x99, 0x9B, 0x33, 0x26, 0x66,
  0x4D, 0x8D, 0x9B, 0x1B, 0x36, 0x34, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0x87, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x86, 0x03, 0x83, 0x83, 0x80,
  0xC1, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x0C, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x33, 0x00, 0x39,
  0xC0, 0x38, 0x60, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x06, 0x1C, 0x03, 0x80,
  0xC0, 0x1F, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x70, 0x70, 0xC3, 0x83, 0x0C,
  0x0E, 0x70, 0x1B, 0x80, 0x6C, 0x01, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x0F, 0xE1, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFE, 0x00,
  0xE0, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x80, 0x0F, 0xE1, 0xFC, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x83, 0xF0, 0xFE, 0x00, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x6C, 0x0E, 0xC0,
  0xC6, 0x18, 0x63, 0x86, 0x30, 0x37, 0x03, 0xE0, 0x30, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE3, 0x8C, 0x30, 0x0F, 0xB8, 0xFF, 0xCE, 0x1E, 0xE0, 0xE6, 0x03,
  0x30, 0x19, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x30, 0x19, 0xC1, 0xCE,
  0x16, 0x3F, 0xF1, 0xFB, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x67, 0xC3, 0xFF, 0x8F, 0x0E, 0x38, 0x38, 0xE0, 0x63, 0x01,
  0x8C, 0x06, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC3,
  0xC7, 0xFE, 0x3B, 0xF0, 0x0F, 0xC0, 0xFF, 0x8E, 0x1C, 0xE0, 0x66, 0x03,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x1D, 0xC0, 0xCE,
  0x0E, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x3E, 0xE1, 0xFF, 0x8E, 0x1E, 0x70, 0x71, 0x80, 0xC6, 0x03,
  0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xE0, 0xE3, 0x85,
  0x87, 0xFE, 0x1F, 0xB8, 0x0F, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36,
  0x03, 0x7F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0xE0, 0xE7,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xB8, 0xFF, 0xCE, 0x1E, 0xE0, 0x66, 0x03, 0x30, 0x19, 0x81, 0xDC,
  0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xE3, 0xC7, 0xF6, 0x1F, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x1F, 0xE1, 0xFC, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x67, 0xC3, 0xFF, 0x8F, 0x0E, 0x38,
  0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x07, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x01,
  0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x01, 0xC6, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x61, 0xC0,
  0xC7, 0x01, 0xFC, 0x03, 0xF8, 0x0E, 0x30, 0x1C, 0x70, 0x38, 0x60, 0x60,
  0xE0, 0xC0, 0xC1, 0x81, 0xC7, 0x01, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xFF, 0x8F, 0xF0, 0x37,
  0x38, 0xFF, 0xF3, 0x18, 0xDC, 0x63, 0x71, 0x8D, 0x8C, 0x76, 0x31, 0xD8,
  0xC6, 0x63, 0x1B, 0x8C, 0x6E, 0x31, 0xB1, 0x86, 0xC6, 0x3B, 0x18, 0xCC,
  0x63, 0x00, 0x19, 0xF0, 0xFF, 0xE3, 0xC3, 0x8E, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x81, 0xCE, 0x07, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x77, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x6E, 0x0E, 0xE1,
  0xC7, 0xFC, 0x3F, 0x00, 0x19, 0xF0, 0xFF, 0xE3, 0xC3, 0x8E, 0x06, 0x38,
  0x18, 0xC0, 0x63, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x1C,
  0x1C, 0x70, 0xF1, 0xFF, 0x8E, 0xFC, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x0F, 0xB8, 0xFF, 0xCE, 0x1E, 0xE0, 0xE6, 0x03, 0x30,
  0x19, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x30, 0x19, 0xC1, 0xCE, 0x16,
  0x7F, 0xF1, 0xFB, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x3B, 0xE1, 0xBF, 0x8F, 0x1E, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0F, 0xE3, 0xFF, 0x38, 0x77, 0x03, 0x70, 0x07, 0x00, 0x7F, 0x03,
  0xFC, 0x03, 0xE0, 0x06, 0x00, 0x6C, 0x06, 0xE0, 0xEF, 0xFC, 0x7F, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x07, 0xFF, 0xFF, 0xFC, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x1C, 0x00, 0xFF, 0x03, 0xF8, 0x30, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x66, 0x03, 0x30, 0x19, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x30,
  0x19, 0xC1, 0xCE, 0x1C, 0x3F, 0xE0, 0xFC, 0x00, 0xC0, 0x3E, 0x01, 0xB8,
  0x1D, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x73, 0x83, 0x98,
  0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xC3, 0x0F, 0x0C,
  0x3C, 0x70, 0xF1, 0xC6, 0xC5, 0x1B, 0x34, 0x6C, 0xD3, 0x32, 0x4C, 0xD9,
  0x33, 0x64, 0x8D, 0x16, 0x3C, 0x58, 0xF1, 0x43, 0x87, 0x0E, 0x1C, 0x00,
  0x1C, 0x0F, 0x0C, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x70, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x1C, 0x70,
  0x38, 0x30, 0x30, 0x38, 0xF0, 0x3C, 0x30, 0x3B, 0x81, 0xDC, 0x0E, 0xE0,
  0x66, 0x03, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39,
  0xE3, 0xC7, 0xF6, 0x1E, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x1F,
  0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE2, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x1F, 0xC0, 0x7E, 0x02, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xF8,
  0x01, 0xC0, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61,
  0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE0,
  0x1F, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xF0, 0x1F, 0x81, 0xC0, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x1B, 0xF0, 0xF9, 0xCF, 0x87, 0xEC,
  0x1E, 0x00,
};

const GFXglyph JetBrainsMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 9, 8, 16, 5, -20 },
  { 25, 15, 20, 16, 1, -20 },
  { 63, 14, 27, 16, 1, -23 },
  { 111, 19, 20, 16, -1, -20 },
  { 159, 15, 20, 16, 1, -20 },
  { 197, 3, 8, 16, 8, -20 },
  { 200, 12, 26, 16, 4, -23 },
  { 239, 11, 26, 16, 1, -23 },
  { 275, 15, 13, 16, 1, -16 },
  { 300, 13, 12, 16, 2, -15 },
  { 320, 7, 8, 16, 3, -4 },
  { 327, 9, 2, 16, 4, -10 },
  { 330, 5, 4, 16, 5, -4 },
  { 333, 17, 25, 16, 0, -22 },
  { 387, 13, 20, 16, 2, -20 },
  { 420, 13, 20, 16, 1, -20 },
  { 453, 14, 20, 16, 1, -20 },
  { 488, 14, 20, 16, 1, -20 },
  { 523, 13, 20, 16, 2, -20 },
  { 556, 13, 20, 16, 2, -20 },
  { 589, 13, 20, 16, 1, -20 },
  { 622, 13, 20, 16, 3, -20 },
  { 655, 14, 20, 16, 1, -20 },
  { 690, 13, 20, 16, 3, -20 },
  { 723, 6, 15, 16, 5, -15 },
  { 735, 8, 19, 16, 3, -15 },
  { 754, 13, 14, 16, 2, -16 },
  { 777, 13, 8, 16, 2, -13 },
  { 790, 13, 14, 16, 1, -16 },
  { 813, 11, 20, 16, 4, -20 },
  { 841, 16, 25, 16, 0, -20 },
  { 891, 14, 20, 16, 0, -20 },
  { 926, 14, 20, 16, 1, -20 },
  { 961, 13, 20, 16, 2, -20 },
  { 994, 14, 20, 16, 1, -20 },
  { 1029, 14, 20, 16, 2, -20 },
  { 1064, 15, 20, 16, 1, -20 },
  { 1102, 13, 20, 16, 2, -20 },
  { 1135, 15, 20, 16, 1, -20 },
  { 1173, 13, 20, 16, 2, -20 },
  { 1206, 15, 20, 16, 0, -20 },
  { 1244, 16, 20, 16, 1, -20 },
  { 1284, 12, 20, 16, 2, -20 },
  { 1314, 15, 20, 16, 1, -20 },
  { 1352, 15, 20, 16, 1, -20 },
  { 1390, 13, 20, 16, 2, -20 },
  { 1423, 15, 20, 16, 1, -20 },
  { 1461, 13, 25, 16, 2, -20 },
  { 1502, 15, 20, 16, 1, -20 },
  { 1540, 15, 20, 16, 1, -20 },
  { 1578, 14, 20, 16, 3, -20 },
  { 1613, 14, 20, 16, 2, -20 },
  { 1648, 14, 20, 16, 3, -20 },
  { 1683, 15, 20, 16, 2, -20 },
  { 1721, 17, 20, 16, 0, -20 },
  { 1764, 14, 20, 16, 3, -20 },
  { 1799, 15, 20, 16, 1, -20 },
  { 1837, 11, 25, 16, 4, -22 },
  { 1872, 9, 25, 16, 4, -22 },
  { 1901, 11, 25, 16, 2, -22 },
  { 1936, 12, 11, 16, 2, -20 },
  { 1953, 13, 2, 16, 0, 1 },
  { 1957, 5, 4, 16, 7, -21 },
  { 1960, 13, 15, 16, 2, -15 },
  { 1985, 14, 20, 16, 1, -20 },
  { 2020, 13, 15, 16, 2, -15 },
  { 2045, 14, 20, 16, 2, -20 },
  { 2080, 12, 15, 16, 2, -15 },
  { 2103, 18, 25, 16, -1, -20 },
  { 2160, 13, 20, 16, 2, -15 },
  { 2193, 14, 20, 16, 1, -20 },
  { 2228, 13, 21, 16, 1, -21 },
  { 2263, 14, 26, 16, 0, -21 },
  { 2309, 15, 20, 16, 1, -20 },
  { 2347, 11, 20, 16, 3, -20 },
  { 2375, 14, 15, 16, 1, -15 },
  { 2402, 14, 15, 16, 1, -15 },
  { 2429, 12, 15, 16, 2, -15 },
  { 2452, 14, 20, 16, 1, -15 },
  { 2487, 13, 20, 16, 2, -15 },
  { 2520, 13, 15, 16, 2, -15 },
  { 2545, 12, 15, 16, 2, -15 },
  { 2568, 13, 19, 16, 2, -19 },
  { 2599, 13, 15, 16, 2, -15 },
  { 2624, 13, 15, 16, 3, -15 },
  { 2649, 14, 15, 16, 2, -15 },
  { 2676, 16, 15, 16, 0, -15 },
  { 2706, 13, 20, 16, 2, -15 },
  { 2739, 14, 15, 16, 1, -15 },
  { 2766, 14, 25, 16, 2, -22 },
  { 2810, 7, 25, 16, 5, -22 },
  { 2832, 13, 25, 16, 1, -22 },
  { 2873, 13, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_ITALIC27PT7B_H_
