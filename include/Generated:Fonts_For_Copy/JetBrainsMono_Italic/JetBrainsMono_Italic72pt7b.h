#ifndef _JETBRAINSMONO_ITALIC72PT7B_H_
#define _JETBRAINSMONO_ITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC7, 0x8F, 0xF8, 0x01, 0xFC,
  0x1E, 0x1F, 0xE0, 0x0F, 0xE0, 0x78, 0x3F, 0x80, 0x3F, 0x81, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0x81, 0xFC, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x1F, 0x80,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x00, 0x00,
  0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xC0, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00,
  0x1F, 0xF1, 0xE0, 0x00, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0x83,
  0xFC, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0xC0, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3C, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x1F,
  0x81, 0xFC, 0x07, 0x80, 0xFE, 0x07, 0xF8, 0x1E, 0x07, 0xF0, 0x1F, 0xE0,
  0x78, 0x3F, 0xC0, 0x3F, 0xE1, 0xE1, 0xFE, 0x00, 0xFF, 0xEF, 0xBF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE1,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE1,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xDF, 0xC0, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xFE, 0x3F, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x07, 0xE0, 0x00, 0x8F, 0x00,
  0x1F, 0x00, 0x1E, 0x3F, 0x80, 0x7C, 0x03, 0xF9, 0xFF, 0x81, 0xF0, 0x7F,
  0xE7, 0xFF, 0x87, 0x87, 0xFF, 0xFF, 0xFF, 0x1E, 0x3F, 0xFF, 0x7F, 0xFF,
  0x73, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0x0F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE3, 0xFF,
  0x0F, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x01, 0xC0, 0x1F, 0x83, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xE0,
  0xFF, 0x83, 0xF0, 0x3F, 0x07, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0xFC, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xBF, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x7F,
  0xE1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x0C, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x00,
  0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x03, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFD, 0xFC,
  0x00, 0x1F, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xFC, 0x7C,
  0x07, 0xE0, 0x03, 0xFF, 0xE7, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0x7C, 0x07,
  0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x7C, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3E, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7E, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0xF7, 0xC0, 0x7E,
  0x00, 0x3F, 0xFE, 0x7C, 0x07, 0xE0, 0x01, 0xFF, 0xC7, 0xC0, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0xFF,
  0x83, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0x78, 0x03, 0xDF, 0x00, 0x1F,
  0xFC, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0xFC, 0xFC, 0x03,
  0xF1, 0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x7E, 0x3E, 0x00, 0xF8, 0x7C,
  0x3E, 0x3F, 0x00, 0x7C, 0x3E, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x1F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x1F, 0x83, 0xCF, 0x87, 0xE0, 0x0F,
  0xC1, 0xF7, 0xC3, 0xF0, 0x07, 0xE0, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x7F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xF0, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x7E,
  0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xEF,
  0x80, 0x07, 0xE0, 0x0F, 0xDF, 0x00, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F,
  0x80, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0xF8, 0x01, 0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07,
  0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x7F,
  0x0F, 0x80, 0x7F, 0x00, 0xFE, 0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xF0, 0x03,
  0xF3, 0xF0, 0x07, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x80, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0x00,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0xF7, 0x80, 0x3E, 0x0F, 0xC0, 0x3D, 0xE0, 0x1F, 0x83, 0xE0, 0x0F,
  0x78, 0x07, 0xE1, 0xF8, 0x07, 0x9E, 0x01, 0xF8, 0x7E, 0x01, 0xE7, 0x80,
  0xFC, 0x1F, 0x80, 0x79, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x78, 0x0F, 0xC1,
  0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x7E, 0x03, 0xC7, 0x81, 0xF8, 0x1F, 0x80,
  0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0x78, 0xF8, 0x1F, 0x81, 0xF8, 0x1E, 0x3C,
  0x07, 0xC0, 0x7E, 0x07, 0x8F, 0x03, 0xF0, 0x1F, 0x83, 0xE3, 0xC0, 0xFC,
  0x07, 0xE0, 0xF0, 0xF0, 0x3E, 0x01, 0xF8, 0x3C, 0x3C, 0x0F, 0x80, 0x7E,
  0x0F, 0x0F, 0x07, 0xE0, 0x1F, 0x87, 0xC3, 0xC1, 0xF8, 0x07, 0xE1, 0xE0,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x3C, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0x0F,
  0xC0, 0x1F, 0x0F, 0x03, 0xC3, 0xF0, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x01,
  0xF0, 0xF0, 0x3C, 0x7E, 0x00, 0x7C, 0x7C, 0x0F, 0x1F, 0x80, 0x1F, 0x1E,
  0x03, 0xC7, 0xC0, 0x0F, 0xC7, 0x80, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x3C,
  0xFC, 0x00, 0xFC, 0xF0, 0x0F, 0x3F, 0x00, 0x3F, 0x3C, 0x03, 0xCF, 0x80,
  0x0F, 0xCF, 0x00, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0xFD,
  0xE0, 0x1F, 0x7E, 0x00, 0x3F, 0x78, 0x07, 0x9F, 0x00, 0x0F, 0xFE, 0x01,
  0xE7, 0xC0, 0x03, 0xFF, 0x00, 0x7B, 0xF0, 0x00, 0xFB, 0xC0, 0x1E, 0xF8,
  0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x7F,
  0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF,
  0xE7, 0xE0, 0x1F, 0xFC, 0x3F, 0x7E, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0x80, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1E, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFC,
  0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xC0, 0x07, 0xFF, 0xF1, 0xFC, 0x00, 0x3F,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x01,
  0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFF,
  0x80, 0x3F, 0x3F, 0xFF, 0xFC, 0x03, 0xF7, 0xE1, 0xFF, 0xC0, 0x3F, 0x70,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF8,
  0x07, 0xF7, 0xFF, 0xFF, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x07, 0xE1, 0xFF,
  0xF8, 0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0x7F,
  0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xFF, 0x9F, 0x80, 0x1F, 0xFC, 0x3F, 0x7E,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x07, 0xBF, 0x00, 0x3F, 0xFF, 0xFE, 0xFC, 0x00, 0x7F,
  0xFF, 0xF3, 0xF0, 0x00, 0xFF, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0xFC, 0x7F,
  0x00, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0x00,
  0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xBF, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF,
  0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xF0, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xFF, 0x80, 0x01, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0x9F,
  0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0x03,
  0xF7, 0xE0, 0xFF, 0xC0, 0x3F, 0x70, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE0, 0x07, 0xC7, 0xFC, 0x3F, 0xE0,
  0x1F, 0x9F, 0xF8, 0xFF, 0xE0, 0x3F, 0x7F, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0x87,
  0xFF, 0xE0, 0x03, 0xF9, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0xF8, 0x03,
  0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0x7E, 0x0F, 0xFC, 0x03, 0xF7, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x9F,
  0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xF0, 0x03, 0xF7, 0xE1, 0xFF, 0xC0,
  0x0F, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0x80, 0x1F, 0x9F,
  0xFF, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xFF, 0x00,
  0x07, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xFE,
  0x7E, 0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1E, 0xFC, 0x03, 0xFF, 0xFF, 0xEF,
  0xC0, 0x1F, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xC0, 0x07, 0xFF,
  0xF1, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0x7E,
  0x1F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0x80,
  0x7F, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0x01, 0xFB, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xC0,
  0x0F, 0xBE, 0x00, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xC0, 0x3F, 0x3E, 0x01, 0xEF, 0x00,
  0xF8, 0xF8, 0x07, 0xBC, 0x03, 0xE3, 0xE0, 0x1E, 0xF0, 0x0F, 0x8F, 0x80,
  0xF3, 0xC0, 0x7E, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x07,
  0xC3, 0xE0, 0x78, 0xF0, 0x3F, 0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x3E, 0x07,
  0x8F, 0x03, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x83, 0xE0, 0xF0, 0xF0, 0x7C,
  0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x3E, 0x1E, 0x0F, 0x0F, 0xC0, 0xF8, 0x78,
  0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0xF0, 0xF8, 0x0F, 0x8F, 0x03, 0xC3, 0xE0,
  0x3E, 0x3C, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x03, 0xE7, 0x80,
  0xF1, 0xF0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x3E, 0x78, 0x0F, 0x3E, 0x00,
  0xF9, 0xE0, 0x3C, 0xF8, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x0F, 0xBC, 0x03,
  0xDF, 0x00, 0x3E, 0xF0, 0x0F, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xBF, 0x01, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF,
  0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xF0, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xF0,
  0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0x83, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x7F, 0x01, 0xFE, 0x0F, 0xE7, 0xE0, 0x0F, 0xFB, 0xFC,
  0x7E, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xF8, 0x7E, 0x00, 0x3F,
  0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 18, 53, 43, 13, -53 },
  { 121, 25, 22, 43, 13, -53 },
  { 190, 42, 53, 43, 2, -53 },
  { 469, 38, 73, 43, 3, -63 },
  { 816, 49, 53, 43, -2, -53 },
  { 1141, 39, 54, 43, 2, -53 },
  { 1405, 10, 22, 43, 20, -53 },
  { 1433, 30, 70, 43, 11, -61 },
  { 1696, 29, 70, 43, 4, -61 },
  { 1950, 38, 37, 43, 4, -44 },
  { 2126, 35, 34, 43, 5, -41 },
  { 2275, 19, 23, 43, 7, -11 },
  { 2330, 24, 6, 43, 10, -27 },
  { 2348, 13, 12, 43, 13, -11 },
  { 2368, 43, 68, 43, 1, -60 },
  { 2734, 37, 54, 43, 4, -53 },
  { 2984, 34, 53, 43, 3, -53 },
  { 3210, 38, 53, 43, 3, -53 },
  { 3462, 37, 54, 43, 3, -53 },
  { 3712, 35, 53, 43, 4, -53 },
  { 3944, 35, 54, 43, 5, -53 },
  { 4181, 35, 54, 43, 4, -53 },
  { 4418, 35, 53, 43, 9, -53 },
  { 4650, 36, 54, 43, 4, -53 },
  { 4893, 35, 53, 43, 7, -53 },
  { 5125, 17, 41, 43, 13, -40 },
  { 5213, 23, 52, 43, 7, -40 },
  { 5363, 35, 38, 43, 6, -43 },
  { 5530, 35, 23, 43, 5, -35 },
  { 5631, 34, 38, 43, 4, -43 },
  { 5793, 29, 53, 43, 10, -53 },
  { 5986, 44, 66, 43, 0, -53 },
  { 6349, 36, 53, 43, 0, -53 },
  { 6588, 37, 53, 43, 4, -53 },
  { 6834, 36, 54, 43, 5, -53 },
  { 7077, 37, 53, 43, 3, -53 },
  { 7323, 39, 53, 43, 4, -53 },
  { 7582, 39, 53, 43, 4, -53 },
  { 7841, 36, 54, 43, 5, -53 },
  { 8084, 38, 53, 43, 4, -53 },
  { 8336, 37, 53, 43, 4, -53 },
  { 8582, 40, 54, 43, 1, -53 },
  { 8852, 42, 53, 43, 3, -53 },
  { 9131, 31, 53, 43, 5, -53 },
  { 9337, 41, 53, 43, 2, -53 },
  { 9609, 39, 53, 43, 3, -53 },
  { 9868, 36, 54, 43, 5, -53 },
  { 10111, 40, 53, 43, 3, -53 },
  { 10376, 37, 66, 43, 4, -53 },
  { 10682, 39, 53, 43, 3, -53 },
  { 10941, 38, 54, 43, 3, -53 },
  { 11198, 36, 53, 43, 8, -53 },
  { 11437, 38, 54, 43, 4, -53 },
  { 11694, 36, 53, 43, 9, -53 },
  { 11933, 42, 53, 43, 5, -53 },
  { 12212, 45, 53, 43, 0, -53 },
  { 12511, 38, 53, 43, 8, -53 },
  { 12763, 39, 53, 43, 3, -53 },
  { 13022, 29, 68, 43, 10, -60 },
  { 13269, 21, 68, 43, 12, -60 },
  { 13448, 29, 68, 43, 6, -60 },
  { 13695, 32, 29, 43, 6, -53 },
  { 13811, 35, 5, 43, 0, 2 },
  { 13833, 13, 11, 43, 19, -57 },
  { 13851, 36, 41, 43, 4, -40 },
  { 14036, 36, 54, 43, 3, -53 },
  { 14279, 34, 41, 43, 5, -40 },
  { 14454, 38, 54, 43, 4, -53 },
  { 14711, 33, 41, 43, 5, -40 },
  { 14881, 49, 66, 43, -3, -53 },
  { 15286, 35, 53, 43, 5, -40 },
  { 15518, 36, 53, 43, 3, -53 },
  { 15757, 34, 56, 43, 3, -56 },
  { 15995, 37, 69, 43, 1, -56 },
  { 16315, 38, 53, 43, 4, -53 },
  { 16567, 30, 53, 43, 7, -53 },
  { 16766, 39, 40, 43, 2, -40 },
  { 16961, 36, 40, 43, 3, -40 },
  { 17141, 33, 41, 43, 5, -40 },
  { 17311, 38, 53, 43, 1, -40 },
  { 17563, 36, 53, 43, 4, -40 },
  { 17802, 35, 40, 43, 5, -40 },
  { 17977, 34, 41, 43, 4, -40 },
  { 18152, 35, 50, 43, 6, -50 },
  { 18371, 36, 41, 43, 4, -40 },
  { 18556, 35, 40, 43, 7, -40 },
  { 18731, 38, 40, 43, 6, -40 },
  { 18921, 41, 40, 43, 1, -40 },
  { 19126, 35, 53, 43, 5, -40 },
  { 19358, 36, 40, 43, 3, -40 },
  { 19538, 36, 68, 43, 7, -60 },
  { 19844, 17, 68, 43, 14, -60 },
  { 19989, 36, 68, 43, 2, -60 },
  { 20295, 36, 15, 43, 4, -33 },
};

const GFXfont JetBrainsMono_Italic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_ITALIC72PT7B_H_
