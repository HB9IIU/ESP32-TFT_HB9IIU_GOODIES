#ifndef _JETBRAINSMONO_ITALIC26PT7B_H_
#define _JETBRAINSMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0x00,
  0x00, 0xF3, 0xCE, 0x00, 0x63, 0xB1, 0xB8, 0xDC, 0x6C, 0x76, 0x3B, 0x19,
  0x8C, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x20, 0x30, 0xC0, 0x61, 0x87, 0xFF,
  0xCF, 0xFF, 0x86, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0x82, 0x0F,
  0xFF, 0x9F, 0xFF, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x86, 0x03, 0x0C,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F, 0xE1,
  0xC9, 0x86, 0x67, 0x19, 0x9C, 0xE6, 0x03, 0x98, 0x07, 0x40, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0xDC, 0x03, 0x30, 0x08, 0xCE, 0x23, 0x38, 0x8C,
  0x76, 0x61, 0xFF, 0x83, 0xF8, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0xC7, 0xF0, 0x61, 0x8C, 0x30, 0x63, 0x18, 0x18, 0xCC,
  0x0C, 0x33, 0x03, 0x99, 0x80, 0x7C, 0xC0, 0x0E, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x80, 0x0E, 0xF8, 0x03, 0x77, 0x01, 0x98, 0xC0, 0xC4, 0x30, 0x63,
  0x0C, 0x30, 0xC6, 0x18, 0x3F, 0x8E, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xC1,
  0xC3, 0x06, 0x0C, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x01,
  0xF8, 0x16, 0x71, 0xB8, 0xCE, 0xE3, 0xF3, 0x87, 0x8C, 0x1C, 0x30, 0x78,
  0xE3, 0xE3, 0xFD, 0xC7, 0xE3, 0x80, 0x77, 0x66, 0x66, 0xEC, 0x00, 0x60,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x01, 0xC0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x61, 0x0F, 0xE5, 0xF3, 0xFF, 0x00, 0xC0, 0x07, 0x80,
  0x37, 0x01, 0x8C, 0x0E, 0x38, 0x70, 0x60, 0x81, 0x00, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x38, 0x71, 0xC3, 0x86, 0x1C, 0x70,
  0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x1C, 0x60,
  0x77, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x66, 0x37, 0x39, 0xB9, 0x9D,
  0x80, 0xEC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xE1, 0xC7, 0xFC, 0x0F,
  0xC0, 0x01, 0xE0, 0x7C, 0x0E, 0xC1, 0xCC, 0x30, 0xC2, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x8E,
  0x06, 0x38, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xCE, 0x07, 0x38, 0x18, 0x70, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x73, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x6F, 0xFE, 0xFF,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1F, 0xF9, 0xFF, 0x8C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xE3, 0x83, 0x18,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x98, 0x1C, 0xE1, 0xC7, 0xFC,
  0x1F, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x03, 0xB8, 0x3F, 0xF1, 0xC3, 0x9C, 0x0E, 0xC0, 0x76, 0x03, 0xF0,
  0x1F, 0x80, 0xCC, 0x0E, 0x70, 0xE3, 0xFE, 0x07, 0xE0, 0x7F, 0xFB, 0xFF,
  0xD8, 0x0D, 0xC0, 0xEE, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x86, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x83, 0x87, 0x1C, 0x0F, 0xC0, 0x1F, 0x01, 0xCE, 0x0E,
  0x1C, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x70, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x1C, 0xE0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEC, 0x06, 0x60, 0x73, 0x87, 0x8F, 0xF8, 0x39, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0xF7, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3, 0xCF, 0x00, 0x06, 0x0F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xC0, 0x00, 0x18, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x03, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x06, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0x30, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x07, 0x8F, 0xC3, 0xC0, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x3C,
  0x0E, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x07,
  0x30, 0x07, 0x30, 0x36, 0x30, 0xFE, 0x31, 0xCE, 0x31, 0x86, 0x63, 0x86,
  0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C, 0x63, 0x0C, 0x63, 0x1C, 0xC3, 0xEC,
  0xC0, 0x80, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60, 0x3B, 0x01, 0x98,
  0x1C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x38, 0x61, 0xFF, 0x9F,
  0xFC, 0xC0, 0xE6, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x06, 0x1F, 0xE0, 0x7F,
  0xE1, 0x83, 0x86, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x81, 0x8C, 0x0C, 0x3F,
  0xE0, 0xFF, 0x83, 0x07, 0x1C, 0x0C, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x18,
  0x1C, 0x60, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x1C,
  0x60, 0x77, 0x03, 0xB8, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x01, 0x98, 0x1C, 0xE1, 0xC3, 0xFC,
  0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0x83, 0x86, 0x06, 0x18, 0x18, 0xE0,
  0x63, 0x81, 0x8C, 0x06, 0x30, 0x38, 0xC0, 0xE3, 0x03, 0x9C, 0x0C, 0x70,
  0x31, 0x80, 0xC6, 0x07, 0x18, 0x18, 0x61, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0xFF, 0x8E, 0x1C, 0x60, 0x77, 0x03, 0xB8, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x1F, 0xB9, 0xFD, 0xC0, 0xEE, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C,
  0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x1C, 0x0C, 0x60, 0x71, 0x81, 0xC6, 0x07,
  0x18, 0x18, 0xE0, 0x63, 0x81, 0x8C, 0x0E, 0x3F, 0xF8, 0xFF, 0xE3, 0x03,
  0x1C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x07, 0x18, 0x1C, 0x60, 0x61, 0x81,
  0x8E, 0x06, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x18, 0x0C, 0x30, 0x18, 0x70, 0x60, 0x7F, 0xC0, 0x7E, 0x00, 0x1C, 0x0E,
  0x30, 0x18, 0x60, 0x70, 0xC1, 0xC1, 0x83, 0x07, 0x0E, 0x0E, 0x38, 0x18,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xC6, 0x03, 0x8E, 0x07, 0x0C, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x30, 0x60, 0x71, 0xC0, 0xE3, 0x80, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0xF1, 0xA1, 0xE3, 0x66, 0xC6, 0xCD,
  0x8D, 0xB6, 0x1B, 0x6C, 0x77, 0x98, 0xE7, 0x31, 0x8C, 0x63, 0x01, 0xC6,
  0x03, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x31, 0x80, 0xE3, 0x01,
  0xC0, 0x1C, 0x0C, 0x78, 0x31, 0xE1, 0xC7, 0x87, 0x3E, 0x18, 0xF8, 0x63,
  0x31, 0x8C, 0xC6, 0x33, 0x18, 0xCC, 0xE3, 0x33, 0x1C, 0x6C, 0x61, 0xB1,
  0x86, 0xC6, 0x1B, 0x18, 0x6C, 0x60, 0xF3, 0x83, 0x8E, 0x0E, 0x00, 0x07,
  0xE0, 0xFF, 0x8E, 0x1C, 0x60, 0x67, 0x03, 0x38, 0x19, 0x80, 0xCC, 0x06,
  0x60, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x03, 0x98,
  0x1C, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x60, 0x70,
  0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8E, 0x03, 0x18, 0x0E, 0x30, 0x38, 0x7F,
  0xE0, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x1C, 0x60,
  0x77, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB8, 0x1D,
  0x80, 0xEC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C, 0xE1, 0xC7, 0xFC, 0x0F,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x1F, 0xF0, 0x7F,
  0xE1, 0x83, 0xC6, 0x07, 0x18, 0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x30,
  0x78, 0xFF, 0xC3, 0xFC, 0x1C, 0x70, 0x71, 0xC1, 0x83, 0x06, 0x0E, 0x18,
  0x38, 0x60, 0x63, 0x81, 0xCE, 0x07, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC1,
  0x86, 0x07, 0x18, 0x1C, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xCE, 0x03, 0x38, 0x1C, 0x70,
  0xE1, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x38, 0x19, 0x80, 0xCC, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x19, 0xC0, 0xCC,
  0x06, 0x60, 0x73, 0x03, 0x98, 0x19, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x03,
  0x98, 0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0xE0, 0x1F, 0x01, 0xF8, 0x0C,
  0xC0, 0xE6, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x0C, 0x18,
  0xE0, 0xE6, 0x07, 0x30, 0x1B, 0x80, 0xD8, 0x06, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xE3, 0x87, 0xC7, 0x1B, 0x8E, 0x37, 0x3C, 0x6C, 0x79, 0xD8,
  0xB3, 0x31, 0x66, 0x66, 0xCC, 0xCD, 0xB1, 0x93, 0x63, 0x66, 0xC6, 0xC9,
  0x8D, 0x16, 0x1A, 0x2C, 0x3C, 0x58, 0x78, 0xB0, 0xE1, 0xC1, 0xC3, 0x83,
  0x87, 0x00, 0x1C, 0x07, 0x0C, 0x0E, 0x0E, 0x0C, 0x06, 0x1C, 0x06, 0x38,
  0x07, 0x30, 0x03, 0x70, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x06, 0xE0, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x30, 0x30, 0x30,
  0x70, 0x38, 0xE0, 0x18, 0xC0, 0x1F, 0x80, 0xE6, 0x03, 0x18, 0x18, 0x70,
  0xE0, 0xC3, 0x03, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x0F, 0xC7, 0xF1, 0xFC, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0xF0, 0xFC, 0x00, 0xE0, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x0C,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x03, 0x0F, 0xE1, 0xF8,
  0x3F, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x87, 0xF0, 0xFE, 0x00, 0x03, 0x80, 0x38, 0x06,
  0xC0, 0xEC, 0x0C, 0xC1, 0x8C, 0x18, 0x63, 0x06, 0x70, 0x6E, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x02, 0x01, 0xFB, 0x3D, 0xB7, 0x07, 0x60,
  0x76, 0x07, 0x60, 0x6E, 0x06, 0xE0, 0x6C, 0x06, 0xC0, 0xEC, 0x0E, 0xE1,
  0xEF, 0xFC, 0x7C, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x88,
  0x1D, 0xF8, 0xFF, 0xC7, 0x07, 0x30, 0x39, 0x81, 0xCC, 0x0E, 0xE0, 0x67,
  0x03, 0x30, 0x19, 0x81, 0xCC, 0x0E, 0x70, 0xE7, 0xFE, 0x3B, 0xE0, 0x02,
  0x01, 0xFE, 0x3F, 0xE7, 0x07, 0x60, 0x76, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x6C, 0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x23, 0x0F, 0xD8, 0xF6, 0xCE, 0x0E, 0x60,
  0x73, 0x03, 0x98, 0x19, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x03, 0x98, 0x1C,
  0xE1, 0xE7, 0xFE, 0x1F, 0x30, 0x03, 0x01, 0xFC, 0x3D, 0xE7, 0x07, 0x60,
  0x76, 0x07, 0xE0, 0x7F, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0E, 0xE0,
  0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x06, 0x01,
  0xFB, 0x3D, 0xF7, 0x07, 0x60, 0x76, 0x07, 0x60, 0x6E, 0x06, 0xE0, 0x6C,
  0x06, 0xE0, 0xEE, 0x1E, 0x7F, 0xE3, 0xEC, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x78, 0x7F, 0x0F, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x8C,
  0x1D, 0xF8, 0xFB, 0xC7, 0x07, 0x30, 0x39, 0x81, 0xCC, 0x0C, 0xE0, 0x67,
  0x03, 0x30, 0x19, 0x81, 0xCC, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x18, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0xF8,
  0x3F, 0xC0, 0xFC, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x73, 0x83, 0x8C, 0x1C, 0x30, 0xE0, 0xC7, 0x03, 0x18, 0x0F,
  0xC0, 0x7F, 0x81, 0xC6, 0x06, 0x1C, 0x18, 0x30, 0x60, 0xE1, 0x81, 0x8E,
  0x07, 0x00, 0xFE, 0x1F, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x27, 0xF8, 0x7F, 0x00, 0x02, 0x10, 0xFD, 0xE3, 0xB9, 0x9C, 0xC7,
  0x63, 0x19, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x1B, 0x88, 0xEC, 0x63,
  0x31, 0x8C, 0xC6, 0x33, 0x18, 0xCC, 0x63, 0x00, 0x00, 0xC1, 0xDF, 0x8F,
  0xBC, 0x70, 0x73, 0x03, 0x98, 0x1C, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0x01,
  0x98, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x33, 0x81, 0x80, 0x03, 0x01, 0xFC,
  0x3F, 0xE7, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x6C, 0x06,
  0xC0, 0xEC, 0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x40, 0x77, 0xE1,
  0xFF, 0x87, 0x07, 0x18, 0x1C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x38, 0x18,
  0xC0, 0x63, 0x03, 0x8C, 0x0E, 0x38, 0x71, 0xFF, 0x87, 0x7C, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x02, 0x01, 0xFB, 0x3D, 0xB7,
  0x07, 0x60, 0x76, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6C, 0x06, 0xC0, 0xEC,
  0x0E, 0xE1, 0xCF, 0xFC, 0x7C, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x00, 0x81, 0xBF, 0x0F, 0xBC, 0x70, 0x67, 0x03, 0x38, 0x19, 0x80,
  0xCC, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x03, 0x01, 0xFE, 0x3F, 0xF7, 0x07, 0x60, 0x07, 0x00, 0x78,
  0x03, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x6C, 0x0E, 0xC0, 0xCF, 0xFC, 0x7F,
  0x80, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xF8, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x70, 0x37, 0x03, 0x60, 0x36,
  0x07, 0x60, 0x76, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE,
  0x1C, 0x7F, 0x83, 0xF0, 0xC0, 0x7C, 0x06, 0xC0, 0xEE, 0x0C, 0xE1, 0xC6,
  0x18, 0x61, 0x86, 0x30, 0x63, 0x07, 0x60, 0x76, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0xC7, 0x0F, 0x1C, 0x6C, 0x51, 0xB1, 0x46, 0xCD, 0x33, 0x24, 0xCC,
  0x93, 0x36, 0x58, 0xD1, 0x63, 0x45, 0x8F, 0x14, 0x38, 0x70, 0xE1, 0xC3,
  0x86, 0x00, 0x1C, 0x0E, 0x18, 0x38, 0x38, 0xE0, 0x33, 0x80, 0x76, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x1D, 0xC0, 0x71, 0x81, 0xC3,
  0x87, 0x03, 0x1C, 0x07, 0x00, 0x70, 0x37, 0x03, 0x60, 0x36, 0x07, 0x60,
  0x76, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE1, 0xE7, 0xFE, 0x3C,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0x87, 0xF0, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0x80, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x7C, 0x03, 0xF8, 0x00, 0x70, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18,
  0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x38, 0xC0,
  0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x81, 0xFC, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x38, 0x3B, 0xF1, 0xBB, 0x8D, 0x8F, 0xEC,
  0x3E, 0x00, 0x40,
};

const GFXglyph JetBrainsMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 9, 8, 16, 5, -19 },
  { 25, 15, 19, 16, 1, -19 },
  { 61, 14, 27, 16, 1, -23 },
  { 109, 18, 19, 16, -1, -19 },
  { 152, 14, 19, 16, 1, -19 },
  { 186, 4, 8, 16, 7, -19 },
  { 190, 11, 25, 16, 4, -22 },
  { 225, 11, 25, 16, 1, -22 },
  { 260, 14, 14, 16, 1, -16 },
  { 285, 12, 13, 16, 2, -15 },
  { 305, 7, 8, 16, 2, -4 },
  { 312, 8, 2, 16, 4, -10 },
  { 314, 4, 4, 16, 5, -4 },
  { 316, 16, 25, 16, 0, -22 },
  { 366, 13, 19, 16, 2, -19 },
  { 397, 12, 19, 16, 1, -19 },
  { 426, 14, 19, 16, 1, -19 },
  { 460, 14, 19, 16, 1, -19 },
  { 494, 12, 19, 16, 2, -19 },
  { 523, 13, 19, 16, 2, -19 },
  { 554, 13, 19, 16, 1, -19 },
  { 585, 13, 19, 16, 3, -19 },
  { 616, 14, 19, 16, 1, -19 },
  { 650, 13, 19, 16, 2, -19 },
  { 681, 6, 15, 16, 5, -15 },
  { 693, 8, 19, 16, 3, -15 },
  { 712, 13, 13, 16, 2, -15 },
  { 734, 12, 9, 16, 2, -13 },
  { 748, 13, 13, 16, 1, -15 },
  { 770, 10, 19, 16, 4, -19 },
  { 794, 16, 24, 16, 0, -19 },
  { 842, 13, 19, 16, 0, -19 },
  { 873, 14, 19, 16, 1, -19 },
  { 907, 13, 19, 16, 2, -19 },
  { 938, 14, 19, 16, 1, -19 },
  { 972, 14, 19, 16, 1, -19 },
  { 1006, 15, 19, 16, 1, -19 },
  { 1042, 13, 19, 16, 2, -19 },
  { 1073, 14, 19, 16, 1, -19 },
  { 1107, 13, 19, 16, 2, -19 },
  { 1138, 15, 19, 16, 0, -19 },
  { 1174, 15, 19, 16, 1, -19 },
  { 1210, 11, 19, 16, 2, -19 },
  { 1237, 15, 19, 16, 1, -19 },
  { 1273, 14, 19, 16, 1, -19 },
  { 1307, 13, 19, 16, 2, -19 },
  { 1338, 15, 19, 16, 1, -19 },
  { 1374, 13, 24, 16, 2, -19 },
  { 1413, 14, 19, 16, 1, -19 },
  { 1447, 14, 19, 16, 1, -19 },
  { 1481, 13, 19, 16, 3, -19 },
  { 1512, 13, 19, 16, 2, -19 },
  { 1543, 13, 19, 16, 3, -19 },
  { 1574, 15, 19, 16, 2, -19 },
  { 1610, 16, 19, 16, 0, -19 },
  { 1648, 14, 19, 16, 3, -19 },
  { 1682, 14, 19, 16, 1, -19 },
  { 1716, 10, 25, 16, 4, -22 },
  { 1748, 8, 25, 16, 4, -22 },
  { 1773, 11, 25, 16, 2, -22 },
  { 1808, 12, 10, 16, 2, -19 },
  { 1823, 13, 2, 16, 0, 1 },
  { 1827, 5, 3, 16, 7, -20 },
  { 1829, 12, 15, 16, 2, -15 },
  { 1852, 13, 19, 16, 1, -19 },
  { 1883, 12, 15, 16, 2, -15 },
  { 1906, 13, 19, 16, 2, -19 },
  { 1937, 12, 15, 16, 2, -15 },
  { 1960, 18, 24, 16, -1, -19 },
  { 2014, 12, 20, 16, 2, -15 },
  { 2044, 13, 19, 16, 1, -19 },
  { 2075, 13, 20, 16, 1, -20 },
  { 2108, 14, 25, 16, 0, -20 },
  { 2152, 14, 19, 16, 1, -19 },
  { 2186, 11, 19, 16, 3, -19 },
  { 2213, 14, 15, 16, 1, -15 },
  { 2240, 13, 15, 16, 1, -15 },
  { 2265, 12, 15, 16, 2, -15 },
  { 2288, 14, 20, 16, 0, -15 },
  { 2323, 12, 20, 16, 2, -15 },
  { 2353, 13, 15, 16, 2, -15 },
  { 2378, 12, 15, 16, 2, -15 },
  { 2401, 13, 18, 16, 2, -18 },
  { 2431, 12, 14, 16, 2, -14 },
  { 2452, 12, 14, 16, 3, -14 },
  { 2473, 14, 14, 16, 2, -14 },
  { 2498, 15, 14, 16, 0, -14 },
  { 2525, 12, 19, 16, 2, -14 },
  { 2554, 13, 14, 16, 1, -14 },
  { 2577, 14, 25, 16, 2, -22 },
  { 2621, 6, 25, 16, 5, -22 },
  { 2640, 13, 25, 16, 1, -22 },
  { 2681, 13, 6, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_ITALIC26PT7B_H_
