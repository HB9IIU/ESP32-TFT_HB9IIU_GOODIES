#ifndef _JETBRAINSMONO_ITALIC50PT7B_H_
#define _JETBRAINSMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0xEF, 0xC0, 0x3E, 0x1C, 0x7C, 0x07, 0x87, 0x0F, 0x81, 0xF0, 0xE0,
  0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x83, 0x83, 0xC0, 0xF0, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x7C, 0x70, 0x00, 0x0F, 0xCE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xEF, 0xE0,
  0x00, 0x1C, 0x7C, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x1C,
  0x1F, 0x00, 0x03, 0x83, 0xE1, 0xE0, 0x70, 0x7C, 0x3C, 0x0E, 0x0F, 0x87,
  0x81, 0xC1, 0xE0, 0xF8, 0x38, 0x7C, 0x1F, 0x0E, 0x1F, 0x03, 0xF1, 0xC7,
  0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x78,
  0x07, 0xFF, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x03, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x07, 0x81, 0xC0, 0x3C, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x3C, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x1C, 0x00, 0x1E,
  0x07, 0x87, 0x80, 0x03, 0xC0, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x78, 0x00,
  0x0F, 0xDF, 0x9E, 0x00, 0x01, 0xFF, 0xE7, 0x80, 0x00, 0x1F, 0xF8, 0xE0,
  0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00,
  0x0F, 0x1F, 0xF0, 0x00, 0x01, 0xC7, 0xFF, 0x00, 0x00, 0x79, 0xFF, 0xE0,
  0x00, 0x1E, 0x3C, 0x3E, 0x00, 0x07, 0x8F, 0x03, 0xC0, 0x01, 0xE1, 0xE0,
  0x78, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x0E, 0x0F, 0x01, 0xC0, 0x03, 0xC1,
  0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xC0,
  0x1E, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x1F, 0x3E, 0x1F, 0x03, 0xE3, 0xE1,
  0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x83, 0xC0, 0xF8, 0xF0, 0x3C, 0x07, 0xDF,
  0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x78,
  0x01, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF8, 0x07, 0x80, 0x3F,
  0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0x1F, 0x03,
  0xFF, 0xC1, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x3E, 0x7C,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0x00, 0x7C, 0x01, 0x70, 0x1E, 0x03, 0x9F,
  0x83, 0x87, 0xFF, 0xF8, 0xC7, 0xFF, 0xFF, 0x33, 0xFF, 0x3F, 0xEF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x02, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0x1F, 0x9F, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C,
  0x3E, 0x0F, 0x0F, 0x0F, 0xC3, 0xC3, 0xC3, 0xF1, 0xF0, 0xF0, 0xFC, 0x7C,
  0x7C, 0x3E, 0x1E, 0x1F, 0x07, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xBE, 0x01, 0xFC, 0x7C, 0x03, 0xF0, 0xF0, 0x07, 0x81,
  0xE0, 0x0E, 0x03, 0xC0, 0x30, 0x0F, 0x80, 0x40, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x7E, 0x00, 0x7C, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x86, 0x00, 0x07, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x07, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x7E,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x01, 0xF8, 0xF0, 0xF0, 0x1F, 0xF3, 0x87, 0x80, 0xFF, 0xEE, 0x1E,
  0x03, 0xE1, 0xF8, 0x78, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x07, 0x87, 0x81,
  0xE0, 0x3E, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0xC0, 0xF0,
  0x0F, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x03,
  0xC3, 0xC1, 0xE0, 0x1E, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x1E, 0x01, 0xE1,
  0xE0, 0x7C, 0x0F, 0x87, 0x81, 0xF0, 0x7E, 0x1E, 0x03, 0xFF, 0x78, 0x78,
  0x0F, 0xFD, 0xE1, 0xE0, 0x0F, 0xC7, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x80, 0x3C, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x78,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0x81,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0xC7, 0xC1,
  0xFF, 0xC3, 0xC1, 0xFF, 0xE1, 0xE0, 0xFF, 0xF1, 0xF0, 0x7F, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x3C,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3C,
  0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xEE, 0x0F, 0x70,
  0x1E, 0xE0, 0xF7, 0x03, 0xDE, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0x83, 0x9C,
  0x0E, 0x78, 0x79, 0xC0, 0xE7, 0x87, 0x3C, 0x1E, 0x38, 0xF3, 0xC1, 0xE3,
  0x8E, 0x3C, 0x1E, 0x39, 0xE3, 0xC1, 0xE3, 0xDC, 0x78, 0x1E, 0x3F, 0xC7,
  0x81, 0xE3, 0xF8, 0x78, 0x1E, 0x1F, 0x87, 0x83, 0xE1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0xC0, 0x0F, 0x81, 0xFC, 0x01,
  0xF0, 0x7F, 0x80, 0x3C, 0x0F, 0xF0, 0x07, 0x81, 0xFE, 0x00, 0xF0, 0x3D,
  0xC0, 0x1E, 0x07, 0xBC, 0x07, 0xC0, 0xF7, 0x80, 0xF8, 0x3E, 0xF0, 0x1F,
  0x07, 0xDE, 0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7,
  0x81, 0xE0, 0x78, 0xF0, 0x7C, 0x0F, 0x1E, 0x0F, 0x83, 0xE3, 0xC1, 0xE0,
  0x7C, 0x3C, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x1E,
  0x3E, 0x07, 0x83, 0xC7, 0xC1, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0x9E, 0x07,
  0x80, 0xF3, 0xC0, 0xF0, 0x1E, 0x78, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x3D,
  0xE0, 0xF8, 0x07, 0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x1F, 0xE0, 0x78,
  0x03, 0xFC, 0x0F, 0x00, 0x3F, 0x81, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0xFE,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x81, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x17, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x79, 0xE0, 0x3E, 0x03,
  0xCF, 0x01, 0xF0, 0x1E, 0x78, 0x1F, 0x81, 0xF3, 0xC0, 0xFC, 0x0F, 0x1E,
  0x07, 0xE0, 0x78, 0xF0, 0x37, 0x03, 0xC7, 0x83, 0xB8, 0x3C, 0x7C, 0x1D,
  0xC1, 0xE3, 0xE0, 0xEE, 0x0F, 0x1E, 0x0E, 0x70, 0x78, 0xF0, 0x73, 0x87,
  0x87, 0x83, 0x9C, 0x3C, 0x3C, 0x18, 0xC1, 0xE1, 0xE1, 0xC6, 0x0E, 0x0F,
  0x0E, 0x30, 0xF0, 0x78, 0x71, 0x87, 0x83, 0xC7, 0x1C, 0x3C, 0x1E, 0x38,
  0xE3, 0xC0, 0xF1, 0xC7, 0x1E, 0x07, 0x8E, 0x38, 0xF0, 0x3C, 0xE1, 0xC7,
  0x81, 0xE7, 0x0E, 0x78, 0x0F, 0x38, 0x73, 0xC0, 0x7B, 0x83, 0x9E, 0x03,
  0xDC, 0x1C, 0xE0, 0x1E, 0xE0, 0xEF, 0x00, 0xF7, 0x07, 0x78, 0x07, 0x70,
  0x3B, 0xC0, 0x3B, 0x81, 0xDC, 0x01, 0xDC, 0x0F, 0xE0, 0x1E, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x78, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x00, 0x7F, 0x0F, 0x80, 0xFF,
  0xC7, 0x80, 0xFF, 0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0xFE, 0x0E, 0xF0, 0x7C,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0xDF,
  0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0x1E, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF8, 0x01, 0xE3, 0xFF,
  0x01, 0xF7, 0xFF, 0xC0, 0xFB, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3D, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7F, 0x01, 0xF8, 0x3D, 0xF7, 0xF8,
  0x1E, 0xFF, 0xFC, 0x0F, 0x3F, 0xF8, 0x0F, 0x8F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7E, 0x01,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC3,
  0xE0, 0x1F, 0xF8, 0xF0, 0x0F, 0xFF, 0x3C, 0x07, 0xFF, 0xEF, 0x03, 0xF8,
  0x3B, 0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x7E, 0x03, 0xF8, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xF3,
  0xE0, 0x0F, 0xF8, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0xFF, 0xE7, 0x80, 0xFF, 0xFB,
  0xC0, 0xFF, 0xFD, 0xE0, 0xFE, 0x0F, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x00,
  0xFC, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0,
  0xFF, 0xFD, 0xE0, 0x7F, 0xFD, 0xF0, 0x1F, 0xFC, 0xF8, 0x03, 0xFC, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC3, 0xF8, 0x01, 0xE7, 0xFF, 0x01, 0xF7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xF8, 0x3D, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07,
  0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0x1E, 0x0F, 0x81, 0xE7,
  0xE3, 0xF8, 0x3D, 0xFE, 0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x03, 0xC7, 0xC1, 0xE0, 0x78, 0xF8, 0x3C, 0x0F, 0x1E, 0x07,
  0x83, 0xE3, 0xC0, 0xF0, 0x78, 0x78, 0x1C, 0x0F, 0x0F, 0x03, 0x81, 0xE1,
  0xE0, 0xF0, 0x3C, 0x7C, 0x1E, 0x07, 0x8F, 0x03, 0xC1, 0xF1, 0xE0, 0x78,
  0x3C, 0x3C, 0x0E, 0x07, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x3E,
  0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0x1E, 0x07, 0x03,
  0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x1C, 0x0F, 0x1F, 0x07, 0x81, 0xE3, 0xE0,
  0xF0, 0x3C, 0x78, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0xF0, 0x03, 0xCF, 0xFE,
  0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF0, 0x7A, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0xF1, 0xFF, 0x80, 0x7D, 0xFF, 0xF0, 0x1F,
  0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0x81, 0xE8, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0xFE, 0x03, 0xF0, 0x3D, 0xF7, 0xF8, 0x0F, 0x7F,
  0xFE, 0x03, 0xCF, 0xFE, 0x01, 0xF1, 0xFF, 0x00, 0x7C, 0x04, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0xFF, 0xC7, 0x80, 0xFF, 0xF3, 0xC0,
  0xFF, 0xFD, 0xE0, 0xFC, 0x0F, 0xF0, 0x7C, 0x03, 0xF8, 0x7C, 0x00, 0xFC,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0,
  0x07, 0xE0, 0xFC, 0x06, 0xF0, 0x7F, 0xDF, 0xF8, 0x1F, 0xFF, 0x7C, 0x07,
  0xFF, 0x3C, 0x01, 0xFF, 0x1E, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x87,
  0xF0, 0x03, 0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xF7,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0,
  0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x1E, 0x01,
  0xFC, 0x07, 0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0xF8, 0x0E, 0xF0, 0x36,
  0x07, 0xBC, 0x1D, 0x81, 0xEF, 0x07, 0x60, 0x73, 0xC1, 0x98, 0x3C, 0xF0,
  0xE6, 0x0F, 0x3C, 0x39, 0x83, 0x8F, 0x0E, 0x60, 0xE3, 0xC7, 0x18, 0x78,
  0xF1, 0xC6, 0x1E, 0x3C, 0x71, 0x87, 0x0F, 0x38, 0x63, 0xC3, 0xCE, 0x18,
  0xF0, 0xE3, 0x86, 0x38, 0x39, 0xC1, 0x9E, 0x0E, 0x70, 0x67, 0x83, 0x9C,
  0x19, 0xC0, 0xE6, 0x06, 0xF0, 0x3B, 0x83, 0xBC, 0x0E, 0xE0, 0xEE, 0x03,
  0xB0, 0x3B, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01,
  0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFD, 0xE0, 0x3F, 0xFD, 0xF0, 0x0F, 0xFC, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x87, 0xF8, 0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x81,
  0xF7, 0xC7, 0xE0, 0xF3, 0xC1, 0xF0, 0x79, 0xE0, 0x7C, 0x7D, 0xF0, 0x3F,
  0xFC, 0xF8, 0x0F, 0xFC, 0x78, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph JetBrainsMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 12, 37, 30, 9, -37 },
  { 57, 17, 16, 30, 9, -37 },
  { 91, 29, 37, 30, 1, -37 },
  { 226, 27, 51, 30, 2, -44 },
  { 399, 35, 37, 30, -2, -37 },
  { 561, 28, 38, 30, 1, -37 },
  { 694, 7, 16, 30, 14, -37 },
  { 708, 21, 48, 30, 8, -42 },
  { 834, 20, 48, 30, 3, -42 },
  { 954, 26, 26, 30, 3, -31 },
  { 1039, 25, 23, 30, 3, -28 },
  { 1111, 13, 16, 30, 5, -8 },
  { 1137, 17, 5, 30, 7, -19 },
  { 1148, 9, 9, 30, 9, -8 },
  { 1159, 30, 48, 30, 1, -42 },
  { 1339, 26, 38, 30, 3, -37 },
  { 1463, 23, 37, 30, 2, -37 },
  { 1570, 26, 37, 30, 2, -37 },
  { 1691, 26, 38, 30, 2, -37 },
  { 1815, 24, 37, 30, 3, -37 },
  { 1926, 25, 38, 30, 3, -37 },
  { 2045, 25, 38, 30, 2, -37 },
  { 2164, 24, 37, 30, 6, -37 },
  { 2275, 25, 38, 30, 3, -37 },
  { 2394, 24, 37, 30, 5, -37 },
  { 2505, 12, 29, 30, 9, -28 },
  { 2549, 16, 36, 30, 5, -28 },
  { 2621, 24, 27, 30, 4, -30 },
  { 2702, 24, 17, 30, 3, -25 },
  { 2753, 24, 27, 30, 3, -30 },
  { 2834, 20, 37, 30, 7, -37 },
  { 2927, 30, 46, 30, 0, -37 },
  { 3100, 25, 37, 30, 0, -37 },
  { 3216, 26, 37, 30, 2, -37 },
  { 3337, 25, 38, 30, 3, -37 },
  { 3456, 26, 37, 30, 2, -37 },
  { 3577, 27, 37, 30, 3, -37 },
  { 3702, 27, 37, 30, 3, -37 },
  { 3827, 25, 38, 30, 3, -37 },
  { 3946, 27, 37, 30, 2, -37 },
  { 4071, 25, 37, 30, 3, -37 },
  { 4187, 27, 38, 30, 1, -37 },
  { 4316, 29, 37, 30, 2, -37 },
  { 4451, 21, 37, 30, 4, -37 },
  { 4549, 28, 37, 30, 2, -37 },
  { 4679, 27, 37, 30, 2, -37 },
  { 4804, 25, 38, 30, 3, -37 },
  { 4923, 28, 37, 30, 2, -37 },
  { 5053, 26, 46, 30, 3, -37 },
  { 5203, 27, 37, 30, 2, -37 },
  { 5328, 27, 38, 30, 2, -37 },
  { 5457, 25, 37, 30, 6, -37 },
  { 5573, 26, 38, 30, 3, -37 },
  { 5697, 25, 37, 30, 6, -37 },
  { 5813, 29, 37, 30, 3, -37 },
  { 5948, 31, 37, 30, 0, -37 },
  { 6092, 27, 37, 30, 5, -37 },
  { 6217, 27, 37, 30, 2, -37 },
  { 6342, 20, 48, 30, 7, -42 },
  { 6462, 15, 48, 30, 8, -42 },
  { 6552, 20, 48, 30, 4, -42 },
  { 6672, 23, 20, 30, 4, -37 },
  { 6730, 25, 4, 30, 0, 1 },
  { 6743, 9, 7, 30, 13, -39 },
  { 6751, 25, 29, 30, 3, -28 },
  { 6842, 25, 38, 30, 2, -37 },
  { 6961, 24, 29, 30, 3, -28 },
  { 7048, 26, 38, 30, 3, -37 },
  { 7172, 24, 29, 30, 3, -28 },
  { 7259, 34, 46, 30, -2, -37 },
  { 7455, 25, 37, 30, 3, -28 },
  { 7571, 25, 37, 30, 2, -37 },
  { 7687, 24, 39, 30, 2, -39 },
  { 7804, 26, 48, 30, 1, -39 },
  { 7960, 26, 37, 30, 3, -37 },
  { 8081, 21, 37, 30, 5, -37 },
  { 8179, 27, 28, 30, 1, -28 },
  { 8274, 25, 28, 30, 2, -28 },
  { 8362, 24, 29, 30, 3, -28 },
  { 8449, 26, 37, 30, 1, -28 },
  { 8570, 25, 37, 30, 3, -28 },
  { 8686, 25, 28, 30, 3, -28 },
  { 8774, 24, 29, 30, 3, -28 },
  { 8861, 24, 35, 30, 4, -35 },
  { 8966, 25, 29, 30, 3, -28 },
  { 9057, 24, 28, 30, 5, -28 },
  { 9141, 26, 28, 30, 4, -28 },
  { 9232, 28, 28, 30, 1, -28 },
  { 9330, 25, 37, 30, 3, -28 },
  { 9446, 25, 28, 30, 2, -28 },
  { 9534, 25, 48, 30, 5, -42 },
  { 9684, 12, 48, 30, 10, -42 },
  { 9756, 26, 48, 30, 1, -42 },
  { 9912, 25, 11, 30, 3, -23 },
};

const GFXfont JetBrainsMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_ITALIC50PT7B_H_
