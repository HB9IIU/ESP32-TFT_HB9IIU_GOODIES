#ifndef _JETBRAINSMONO_ITALIC42PT7B_H_
#define _JETBRAINSMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x78, 0x3D, 0xE0, 0xF7, 0x87, 0xDE, 0x1E, 0x78,
  0x79, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x38,
  0x3C, 0xE0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xF0, 0x0F, 0xBF, 0xE0, 0x78, 0xC7, 0x83, 0xC3, 0x0F, 0x0F, 0x0C, 0x3C,
  0x3C, 0x70, 0xF0, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x18, 0x00, 0x3C,
  0x60, 0x00, 0xFD, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x33, 0xE0, 0x00, 0xC7, 0x80,
  0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF3, 0xC1, 0x83, 0xCF, 0x06,
  0x1E, 0x3C, 0x18, 0x78, 0x78, 0xE3, 0xC1, 0xF3, 0xBF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x1F, 0xE0, 0x07, 0x81, 0xFF, 0x80, 0x38, 0x0E, 0x1C,
  0x03, 0x80, 0xE0, 0xF0, 0x38, 0x07, 0x07, 0x83, 0x80, 0x38, 0x38, 0x3C,
  0x01, 0xC1, 0xC3, 0xC0, 0x1E, 0x0E, 0x1C, 0x00, 0xE0, 0x71, 0xC0, 0x07,
  0x87, 0x1C, 0x00, 0x1F, 0xF9, 0xC0, 0x00, 0xFF, 0x9C, 0x00, 0x03, 0xF9,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0xF3, 0xFF, 0x00,
  0x07, 0x3C, 0x78, 0x00, 0x71, 0xC1, 0xC0, 0x07, 0x1C, 0x0E, 0x00, 0x70,
  0xE0, 0x70, 0x07, 0x07, 0x03, 0x80, 0x78, 0x38, 0x3C, 0x07, 0x81, 0xC1,
  0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0x7F, 0xE0, 0x38, 0x01, 0xFE, 0x03,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0x78, 0x1E, 0x78, 0xF0, 0x79, 0xE0, 0xF1, 0xE3, 0xC1,
  0xE3, 0xC7, 0x81, 0xEF, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xF0, 0x38, 0x07,
  0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x83, 0xC0, 0x7F, 0x03, 0xC1, 0xFF,
  0x07, 0xFF, 0xDF, 0x07, 0xFE, 0x1E, 0x07, 0xF8, 0x3E, 0x00, 0x7B, 0xDE,
  0xF7, 0xBF, 0xDE, 0xF7, 0xBD, 0xCE, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x02, 0x03, 0xC0, 0x5E, 0x0E, 0x0F, 0x7E, 0x38, 0xFF, 0xFE, 0xCF,
  0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x20, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x7E,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1F, 0x1C, 0x38, 0x7C, 0x70,
  0xE1, 0xE3, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7E, 0xF0, 0x1F, 0x9E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x18, 0x0F,
  0x02, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFC, 0xFE, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xC7, 0x80, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xC7,
  0xC0, 0x1C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFE, 0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x3E,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xBF, 0x00, 0xF7, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3E, 0x3E, 0x01, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x03, 0xC7, 0xE0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x7C, 0x3C, 0x01,
  0xF7, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7C, 0x3E,
  0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x71, 0xE0,
  0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0,
  0xFC, 0x1F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFC, 0xFE, 0x3E, 0x01, 0xE3,
  0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x03,
  0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0x78, 0x1F, 0xEF, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x07, 0xF1, 0xFC,
  0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x07, 0xF0, 0xFE, 0x1F,
  0x83, 0xE0, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x07,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x10, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0x80, 0x7E, 0x71, 0xC0, 0xFF, 0xB8, 0xE0, 0x78, 0xF8,
  0x70, 0x78, 0x3C, 0x78, 0x38, 0x0E, 0x3C, 0x1C, 0x07, 0x1E, 0x1E, 0x07,
  0x8E, 0x0F, 0x03, 0xC7, 0x07, 0x01, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0xC0,
  0x71, 0xE0, 0xE0, 0x38, 0xF0, 0xF0, 0x3C, 0x70, 0x78, 0x1E, 0x38, 0x1E,
  0x1F, 0x1C, 0x0F, 0xFF, 0x0E, 0x03, 0xFB, 0x87, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x77,
  0x80, 0x07, 0xBC, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x01,
  0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0xC0, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x3C, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x7C, 0x1C, 0x0F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0x01, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1C, 0x1F, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x01, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0xFC,
  0x78, 0x7F, 0xE3, 0xC3, 0xFF, 0x1E, 0x1F, 0xF8, 0xE0, 0x03, 0xC7, 0x00,
  0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83,
  0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x70, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xC1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xE0, 0x7C,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0E, 0x03,
  0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x38, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3F, 0x06, 0xE0, 0x7F, 0x06, 0xE0, 0x76, 0x0E, 0xE0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x0E, 0x71, 0xDE, 0x0E,
  0x73, 0x9C, 0x1E, 0x73, 0x9C, 0x1E, 0x77, 0x1C, 0x1E, 0x77, 0x3C, 0x1C,
  0x76, 0x3C, 0x1C, 0x3E, 0x3C, 0x1C, 0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x1C, 0x1F, 0x00, 0x70, 0xFC, 0x03, 0xC3, 0xF0,
  0x0F, 0x0F, 0xE0, 0x3C, 0x3B, 0x80, 0xF0, 0xEE, 0x03, 0x83, 0xB8, 0x0E,
  0x1E, 0xE0, 0x78, 0x7B, 0xC1, 0xE1, 0xEF, 0x07, 0x87, 0x9C, 0x1E, 0x1E,
  0x70, 0x78, 0x71, 0xC1, 0xC1, 0xC7, 0x87, 0x0F, 0x0E, 0x3C, 0x3C, 0x38,
  0xF0, 0xF0, 0xE3, 0xC3, 0xC3, 0x8F, 0x0E, 0x0F, 0x38, 0x38, 0x3C, 0xE1,
  0xE0, 0x77, 0x87, 0x81, 0xDE, 0x1E, 0x07, 0x78, 0x78, 0x1F, 0xE1, 0xC0,
  0x7F, 0x07, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0xC3, 0xC0, 0x3F,
  0x0F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xCF, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80,
  0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x7E, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFE, 0x07, 0x80, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1,
  0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x83,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0x7C, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0,
  0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x7C, 0x1C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0x7E, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x3C,
  0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x07,
  0x03, 0xC0, 0x38, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x78, 0x3E, 0x0F,
  0x70, 0x3E, 0x0F, 0x70, 0x3E, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x7C, 0x1E,
  0x70, 0x6C, 0x1C, 0x70, 0x6C, 0x1C, 0x70, 0xEC, 0x1C, 0x70, 0xEC, 0x3C,
  0x70, 0xCC, 0x38, 0x71, 0xCC, 0x38, 0x71, 0xCC, 0x78, 0xF1, 0x8C, 0x78,
  0xF1, 0x8C, 0x70, 0xF3, 0x8C, 0x70, 0xF3, 0x8C, 0xF0, 0xF3, 0x0C, 0xE0,
  0xF7, 0x1C, 0xE0, 0xF7, 0x1C, 0xE0, 0xE6, 0x1D, 0xE0, 0xE6, 0x1D, 0xC0,
  0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1F, 0x80, 0xEC, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xF8, 0x1B, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xEE,
  0x00, 0x73, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xC0,
  0xE0, 0x70, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x3D, 0xC0,
  0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x00, 0x20, 0x00, 0x3F, 0xCF, 0x07,
  0xFE, 0xF0, 0xFF, 0xEF, 0x1F, 0x03, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xFF,
  0xF8, 0x3F, 0xF7, 0x81, 0xFC, 0x78, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x80, 0x0E, 0x3F, 0xC0, 0xF7, 0xFF, 0x07, 0xBF, 0xF8, 0x3F,
  0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xEC, 0x1F, 0x0F, 0x7F, 0xF0, 0x7B, 0xFF,
  0x03, 0xCF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x0E,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x78, 0x7C, 0x1F, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x04,
  0x1E, 0x03, 0xFC, 0xF0, 0x3F, 0xF7, 0x83, 0xFF, 0xBC, 0x3E, 0x07, 0xE3,
  0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0x7F,
  0x1E, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBF, 0xFF, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x78,
  0x03, 0xC7, 0x80, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xCF, 0x07, 0xFE, 0xF0, 0xFF, 0xFF, 0x1F, 0x03, 0xF3, 0xE0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x1B, 0x87, 0xFF, 0xB8, 0x3F,
  0xF7, 0x81, 0xFE, 0x78, 0x02, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x80, 0x0E, 0x3F, 0xC0, 0xF7, 0xFF, 0x07, 0xBF, 0xF8, 0x3F, 0x03,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x1C, 0x00, 0xF0,
  0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07,
  0x81, 0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x20, 0x20, 0x3D, 0xF1, 0xF0, 0x7F, 0xF7, 0xF0, 0xF9, 0xF9, 0xE1, 0xE1,
  0xE1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x3C, 0x1C,
  0x1C, 0x78, 0x38, 0x78, 0xF0, 0xE0, 0xF1, 0xC1, 0xC1, 0xE3, 0x83, 0x83,
  0x87, 0x07, 0x07, 0x1E, 0x0E, 0x0E, 0x3C, 0x1C, 0x3C, 0x78, 0x70, 0x78,
  0xE0, 0xE0, 0xF1, 0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x8F, 0x07, 0x07, 0x1E,
  0x0E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x70, 0x78, 0x00, 0x04, 0x00, 0x71,
  0xFE, 0x07, 0xBF, 0xF8, 0x3D, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07,
  0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3E, 0x7C,
  0x03, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x7C, 0x07, 0xC7, 0xC1,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x1C,
  0x7F, 0x80, 0xF7, 0xFF, 0x03, 0xDF, 0xFC, 0x0F, 0xC0, 0xF8, 0x3E, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x0F, 0x80, 0xF8, 0x3B, 0x07, 0xC1, 0xEF, 0xFE, 0x07, 0xBF, 0xF0, 0x1E,
  0x7F, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xCF, 0x07, 0xFE, 0xF0, 0xFF, 0xEF, 0x1F, 0x03,
  0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0x78, 0x7F, 0xF7, 0x81, 0xFC, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0xF3,
  0xFC, 0x07, 0xBF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0x78,
  0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80,
  0x3C, 0x7C, 0x07, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0x80, 0x0E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF8, 0x0F, 0x87,
  0xC1, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0x83, 0x80, 0x78, 0x38, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0E, 0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01,
  0xE7, 0x80, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x78, 0x1F, 0xC0,
  0xF0, 0x3B, 0x81, 0xE0, 0x77, 0x07, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B,
  0x07, 0x38, 0x76, 0x1C, 0x70, 0xCC, 0x38, 0xE1, 0x98, 0x71, 0xC7, 0x31,
  0xC3, 0x8E, 0x63, 0x87, 0x18, 0xC7, 0x0E, 0x31, 0x9C, 0x1C, 0xE3, 0x38,
  0x39, 0x86, 0x70, 0x73, 0x0C, 0xC0, 0xEE, 0x1B, 0x81, 0xD8, 0x37, 0x03,
  0xB0, 0x6E, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xE0,
  0x00, 0x73, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x81, 0xE0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0xF8, 0x00, 0xF8,
  0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC1, 0xB8, 0x7F, 0xFF, 0x83,
  0xFF, 0x78, 0x1F, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x79, 0xFE, 0x03, 0x9F, 0xF8, 0x1C, 0xF3,
  0xE1, 0xEF, 0x0F, 0x8F, 0x78, 0x3F, 0xF3, 0x80, 0xFF, 0x9C, 0x03, 0xF0,
  0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 14, 13, 25, 8, -31 },
  { 63, 24, 31, 25, 1, -31 },
  { 156, 22, 43, 25, 2, -37 },
  { 275, 29, 31, 25, -1, -31 },
  { 388, 23, 31, 25, 1, -31 },
  { 478, 5, 13, 25, 12, -31 },
  { 487, 17, 40, 25, 7, -35 },
  { 572, 17, 40, 25, 2, -35 },
  { 657, 22, 22, 25, 2, -26 },
  { 718, 20, 20, 25, 3, -24 },
  { 768, 11, 13, 25, 4, -6 },
  { 786, 14, 4, 25, 6, -16 },
  { 793, 8, 7, 25, 7, -7 },
  { 800, 25, 40, 25, 1, -35 },
  { 925, 22, 31, 25, 2, -31 },
  { 1011, 19, 31, 25, 2, -31 },
  { 1085, 22, 31, 25, 2, -31 },
  { 1171, 21, 31, 25, 2, -31 },
  { 1253, 20, 31, 25, 3, -31 },
  { 1331, 21, 31, 25, 3, -31 },
  { 1413, 20, 31, 25, 2, -31 },
  { 1491, 21, 31, 25, 5, -31 },
  { 1573, 21, 31, 25, 2, -31 },
  { 1655, 20, 31, 25, 4, -31 },
  { 1733, 11, 24, 25, 7, -24 },
  { 1766, 14, 31, 25, 4, -24 },
  { 1821, 20, 22, 25, 4, -25 },
  { 1876, 20, 14, 25, 3, -21 },
  { 1911, 20, 22, 25, 2, -25 },
  { 1966, 17, 31, 25, 6, -31 },
  { 2032, 25, 39, 25, 0, -31 },
  { 2154, 21, 31, 25, 0, -31 },
  { 2236, 22, 31, 25, 2, -31 },
  { 2322, 21, 31, 25, 3, -31 },
  { 2404, 22, 31, 25, 2, -31 },
  { 2490, 23, 31, 25, 2, -31 },
  { 2580, 23, 31, 25, 2, -31 },
  { 2670, 21, 31, 25, 3, -31 },
  { 2752, 22, 31, 25, 2, -31 },
  { 2838, 21, 31, 25, 3, -31 },
  { 2920, 23, 31, 25, 1, -31 },
  { 3010, 24, 31, 25, 2, -31 },
  { 3103, 18, 31, 25, 3, -31 },
  { 3173, 24, 31, 25, 1, -31 },
  { 3266, 22, 31, 25, 2, -31 },
  { 3352, 21, 31, 25, 3, -31 },
  { 3434, 23, 31, 25, 2, -31 },
  { 3524, 22, 39, 25, 2, -31 },
  { 3632, 22, 31, 25, 2, -31 },
  { 3718, 22, 31, 25, 2, -31 },
  { 3804, 21, 31, 25, 5, -31 },
  { 3886, 21, 31, 25, 3, -31 },
  { 3968, 21, 31, 25, 5, -31 },
  { 4050, 24, 31, 25, 3, -31 },
  { 4143, 26, 31, 25, 0, -31 },
  { 4244, 23, 31, 25, 4, -31 },
  { 4334, 22, 31, 25, 2, -31 },
  { 4420, 17, 40, 25, 6, -35 },
  { 4505, 12, 40, 25, 7, -35 },
  { 4565, 16, 40, 25, 4, -35 },
  { 4645, 18, 17, 25, 4, -31 },
  { 4684, 21, 3, 25, 0, 1 },
  { 4692, 8, 6, 25, 11, -33 },
  { 4698, 20, 24, 25, 3, -24 },
  { 4758, 21, 31, 25, 2, -31 },
  { 4840, 20, 24, 25, 3, -24 },
  { 4900, 21, 31, 25, 3, -31 },
  { 4982, 19, 24, 25, 3, -24 },
  { 5039, 29, 39, 25, -2, -31 },
  { 5181, 20, 32, 25, 3, -24 },
  { 5261, 21, 31, 25, 2, -31 },
  { 5343, 20, 33, 25, 2, -33 },
  { 5426, 22, 41, 25, 0, -33 },
  { 5539, 23, 31, 25, 2, -31 },
  { 5629, 18, 31, 25, 4, -31 },
  { 5699, 23, 24, 25, 1, -24 },
  { 5768, 21, 24, 25, 2, -24 },
  { 5831, 19, 24, 25, 3, -24 },
  { 5888, 22, 32, 25, 1, -24 },
  { 5976, 20, 32, 25, 3, -24 },
  { 6056, 21, 24, 25, 3, -24 },
  { 6119, 20, 24, 25, 2, -24 },
  { 6179, 20, 29, 25, 4, -29 },
  { 6252, 20, 23, 25, 3, -23 },
  { 6310, 20, 23, 25, 4, -23 },
  { 6368, 23, 23, 25, 3, -23 },
  { 6435, 24, 23, 25, 0, -23 },
  { 6504, 20, 31, 25, 3, -23 },
  { 6582, 21, 23, 25, 2, -23 },
  { 6643, 21, 40, 25, 4, -35 },
  { 6748, 10, 40, 25, 8, -35 },
  { 6798, 21, 40, 25, 1, -35 },
  { 6903, 21, 9, 25, 3, -19 },
};

const GFXfont JetBrainsMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_ITALIC42PT7B_H_
