#ifndef _JETBRAINSMONO_ITALIC70PT7B_H_
#define _JETBRAINSMONO_ITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xF3, 0xFC, 0x00, 0x7F,
  0x0F, 0x0F, 0xF0, 0x07, 0xF0, 0x78, 0x3F, 0x80, 0x3F, 0x03, 0xC0, 0xFC,
  0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0x81, 0xF8, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0x7F, 0x03, 0xC0, 0x00, 0x03,
  0xF8, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0x80,
  0x00, 0x07, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0xFF,
  0x1E, 0x00, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x7F,
  0xE0, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x00,
  0x3C, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x01, 0xF8,
  0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x01, 0xFC, 0x1F,
  0x80, 0x78, 0x0F, 0xC0, 0xFE, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x07,
  0xE0, 0x3F, 0xC1, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0x0F, 0xF0, 0x07, 0xFE,
  0x79, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x0F,
  0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x83, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x7E,
  0x03, 0xF0, 0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x00,
  0x1F, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x1F,
  0xF7, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00,
  0x3F, 0x00, 0x0C, 0x78, 0x01, 0xF8, 0x03, 0xE7, 0xF8, 0x0F, 0x80, 0x7F,
  0x3F, 0xF0, 0x7C, 0x1F, 0xFB, 0xFF, 0xE3, 0xC3, 0xFF, 0xDF, 0xFF, 0x8E,
  0x7F, 0xFF, 0x7F, 0xFE, 0x77, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x83, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0x83, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0xC1, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0x83, 0xF0, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0x40, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x9F, 0x80, 0x01, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0x07, 0xE0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x3F, 0x00,
  0x08, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x20, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xC0,
  0x00, 0x1F, 0x87, 0xFF, 0x80, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x7E, 0xFF,
  0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFD, 0xF8, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xFE,
  0x7F, 0x00, 0x00, 0x58, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE0, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0xF8, 0x1F, 0x80, 0x07, 0xFE, 0x3E, 0x07, 0xE0, 0x07, 0xFF, 0xCF, 0x81,
  0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0x7C, 0x00, 0xFF, 0xBE, 0xF8, 0x1F, 0x00,
  0x7F, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00,
  0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x03, 0xFE, 0x3F, 0xE0,
  0x7E, 0x00, 0x7F, 0xFE, 0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xBE, 0x07, 0xE0,
  0x03, 0xFF, 0x8F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0x80,
  0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x03, 0xFF, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xDE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xBC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0xFC, 0xF8,
  0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x03, 0xE3,
  0xE1, 0xF1, 0xF8, 0x07, 0xE1, 0xE1, 0xF1, 0xF8, 0x07, 0xE1, 0xF3, 0xE1,
  0xF8, 0x07, 0xE1, 0xF3, 0xE1, 0xF0, 0x07, 0xE1, 0xF7, 0xC1, 0xF0, 0x07,
  0xE1, 0xF7, 0xC3, 0xF0, 0x07, 0xC1, 0xF7, 0x83, 0xF0, 0x0F, 0xC0, 0xFF,
  0x83, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0,
  0x00, 0xFE, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0x07, 0xDF, 0x80, 0x0F, 0xC0,
  0x1F, 0x7E, 0x00, 0x3F, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x03, 0xF3, 0xE0,
  0x03, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07,
  0xE1, 0xF8, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0x80,
  0xFC, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xFC,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x3E, 0x3F,
  0x80, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0xFC,
  0x03, 0xF0, 0x01, 0xF3, 0xF0, 0x0F, 0xC0, 0x07, 0xEF, 0x80, 0x3F, 0x00,
  0x1F, 0xBE, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x7E, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x00,
  0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x00, 0x7E, 0x7E,
  0x00, 0xFF, 0x00, 0x7C, 0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xEF,
  0x00, 0xFC, 0x7E, 0x01, 0xEF, 0x00, 0xFC, 0x7E, 0x01, 0xEF, 0x00, 0xF8,
  0x7E, 0x03, 0xEF, 0x01, 0xF8, 0x7E, 0x03, 0xCF, 0x01, 0xF8, 0x7E, 0x03,
  0xCF, 0x01, 0xF8, 0x7E, 0x03, 0xCF, 0x01, 0xF0, 0x7E, 0x07, 0x8F, 0x03,
  0xF0, 0x7E, 0x07, 0x8F, 0x03, 0xF0, 0x7E, 0x07, 0x8F, 0x03, 0xE0, 0x7E,
  0x07, 0x8F, 0x03, 0xE0, 0x7E, 0x0F, 0x0F, 0x07, 0xE0, 0x7E, 0x0F, 0x0F,
  0x07, 0xE0, 0x7C, 0x0F, 0x0F, 0x07, 0xC0, 0x7C, 0x1E, 0x0E, 0x07, 0xC0,
  0x7C, 0x1E, 0x1E, 0x0F, 0xC0, 0x7C, 0x1E, 0x1E, 0x0F, 0x80, 0x7C, 0x1E,
  0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x1E, 0x1F, 0x80, 0x7C, 0x3C, 0x1E, 0x1F,
  0x80, 0x7C, 0x3C, 0x1E, 0x1F, 0x00, 0xFC, 0x78, 0x1E, 0x1F, 0x00, 0xFC,
  0x78, 0x1E, 0x3F, 0x00, 0xFC, 0x78, 0x1E, 0x3F, 0x00, 0xFC, 0x78, 0x1E,
  0x3E, 0x00, 0xFC, 0xF0, 0x1E, 0x3E, 0x00, 0xFC, 0xF0, 0x1E, 0x7E, 0x00,
  0xFC, 0xF0, 0x1E, 0x7C, 0x00, 0xFD, 0xF0, 0x1E, 0x7C, 0x00, 0xFD, 0xE0,
  0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0x1E, 0xFC, 0x00, 0xF9, 0xE0, 0x1E, 0xF8,
  0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0xFB,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1D,
  0xF0, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xE1,
  0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF,
  0xFE, 0xFC, 0x03, 0xFF, 0x0F, 0xDF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF7,
  0xE0, 0x0F, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x0F, 0xFF,
  0xC7, 0xF0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xF8,
  0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xF8, 0x03, 0xF7, 0xFF,
  0xFF, 0x80, 0x7E, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xF6,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xBF, 0xFF, 0xFC,
  0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF,
  0xF0, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0x87,
  0xF0, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF,
  0xFF, 0xEF, 0xC0, 0x0F, 0xFC, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xFF,
  0x3F, 0x00, 0x0F, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x87, 0xE0, 0x07, 0xFF,
  0xF9, 0xF8, 0x07, 0xFF, 0xFE, 0x7E, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0xFF,
  0xC3, 0xF7, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xDF,
  0x80, 0xFF, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFC,
  0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x10,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x81, 0xFF, 0x00, 0x07, 0xF1, 0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFF, 0x80,
  0x1F, 0x9F, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0x80, 0x7E, 0xF8, 0x3F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x1F, 0x9F, 0xF0, 0xFF, 0x80, 0x7E, 0xFF,
  0xE7, 0xFF, 0x01, 0xFB, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0x1F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0x80,
  0x3F, 0x7F, 0xFF, 0xF8, 0x07, 0xEF, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x00, 0x3F,
  0x1F, 0xFF, 0xE0, 0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xFE,
  0x00, 0x7E, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0xFD, 0xE0,
  0x1F, 0xF0, 0x07, 0xEF, 0xFF, 0xFF, 0x00, 0x3F, 0x3F, 0xFF, 0xF0, 0x01,
  0xF9, 0xFF, 0xFF, 0x00, 0x0F, 0xC7, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xE1, 0xF8, 0x01,
  0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFC, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF7, 0xE0, 0x0F,
  0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xC7, 0xF0,
  0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x7F,
  0x3F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFF, 0x01,
  0xFB, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xEF, 0xC0,
  0x1F, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x01,
  0xF3, 0xF0, 0x0F, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFF, 0x00, 0xF8, 0xFC, 0x07, 0xBC, 0x03, 0xE3, 0xF0, 0x1E, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7B, 0xC0, 0x7C, 0x3F, 0x03, 0xCF, 0x01, 0xF0, 0xFC, 0x0F,
  0x3C, 0x07, 0xC3, 0xF0, 0x3C, 0xF0, 0x3E, 0x0F, 0xC1, 0xE3, 0xC0, 0xF8,
  0x3F, 0x07, 0x8F, 0x03, 0xE0, 0xFC, 0x1E, 0x3C, 0x1F, 0x03, 0xF0, 0xF0,
  0xF0, 0x7C, 0x0F, 0xC3, 0xC3, 0xC1, 0xF0, 0x3F, 0x0F, 0x0F, 0x0F, 0x80,
  0xFC, 0x78, 0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0xF0, 0xF8, 0x0F, 0x87, 0x83,
  0xC3, 0xC0, 0x1E, 0x1C, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x3C, 0x7C, 0x01,
  0xE3, 0xC0, 0xF1, 0xE0, 0x07, 0x8E, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x0F,
  0x3E, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x07,
  0xBC, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x07, 0xDF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF,
  0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x07,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0xF0, 0x00, 0xFC, 0x1F, 0xFF, 0x00,
  0x1F, 0x87, 0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xFF, 0x00, 0x7E, 0x7F, 0xBF,
  0xE0, 0x0F, 0xCF, 0xC1, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E,
  0x01, 0xFE, 0x1F, 0xCF, 0xC0, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xFC,
  0x3F, 0x00, 0x3F, 0xFF, 0x87, 0xE0, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph JetBrainsMono_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 17, 51, 42, 13, -51 },
  { 110, 24, 21, 42, 13, -51 },
  { 173, 40, 51, 42, 2, -51 },
  { 428, 37, 71, 42, 3, -61 },
  { 757, 48, 51, 42, -2, -51 },
  { 1063, 38, 53, 42, 2, -52 },
  { 1315, 9, 21, 42, 20, -51 },
  { 1339, 29, 68, 42, 11, -59 },
  { 1586, 28, 68, 42, 4, -59 },
  { 1824, 37, 36, 42, 4, -43 },
  { 1991, 34, 33, 42, 5, -40 },
  { 2132, 18, 22, 42, 7, -11 },
  { 2182, 23, 6, 42, 10, -26 },
  { 2200, 13, 12, 42, 12, -11 },
  { 2220, 42, 66, 42, 1, -58 },
  { 2567, 36, 53, 42, 4, -52 },
  { 2806, 33, 51, 42, 3, -51 },
  { 3017, 36, 52, 42, 3, -52 },
  { 3251, 36, 52, 42, 3, -51 },
  { 3485, 34, 51, 42, 4, -51 },
  { 3702, 35, 52, 42, 4, -51 },
  { 3930, 34, 52, 42, 3, -51 },
  { 4151, 33, 51, 42, 9, -51 },
  { 4362, 35, 53, 42, 4, -52 },
  { 4594, 34, 52, 42, 7, -52 },
  { 4815, 17, 40, 42, 12, -39 },
  { 4900, 23, 50, 42, 7, -39 },
  { 5044, 34, 37, 42, 6, -42 },
  { 5202, 33, 22, 42, 5, -34 },
  { 5293, 33, 37, 42, 4, -42 },
  { 5446, 28, 51, 42, 10, -51 },
  { 5625, 42, 65, 42, 0, -52 },
  { 5967, 35, 51, 42, 0, -51 },
  { 6191, 37, 51, 42, 3, -51 },
  { 6427, 35, 53, 42, 5, -52 },
  { 6659, 36, 51, 42, 3, -51 },
  { 6889, 37, 51, 42, 4, -51 },
  { 7125, 38, 51, 42, 4, -51 },
  { 7368, 35, 53, 42, 5, -52 },
  { 7600, 38, 51, 42, 3, -51 },
  { 7843, 36, 51, 42, 4, -51 },
  { 8073, 39, 52, 42, 1, -51 },
  { 8327, 41, 51, 42, 3, -51 },
  { 8589, 30, 51, 42, 5, -51 },
  { 8781, 40, 51, 42, 2, -51 },
  { 9036, 38, 51, 42, 3, -51 },
  { 9279, 34, 53, 42, 5, -52 },
  { 9505, 39, 51, 42, 3, -51 },
  { 9754, 36, 65, 42, 4, -52 },
  { 10047, 38, 51, 42, 3, -51 },
  { 10290, 37, 53, 42, 3, -52 },
  { 10536, 35, 51, 42, 8, -51 },
  { 10760, 37, 52, 42, 4, -51 },
  { 11001, 35, 51, 42, 9, -51 },
  { 11225, 40, 51, 42, 5, -51 },
  { 11480, 43, 51, 42, 0, -51 },
  { 11755, 38, 51, 42, 7, -51 },
  { 11998, 37, 51, 42, 3, -51 },
  { 12234, 28, 66, 42, 10, -58 },
  { 12465, 21, 66, 42, 11, -58 },
  { 12639, 28, 66, 42, 6, -58 },
  { 12870, 31, 27, 42, 6, -51 },
  { 12975, 34, 5, 42, 0, 2 },
  { 12997, 12, 10, 42, 19, -55 },
  { 13012, 35, 40, 42, 4, -39 },
  { 13187, 35, 52, 42, 3, -51 },
  { 13415, 33, 40, 42, 5, -39 },
  { 13580, 37, 52, 42, 4, -51 },
  { 13821, 32, 40, 42, 5, -39 },
  { 13981, 48, 64, 42, -3, -51 },
  { 14365, 34, 52, 42, 5, -39 },
  { 14586, 35, 51, 42, 3, -51 },
  { 14810, 33, 54, 42, 3, -54 },
  { 15033, 36, 67, 42, 1, -54 },
  { 15335, 37, 51, 42, 4, -51 },
  { 15571, 29, 51, 42, 7, -51 },
  { 15756, 38, 39, 42, 2, -39 },
  { 15942, 35, 39, 42, 3, -39 },
  { 16113, 32, 40, 42, 5, -39 },
  { 16273, 37, 52, 42, 1, -39 },
  { 16514, 35, 52, 42, 4, -39 },
  { 16742, 34, 39, 42, 5, -39 },
  { 16908, 33, 40, 42, 4, -39 },
  { 17073, 33, 49, 42, 6, -49 },
  { 17276, 35, 40, 42, 4, -39 },
  { 17451, 34, 39, 42, 7, -39 },
  { 17617, 38, 39, 42, 5, -39 },
  { 17803, 39, 39, 42, 1, -39 },
  { 17994, 34, 52, 42, 5, -39 },
  { 18215, 35, 39, 42, 3, -39 },
  { 18386, 36, 66, 42, 6, -58 },
  { 18683, 16, 66, 42, 14, -58 },
  { 18815, 35, 66, 42, 2, -58 },
  { 19104, 35, 15, 42, 4, -32 },
};

const GFXfont JetBrainsMono_Italic70pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic70pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _JETBRAINSMONO_ITALIC70PT7B_H_
