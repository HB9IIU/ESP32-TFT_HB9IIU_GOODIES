#ifndef _JETBRAINSMONO_ITALIC17PT7B_H_
#define _JETBRAINSMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x22, 0x26, 0x00, 0xEE, 0x4F, 0x3C, 0xB2, 0x88, 0x04,
  0xC2, 0x20, 0x88, 0xFF, 0x11, 0x04, 0x41, 0x31, 0xFE, 0xFF, 0x89, 0x84,
  0x41, 0x10, 0x04, 0x02, 0x01, 0x07, 0xE2, 0x5B, 0x4D, 0xA0, 0xF0, 0x3C,
  0x07, 0x02, 0xC3, 0x6D, 0x36, 0xB1, 0xF0, 0x20, 0x10, 0x00, 0x08, 0x01,
  0xE3, 0x22, 0x62, 0x2C, 0x26, 0x83, 0xD0, 0x02, 0x00, 0x4C, 0x0F, 0xE1,
  0xA6, 0x12, 0x62, 0x24, 0xC3, 0xC0, 0x06, 0x07, 0xC1, 0x18, 0xC0, 0x10,
  0x06, 0x03, 0x81, 0xB3, 0x45, 0x91, 0xC4, 0x21, 0x1C, 0x79, 0x80, 0xFE,
  0x80, 0x06, 0x30, 0xC1, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x0C, 0x1C, 0x08, 0x30, 0x30, 0x30, 0x20, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0x30, 0x41, 0x86, 0x18, 0x60, 0x0C, 0x04, 0x32, 0x7F, 0xF0, 0x81, 0xE1,
  0x91, 0x8C, 0x0C, 0x08, 0x08, 0x08, 0xFF, 0x18, 0x18, 0x10, 0x36, 0x64,
  0xC8, 0xFC, 0x5F, 0x80, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x0C, 0x1F, 0x88, 0x4C, 0x34, 0x12, 0x09, 0x65, 0x96, 0xC3, 0x61, 0xB0,
  0x98, 0xC7, 0xC0, 0x1E, 0x34, 0x44, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0xFF, 0x0C, 0x1F, 0x98, 0x4C, 0x20, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0F, 0xE0, 0x3F, 0x81, 0x81, 0x81, 0x01, 0xC0,
  0xF0, 0x0C, 0x06, 0x02, 0x61, 0x31, 0x8F, 0x80, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x23, 0x43, 0xC2, 0xFE, 0x02, 0x06, 0x06, 0x3F, 0x90, 0x08, 0x0C,
  0x07, 0xE3, 0x18, 0x0C, 0x06, 0x03, 0x61, 0x31, 0x8F, 0x80, 0x06, 0x0C,
  0x18, 0x10, 0x2C, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7C, 0xFF, 0xC3,
  0xC2, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x1F,
  0x88, 0x4C, 0x26, 0x31, 0xB0, 0x70, 0x6C, 0x43, 0x61, 0xB0, 0x98, 0xC7,
  0xC0, 0x18, 0x7E, 0xC3, 0xC3, 0x83, 0x82, 0xC6, 0xFC, 0x0C, 0x18, 0x30,
  0x20, 0xE0, 0x27, 0x70, 0x00, 0x00, 0xEE, 0x11, 0xCE, 0x00, 0x00, 0x06,
  0x73, 0x11, 0x88, 0x00, 0x01, 0x83, 0x87, 0x0E, 0x04, 0x07, 0x80, 0x70,
  0x0C, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x40, 0x70, 0x1C, 0x07,
  0x03, 0x0E, 0x38, 0xE0, 0x80, 0x7C, 0x0C, 0x18, 0x30, 0x67, 0x8C, 0x10,
  0x60, 0x01, 0x87, 0x00, 0x03, 0x07, 0xE3, 0x0C, 0x81, 0x60, 0x59, 0xD4,
  0xCD, 0x33, 0x48, 0x92, 0x2C, 0x8B, 0x3E, 0xC0, 0x30, 0x06, 0x00, 0xF0,
  0x06, 0x07, 0x83, 0xC1, 0x61, 0xB0, 0x88, 0xC4, 0x7E, 0x3F, 0x30, 0x90,
  0x58, 0x30, 0x3F, 0x10, 0x98, 0x4C, 0x26, 0x33, 0xE1, 0x0C, 0x86, 0xC3,
  0x61, 0xB1, 0x9F, 0x80, 0x0C, 0x1F, 0x88, 0x4C, 0x36, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0xB0, 0x98, 0xC7, 0xC0, 0x3F, 0x31, 0x98, 0x4C, 0x26,
  0x12, 0x19, 0x0C, 0x86, 0xC3, 0x61, 0x33, 0x9F, 0x00, 0x3F, 0x90, 0x18,
  0x0C, 0x06, 0x03, 0xF9, 0x00, 0x80, 0x40, 0x60, 0x30, 0x1F, 0xC0, 0x3F,
  0x90, 0x18, 0x0C, 0x06, 0x03, 0xF9, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x00, 0x0C, 0x1F, 0x88, 0x4C, 0x36, 0x02, 0x01, 0x00, 0x9E, 0xC3, 0x61,
  0xB0, 0x98, 0xC7, 0xC0, 0x21, 0x90, 0xD8, 0x4C, 0x26, 0x13, 0xF9, 0x0C,
  0x86, 0xC2, 0x61, 0x30, 0x90, 0xC0, 0x3F, 0x86, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x1F, 0xC0, 0x07, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x41, 0x10, 0xC6, 0x60, 0xF0, 0x21,
  0xD8, 0x46, 0x31, 0x98, 0x64, 0x1F, 0x04, 0xC1, 0x10, 0xC6, 0x31, 0x8C,
  0x22, 0x0C, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40,
  0xC1, 0xFE, 0x71, 0xA9, 0x54, 0xEA, 0xF5, 0x52, 0xEB, 0x65, 0x86, 0xC3,
  0x41, 0xA0, 0x90, 0x40, 0x31, 0xB8, 0xDC, 0x4F, 0x25, 0x92, 0x59, 0x2D,
  0x96, 0xCE, 0x67, 0x31, 0x90, 0xC0, 0x0C, 0x1F, 0x88, 0x4C, 0x26, 0x12,
  0x09, 0x0C, 0x86, 0xC3, 0x61, 0xB0, 0x98, 0xC7, 0xC0, 0x3F, 0x30, 0xD8,
  0x6C, 0x36, 0x1A, 0x39, 0xF8, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x0C,
  0x1F, 0x88, 0x4C, 0x34, 0x12, 0x09, 0x05, 0x86, 0xC3, 0x61, 0xB0, 0x98,
  0xC7, 0xC0, 0x60, 0x30, 0x0C, 0x3F, 0x30, 0xD8, 0x6C, 0x36, 0x13, 0xF9,
  0xF0, 0x98, 0xC4, 0x63, 0x31, 0x90, 0x60, 0x0C, 0x1F, 0x88, 0x6C, 0x36,
  0x03, 0x80, 0xF0, 0x0C, 0x03, 0x01, 0xB0, 0xD8, 0xC7, 0xC0, 0xFF, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x21, 0xB0,
  0xD8, 0x4C, 0x26, 0x12, 0x19, 0x0C, 0x86, 0xC2, 0x61, 0x31, 0x8F, 0x80,
  0xC1, 0xE1, 0xB0, 0x98, 0xC4, 0x62, 0x21, 0x30, 0x90, 0x58, 0x38, 0x1C,
  0x0E, 0x00, 0x4C, 0xD3, 0x24, 0xCB, 0x52, 0xD5, 0xB5, 0x4D, 0x53, 0x94,
  0xE7, 0x39, 0x8C, 0x63, 0x18, 0x30, 0xE2, 0x30, 0x64, 0x05, 0x80, 0xE0,
  0x18, 0x03, 0x80, 0xF0, 0x32, 0x04, 0x61, 0x84, 0x60, 0xC0, 0xC1, 0xE1,
  0x91, 0x8C, 0x86, 0xC1, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x00,
  0x3F, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30,
  0x1F, 0xC0, 0x1E, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x10, 0x7C, 0x86, 0x30, 0x84, 0x31, 0x8C, 0x21, 0x0C, 0x61,
  0x08, 0x63, 0x3C, 0x30, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x61, 0x84, 0x10,
  0x43, 0x3C, 0x18, 0x78, 0x93, 0x24, 0x70, 0xC0, 0xFF, 0xFF, 0xE3, 0x08,
  0x3D, 0x63, 0x43, 0x43, 0xC3, 0xC2, 0xC2, 0xC6, 0x7E, 0x20, 0x60, 0x64,
  0x7F, 0x63, 0x43, 0x43, 0x43, 0xC3, 0xC2, 0xC6, 0xBC, 0x08, 0x3F, 0x63,
  0x41, 0x40, 0xC0, 0xC0, 0xC3, 0xC6, 0x7C, 0x01, 0x80, 0xC2, 0x47, 0xA6,
  0x32, 0x19, 0x0D, 0x86, 0xC2, 0x61, 0x31, 0x8F, 0xC0, 0x08, 0x3E, 0x63,
  0x43, 0x43, 0xFF, 0xC0, 0xC0, 0xC6, 0x7C, 0x03, 0xF0, 0x20, 0x06, 0x00,
  0x60, 0x3F, 0xE0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0xF0, 0x00, 0x08, 0x3D, 0x63, 0x43, 0x43, 0xC3,
  0xC2, 0xC6, 0x7A, 0x06, 0x06, 0x04, 0x7C, 0x20, 0x60, 0x64, 0x7F, 0x63,
  0x43, 0x43, 0x43, 0xC2, 0xC2, 0xC2, 0x86, 0x0E, 0x0C, 0x00, 0x00, 0x7C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x81, 0xC0, 0x00,
  0x03, 0xF0, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x31, 0xF0, 0x20, 0x10, 0x18, 0x2C, 0x66, 0x22, 0x31, 0x30, 0xF0, 0xCC,
  0x62, 0x31, 0x90, 0x60, 0xF0, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x81, 0xF0, 0x09, 0x0F, 0xE2, 0x4D, 0x92, 0x64, 0x9B, 0x24, 0xD9,
  0x26, 0x49, 0xB2, 0x40, 0x04, 0x7F, 0x63, 0x43, 0x43, 0x43, 0xC2, 0xC2,
  0xC2, 0x86, 0x08, 0x3E, 0x63, 0x43, 0x43, 0xC3, 0xC3, 0xC2, 0xC6, 0x7C,
  0x02, 0x1F, 0xCC, 0x64, 0x32, 0x19, 0x0D, 0x86, 0xC2, 0x63, 0x2F, 0x10,
  0x08, 0x0C, 0x00, 0x08, 0x3D, 0x63, 0x43, 0x43, 0xC3, 0xC2, 0xC2, 0xC6,
  0x7E, 0x06, 0x06, 0x04, 0x04, 0x3F, 0x98, 0x4C, 0x26, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x00, 0x0C, 0x3F, 0x63, 0x60, 0x70, 0x3E, 0x02, 0x02,
  0xC6, 0x7C, 0x08, 0x0C, 0x06, 0x3F, 0xE1, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x03, 0xC0, 0x61, 0x61, 0x43, 0x43, 0x43, 0xC2, 0xC2, 0xC6,
  0x7C, 0x83, 0xC6, 0xC6, 0xC4, 0x4C, 0x48, 0x58, 0x50, 0x70, 0xCC, 0xEA,
  0xF5, 0x5A, 0xAE, 0x57, 0x33, 0x99, 0x4C, 0xC4, 0x00, 0x31, 0xC4, 0x41,
  0xA0, 0x38, 0x0C, 0x07, 0x83, 0x21, 0x8C, 0xC1, 0x80, 0x61, 0x61, 0x43,
  0x43, 0x43, 0xC2, 0xC6, 0x7A, 0x06, 0x06, 0x04, 0x7C, 0x7F, 0x03, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x07, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0xF0, 0xF0, 0x10, 0x10, 0x10, 0x30, 0x30, 0x38, 0x1C, 0x11, 0x33,
  0x32, 0x22, 0x66, 0x66, 0x44, 0x4C, 0x1C, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x0F, 0x0F, 0x84, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC1, 0xC0,
  0x31, 0xBC, 0xB3, 0xD8, 0xC0,
};

const GFXglyph JetBrainsMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 12, 13, 10, -1, -13 },
  { 66, 10, 13, 10, 0, -13 },
  { 83, 2, 5, 10, 5, -12 },
  { 85, 7, 16, 10, 3, -14 },
  { 99, 7, 16, 10, 1, -14 },
  { 113, 9, 8, 10, 1, -10 },
  { 122, 8, 8, 10, 1, -10 },
  { 130, 4, 6, 10, 2, -3 },
  { 133, 6, 1, 10, 2, -6 },
  { 134, 3, 3, 10, 3, -3 },
  { 136, 10, 16, 10, 0, -14 },
  { 156, 9, 13, 10, 1, -13 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 9, 13, 10, 1, -13 },
  { 198, 9, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 9, 12, 10, 1, -12 },
  { 238, 8, 12, 10, 1, -12 },
  { 250, 8, 12, 10, 2, -12 },
  { 262, 9, 13, 10, 1, -13 },
  { 277, 8, 13, 10, 2, -13 },
  { 290, 4, 10, 10, 3, -10 },
  { 295, 5, 13, 10, 2, -10 },
  { 304, 9, 9, 10, 1, -10 },
  { 315, 8, 5, 10, 1, -8 },
  { 320, 8, 9, 10, 1, -10 },
  { 329, 7, 12, 10, 2, -12 },
  { 340, 10, 16, 10, 0, -13 },
  { 360, 9, 12, 10, 0, -12 },
  { 374, 9, 12, 10, 1, -12 },
  { 388, 9, 13, 10, 1, -13 },
  { 403, 9, 12, 10, 1, -12 },
  { 417, 9, 12, 10, 1, -12 },
  { 431, 9, 12, 10, 1, -12 },
  { 445, 9, 13, 10, 1, -13 },
  { 460, 9, 12, 10, 1, -12 },
  { 474, 9, 12, 10, 1, -12 },
  { 488, 10, 12, 10, 0, -12 },
  { 503, 10, 12, 10, 1, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 9, 12, 10, 1, -12 },
  { 544, 9, 12, 10, 1, -12 },
  { 558, 9, 13, 10, 1, -13 },
  { 573, 9, 12, 10, 1, -12 },
  { 587, 9, 16, 10, 1, -13 },
  { 605, 9, 12, 10, 1, -12 },
  { 619, 9, 13, 10, 1, -13 },
  { 634, 8, 12, 10, 2, -12 },
  { 646, 9, 12, 10, 1, -12 },
  { 660, 9, 12, 10, 2, -12 },
  { 674, 10, 12, 10, 1, -12 },
  { 689, 11, 12, 10, 0, -12 },
  { 706, 9, 12, 10, 2, -12 },
  { 720, 9, 12, 10, 1, -12 },
  { 734, 7, 16, 10, 2, -14 },
  { 748, 5, 16, 10, 3, -14 },
  { 758, 6, 16, 10, 2, -14 },
  { 770, 7, 6, 10, 2, -12 },
  { 776, 8, 2, 10, 0, 0 },
  { 778, 4, 2, 10, 4, -13 },
  { 779, 8, 10, 10, 1, -10 },
  { 789, 8, 12, 10, 1, -12 },
  { 801, 8, 10, 10, 1, -10 },
  { 811, 9, 12, 10, 1, -12 },
  { 825, 8, 10, 10, 1, -10 },
  { 835, 12, 15, 10, -1, -12 },
  { 858, 8, 13, 10, 1, -10 },
  { 871, 8, 12, 10, 1, -12 },
  { 883, 8, 13, 10, 1, -13 },
  { 896, 9, 16, 10, 0, -13 },
  { 914, 9, 12, 10, 1, -12 },
  { 928, 7, 12, 10, 2, -12 },
  { 939, 10, 10, 10, 0, -10 },
  { 952, 8, 10, 10, 1, -10 },
  { 962, 8, 10, 10, 1, -10 },
  { 972, 9, 13, 10, 0, -10 },
  { 987, 8, 13, 10, 1, -10 },
  { 1000, 9, 10, 10, 1, -10 },
  { 1012, 8, 10, 10, 1, -10 },
  { 1022, 9, 12, 10, 1, -12 },
  { 1036, 8, 9, 10, 1, -9 },
  { 1045, 8, 9, 10, 2, -9 },
  { 1054, 9, 9, 10, 1, -9 },
  { 1065, 10, 9, 10, 0, -9 },
  { 1077, 8, 12, 10, 1, -9 },
  { 1089, 8, 9, 10, 1, -9 },
  { 1098, 8, 16, 10, 2, -14 },
  { 1114, 4, 16, 10, 3, -14 },
  { 1122, 9, 16, 10, 0, -14 },
  { 1140, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_ITALIC17PT7B_H_
