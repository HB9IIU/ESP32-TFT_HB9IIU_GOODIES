#ifndef _JETBRAINSMONO_ITALIC22PT7B_H_
#define _JETBRAINSMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x31, 0x08, 0x00, 0x33, 0xDC, 0x66,
  0xCF, 0x9E, 0x3C, 0x78, 0xB1, 0x00, 0x03, 0x18, 0x10, 0x81, 0x8C, 0x0C,
  0x63, 0xFF, 0x9F, 0xFC, 0x31, 0x81, 0x08, 0x18, 0xC0, 0xC6, 0x1F, 0xFD,
  0xFF, 0xC3, 0x18, 0x10, 0x81, 0x8C, 0x0C, 0x60, 0x01, 0x00, 0x10, 0x01,
  0x00, 0xFC, 0x1F, 0xE3, 0xB6, 0x32, 0x63, 0x20, 0x32, 0x03, 0xA0, 0x1F,
  0x00, 0x7C, 0x05, 0xC0, 0x4C, 0x04, 0xCC, 0x4C, 0xEC, 0xC7, 0xF8, 0x3F,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0x06, 0x33, 0x18, 0x46, 0x21, 0x88,
  0x83, 0x13, 0x06, 0x6C, 0x07, 0xB0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0xF0,
  0x1B, 0x30, 0x6C, 0x61, 0x98, 0x86, 0x31, 0x08, 0x66, 0x60, 0x78, 0x07,
  0xC0, 0x77, 0x06, 0x18, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0xC0,
  0x36, 0x3B, 0x19, 0x98, 0xD8, 0xC3, 0x86, 0x18, 0x30, 0xE1, 0xFF, 0x87,
  0xCC, 0x6D, 0xFD, 0xB0, 0x00, 0x40, 0x60, 0x78, 0x38, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xF0, 0x0E, 0x01, 0x00, 0x10, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x07, 0x0F, 0x0E, 0x04, 0x00, 0x03, 0x00, 0x60,
  0x06, 0x06, 0x67, 0xFD, 0xF1, 0xF8, 0x0E, 0x01, 0xB0, 0x33, 0x87, 0x18,
  0x21, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0xC1, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x1C, 0xE3, 0x1C, 0x63, 0x8C, 0x00, 0xFF, 0xFC,
  0xFF, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F,
  0xC1, 0xCE, 0x30, 0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x66, 0x66,
  0x66, 0x04, 0x60, 0xCC, 0x0C, 0xC0, 0xC6, 0x18, 0x7F, 0x83, 0xE0, 0x07,
  0x83, 0xE3, 0x90, 0xCC, 0x23, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x8F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFC, 0xC1, 0x98,
  0x34, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x3F, 0xF7, 0xFE, 0x1F, 0xE7, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xE0, 0x7E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x6C, 0x0D, 0xC3,
  0x1F, 0xE1, 0xF0, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x09, 0xC6, 0x30, 0xCC, 0x19, 0x83, 0x3F, 0xE8, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x1F, 0xE3, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x66, 0x0F, 0xF1, 0xCE,
  0x70, 0xC0, 0x18, 0x03, 0x00, 0x6C, 0x0C, 0xC3, 0x1F, 0xE1, 0xF8, 0x01,
  0xC0, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xE1, 0xFE, 0x70, 0xCC,
  0x0F, 0x01, 0xE0, 0x6C, 0x0D, 0xC3, 0x9F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFC,
  0x0F, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x80, 0x0F, 0xC3, 0x9C, 0xE1, 0x98, 0x33, 0x06,
  0x61, 0x86, 0x60, 0x78, 0x1F, 0x86, 0x39, 0x83, 0x20, 0x6C, 0x0D, 0xC3,
  0x9F, 0xE1, 0xF8, 0x1F, 0x87, 0xF9, 0x83, 0x30, 0x3C, 0x07, 0x81, 0xB0,
  0x37, 0x0E, 0x7F, 0x87, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x3D, 0xC0, 0x0E, 0x3C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0x00,
  0x40, 0x70, 0x78, 0x78, 0x78, 0x30, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x18, 0x02, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xF0,
  0x20, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x70, 0x3C, 0x1E,
  0x0F, 0x03, 0x00, 0x40, 0x00, 0x7E, 0x3F, 0x80, 0xE0, 0x30, 0x18, 0x18,
  0x0C, 0x1C, 0x3C, 0x18, 0x0C, 0x08, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0x07,
  0xF0, 0x71, 0xC6, 0x06, 0x60, 0x33, 0x01, 0x90, 0x6C, 0x8F, 0xEC, 0x63,
  0x66, 0x1B, 0x30, 0x99, 0x8C, 0x8C, 0x64, 0x63, 0x63, 0xFB, 0x0E, 0xD8,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x0F,
  0x03, 0x60, 0x6C, 0x09, 0x83, 0x30, 0x66, 0x18, 0x43, 0x08, 0xFF, 0x9F,
  0xF3, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0x1F, 0xC3, 0xFE, 0x30, 0x63, 0x06,
  0x30, 0x63, 0x06, 0x30, 0xC7, 0xF0, 0x7F, 0xC6, 0x0C, 0x60, 0xC6, 0x0C,
  0x60, 0xCC, 0x1C, 0xFF, 0x8F, 0xE0, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x06,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x1F, 0x87, 0xF8, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x4C, 0x19, 0x83, 0x30, 0x66, 0x0D,
  0x83, 0x3F, 0xC7, 0xF0, 0x1F, 0xF1, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xFC, 0x7F, 0xC6, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0xFC, 0x7F, 0xC6, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x06, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x67, 0xE6, 0x7C, 0x60, 0xC6, 0x0C, 0x60, 0xC6,
  0x1C, 0x7F, 0x83, 0xF0, 0x18, 0x33, 0x02, 0x30, 0x63, 0x06, 0x30, 0x63,
  0x06, 0x30, 0x67, 0xFE, 0x7F, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCC,
  0x0C, 0xC1, 0x8C, 0x18, 0x1F, 0xE3, 0xFC, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x1F,
  0xE7, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x7F,
  0x83, 0xF0, 0x18, 0x39, 0x83, 0x8C, 0x18, 0x61, 0x83, 0x1C, 0x18, 0xC0,
  0xCC, 0x0F, 0xE0, 0x7F, 0x03, 0x18, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x60,
  0xC3, 0x03, 0x18, 0x18, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0x38, 0x73,
  0x85, 0x28, 0xF2, 0x8B, 0x2D, 0xA6, 0xD2, 0x6F, 0x66, 0xF6, 0x66, 0x66,
  0x06, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0x38, 0x33,
  0xC3, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0x46, 0x26, 0x66, 0x66, 0x66, 0x46,
  0x6C, 0x62, 0xC6, 0x3C, 0x43, 0xCC, 0x3C, 0xC3, 0x8C, 0x18, 0x0F, 0xC3,
  0xFC, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xD8, 0x1B, 0x03, 0x60, 0x4C, 0x19,
  0x83, 0x30, 0x66, 0x0C, 0xC3, 0x1F, 0xE1, 0xF8, 0x1F, 0xC3, 0xFE, 0x30,
  0x73, 0x03, 0x30, 0x33, 0x03, 0x30, 0x66, 0x0E, 0x7F, 0xC6, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC1, 0xFE, 0x38,
  0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x60,
  0xCC, 0x0C, 0xC0, 0xC6, 0x18, 0x7F, 0x83, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x1F, 0xC3, 0xFE, 0x30, 0x73, 0x03, 0x30, 0x33, 0x06, 0x30,
  0x67, 0xFC, 0x7F, 0x86, 0x30, 0x63, 0x06, 0x38, 0x61, 0x8C, 0x18, 0xC1,
  0xCC, 0x0C, 0x0F, 0xC1, 0xFE, 0x38, 0x63, 0x06, 0x30, 0x03, 0x00, 0x38,
  0x01, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0xC0, 0xCE, 0x0C, 0x7F,
  0x83, 0xF0, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x33, 0x03, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06, 0x30, 0x66, 0x06,
  0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x18, 0x7F, 0x83, 0xF0,
  0xC0, 0xF8, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x18, 0x46,
  0x0C, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x63, 0x1B,
  0x18, 0xD9, 0xC6, 0xCA, 0x66, 0x53, 0x32, 0x99, 0xB4, 0x8D, 0x2C, 0x49,
  0x62, 0xCB, 0x14, 0x50, 0xA3, 0x85, 0x3C, 0x39, 0xC1, 0x8E, 0x1C, 0x70,
  0x18, 0x1C, 0x60, 0xE0, 0xC3, 0x03, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x78,
  0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xD8, 0x06, 0x70, 0x38, 0xC0, 0xC3,
  0x06, 0x06, 0x38, 0x18, 0xE0, 0x36, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0x83,
  0x30, 0x33, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xFF, 0xCF, 0xF8, 0x1F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x1F, 0x80, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x0C,
  0x30, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x1F, 0x8F, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x1F, 0x00, 0x06, 0x03, 0xC0, 0xB0, 0x64, 0x31, 0x0C,
  0x66, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0xE0, 0xC6, 0x30, 0x1F, 0x67, 0x3C,
  0xC3, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x39, 0xFE,
  0x1E, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x7C, 0x73, 0x8C, 0x3B,
  0x03, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x0D, 0xC3, 0x37, 0xE6, 0xF8,
  0x0F, 0xC7, 0xB8, 0xC1, 0xB0, 0x36, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0xCC, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x1F,
  0x63, 0x9E, 0x30, 0xE6, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60,
  0xC6, 0x1C, 0x7F, 0x83, 0xD8, 0x0F, 0x87, 0x38, 0xC3, 0xB0, 0x36, 0x04,
  0xFF, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x39, 0xCE, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xFF, 0x87, 0xFE, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x3E, 0xDC, 0xF6, 0x1F, 0x03, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0xBF,
  0x67, 0xF0, 0x0C, 0x03, 0x00, 0xCF, 0xE3, 0xF0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x7C, 0x73, 0x8C, 0x3B, 0x03, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0x66, 0x0D, 0x81, 0xB0, 0x26, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC3, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x21,
  0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x07, 0xE0, 0xFC, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x73, 0x0E, 0x31, 0xC6, 0x38,
  0x63, 0x07, 0xE0, 0x7E, 0x06, 0x30, 0x63, 0x06, 0x18, 0xC1, 0x8C, 0x0C,
  0xFC, 0x7E, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFE, 0x3F, 0x3F, 0x73, 0x3B, 0x33, 0x33, 0x33,
  0x33, 0x32, 0x23, 0x62, 0x36, 0x22, 0x66, 0x26, 0x66, 0x66, 0x6C, 0x66,
  0x37, 0xC7, 0x38, 0xC3, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60,
  0xD8, 0x1B, 0x02, 0x60, 0xC0, 0x0F, 0x87, 0xB8, 0xC3, 0xB0, 0x36, 0x0C,
  0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x31, 0xFE, 0x1F, 0x80, 0x1B, 0xE1,
  0xEE, 0x18, 0x73, 0x03, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06, 0x30, 0x67,
  0x0C, 0x6F, 0xC6, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0x67,
  0x3C, 0xC3, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x39,
  0xFE, 0x1E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x37, 0xC7, 0x9C, 0xC1,
  0x98, 0x33, 0x06, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x00, 0x1F, 0xC7, 0x38, 0xC1, 0x98, 0x03, 0x00, 0x7E, 0x03, 0xF0, 0x06,
  0x00, 0xD8, 0x19, 0xFE, 0x3F, 0x80, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xE1,
  0xF0, 0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0x60, 0xCC, 0x31, 0xFE, 0x1F, 0x00, 0xC0, 0xE8, 0x19, 0x83, 0x30, 0xC6,
  0x18, 0xC6, 0x18, 0xC1, 0x30, 0x36, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x8C,
  0x31, 0x8E, 0x31, 0xCE, 0x29, 0x4D, 0x29, 0xAD, 0x25, 0x2C, 0xA5, 0x94,
  0xA3, 0x1C, 0x63, 0x80, 0x38, 0x38, 0xC3, 0x03, 0x38, 0x19, 0x80, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xB0, 0x19, 0x81, 0xC6, 0x1C, 0x31, 0xC1, 0xC0,
  0x60, 0xD8, 0x36, 0x0F, 0x03, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0xBF,
  0x67, 0x90, 0x0C, 0x03, 0x00, 0xCF, 0xE3, 0xF0, 0x3F, 0xE7, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xE0, 0x7C, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x1F, 0x83, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x30, 0x07, 0x80, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30,
  0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x86, 0x30, 0x1C, 0x03, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xFC, 0x1F, 0x86,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x00,
  0x3C, 0x6F, 0x8D, 0x99, 0xE1, 0xE0, 0x10,
};

const GFXglyph JetBrainsMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 7, 13, 4, -16 },
  { 18, 13, 16, 13, 0, -16 },
  { 44, 12, 22, 13, 1, -19 },
  { 77, 15, 16, 13, -1, -16 },
  { 107, 13, 16, 13, 0, -16 },
  { 133, 3, 7, 13, 6, -16 },
  { 136, 10, 22, 13, 3, -19 },
  { 164, 9, 22, 13, 1, -19 },
  { 189, 12, 11, 13, 1, -13 },
  { 206, 11, 10, 13, 1, -12 },
  { 220, 6, 7, 13, 2, -3 },
  { 226, 7, 2, 13, 3, -8 },
  { 228, 4, 3, 13, 4, -3 },
  { 230, 13, 20, 13, 0, -18 },
  { 263, 12, 16, 13, 1, -16 },
  { 287, 10, 16, 13, 1, -16 },
  { 307, 11, 16, 13, 1, -16 },
  { 329, 11, 16, 13, 1, -16 },
  { 351, 11, 16, 13, 1, -16 },
  { 373, 11, 16, 13, 1, -16 },
  { 395, 11, 16, 13, 1, -16 },
  { 417, 10, 16, 13, 3, -16 },
  { 437, 11, 16, 13, 1, -16 },
  { 459, 11, 16, 13, 2, -16 },
  { 481, 5, 12, 13, 4, -12 },
  { 489, 7, 16, 13, 2, -12 },
  { 503, 10, 12, 13, 2, -13 },
  { 518, 11, 7, 13, 1, -11 },
  { 528, 11, 12, 13, 1, -13 },
  { 545, 9, 16, 13, 3, -16 },
  { 563, 13, 20, 13, 0, -16 },
  { 596, 11, 16, 13, 0, -16 },
  { 618, 12, 16, 13, 1, -16 },
  { 642, 12, 16, 13, 1, -16 },
  { 666, 11, 16, 13, 1, -16 },
  { 688, 12, 16, 13, 1, -16 },
  { 712, 12, 16, 13, 1, -16 },
  { 736, 12, 16, 13, 1, -16 },
  { 760, 12, 16, 13, 1, -16 },
  { 784, 11, 16, 13, 1, -16 },
  { 806, 12, 16, 13, 0, -16 },
  { 830, 13, 16, 13, 1, -16 },
  { 856, 9, 16, 13, 2, -16 },
  { 874, 12, 16, 13, 1, -16 },
  { 898, 12, 16, 13, 1, -16 },
  { 922, 11, 16, 13, 1, -16 },
  { 944, 12, 16, 13, 1, -16 },
  { 968, 12, 20, 13, 1, -16 },
  { 998, 12, 16, 13, 1, -16 },
  { 1022, 12, 16, 13, 1, -16 },
  { 1046, 11, 16, 13, 3, -16 },
  { 1068, 12, 16, 13, 1, -16 },
  { 1092, 11, 16, 13, 3, -16 },
  { 1114, 13, 16, 13, 1, -16 },
  { 1140, 14, 16, 13, 0, -16 },
  { 1168, 12, 16, 13, 2, -16 },
  { 1192, 12, 16, 13, 1, -16 },
  { 1216, 9, 20, 13, 3, -18 },
  { 1239, 6, 20, 13, 4, -18 },
  { 1254, 9, 20, 13, 2, -18 },
  { 1277, 10, 9, 13, 2, -16 },
  { 1289, 11, 1, 13, 0, 1 },
  { 1291, 4, 3, 13, 6, -17 },
  { 1293, 11, 12, 13, 1, -12 },
  { 1310, 11, 16, 13, 1, -16 },
  { 1332, 11, 12, 13, 1, -12 },
  { 1349, 12, 16, 13, 1, -16 },
  { 1373, 11, 12, 13, 1, -12 },
  { 1390, 15, 20, 13, -1, -16 },
  { 1428, 10, 16, 13, 2, -12 },
  { 1448, 11, 16, 13, 1, -16 },
  { 1470, 10, 17, 13, 1, -17 },
  { 1492, 12, 21, 13, 0, -17 },
  { 1524, 12, 16, 13, 1, -16 },
  { 1548, 9, 16, 13, 2, -16 },
  { 1566, 12, 12, 13, 0, -12 },
  { 1584, 11, 12, 13, 1, -12 },
  { 1601, 11, 12, 13, 1, -12 },
  { 1618, 12, 16, 13, 0, -12 },
  { 1642, 11, 16, 13, 1, -12 },
  { 1664, 11, 12, 13, 1, -12 },
  { 1681, 11, 12, 13, 1, -12 },
  { 1698, 10, 15, 13, 2, -15 },
  { 1717, 11, 12, 13, 1, -12 },
  { 1734, 11, 12, 13, 2, -12 },
  { 1751, 11, 12, 13, 2, -12 },
  { 1768, 13, 12, 13, 0, -12 },
  { 1788, 10, 16, 13, 2, -12 },
  { 1808, 11, 12, 13, 1, -12 },
  { 1825, 11, 20, 13, 2, -18 },
  { 1853, 6, 20, 13, 4, -18 },
  { 1868, 11, 20, 13, 1, -18 },
  { 1896, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_ITALIC22PT7B_H_
