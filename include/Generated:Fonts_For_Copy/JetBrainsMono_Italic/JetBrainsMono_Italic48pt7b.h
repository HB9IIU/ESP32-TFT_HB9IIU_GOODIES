#ifndef _JETBRAINSMONO_ITALIC48PT7B_H_
#define _JETBRAINSMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1,
  0xF0, 0x00, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0x8E, 0x7E,
  0x07, 0xC3, 0x8F, 0x81, 0xE0, 0xC1, 0xE0, 0x78, 0x70, 0x78, 0x3E, 0x1C,
  0x1E, 0x0F, 0x87, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0x3F,
  0x1C, 0x00, 0x07, 0xEE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x73, 0xF0, 0x00, 0x1C, 0x7C, 0x00, 0x07, 0x0F, 0x80, 0x01,
  0xC3, 0xE0, 0x00, 0x70, 0xF8, 0x00, 0x18, 0x3E, 0x1E, 0x0E, 0x0F, 0x87,
  0x83, 0x83, 0xC1, 0xE0, 0xE1, 0xF0, 0x7C, 0x38, 0x78, 0x1F, 0x8E, 0x7E,
  0x03, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x07, 0x00, 0xFF, 0xE0,
  0x07, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x70, 0x3C, 0x07, 0x80, 0x78, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x03, 0x80, 0x0E, 0x03,
  0x83, 0x80, 0x07, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xE3, 0xC0, 0x01, 0xE0,
  0xE3, 0xC0, 0x00, 0xFF, 0xF3, 0xC0, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x1F,
  0xF1, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0xE3, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0x80, 0x00, 0xF3, 0xF7, 0xC0,
  0x00, 0xF1, 0xE0, 0xE0, 0x00, 0xF1, 0xE0, 0x78, 0x00, 0x70, 0xF0, 0x38,
  0x00, 0x70, 0x70, 0x1C, 0x00, 0x78, 0x38, 0x0E, 0x00, 0x78, 0x1C, 0x0F,
  0x00, 0x78, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x03, 0xC3,
  0xC0, 0x38, 0x01, 0xFF, 0xC0, 0x38, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x8F, 0x9F, 0x01, 0xE3, 0xE1, 0xE0,
  0x78, 0x78, 0x3E, 0x1F, 0x0F, 0x03, 0xC7, 0xC3, 0xE0, 0x7C, 0xF0, 0x7C,
  0x07, 0xFC, 0x0F, 0x80, 0xFF, 0x81, 0xE0, 0x0F, 0xE0, 0x3C, 0x01, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x01, 0xFE, 0x03, 0xE0,
  0x7F, 0xE0, 0x7F, 0x3F, 0x7C, 0x0F, 0xFF, 0xC7, 0xC0, 0xFF, 0xF0, 0xF8,
  0x0F, 0xF8, 0x0F, 0x80, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0xBE, 0xF3, 0xCF,
  0x3C, 0xF3, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x00, 0xF0, 0x04, 0xE0, 0x38,
  0x0E, 0x7F, 0x0E, 0x1F, 0xDF, 0xE3, 0x9F, 0xFF, 0xFE, 0xCF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x30, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x08,
  0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xF9, 0xE0, 0x1F, 0xCF, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF0, 0x0E,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x1E, 0x7F, 0xE0, 0x1E, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x8F, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0x80, 0x03, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xE3, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xE0,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x81, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFC,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x7F, 0x38, 0x78, 0x07, 0xFD,
  0xC3, 0xC0, 0x7F, 0xEE, 0x1E, 0x07, 0xC1, 0xF0, 0xF0, 0x3C, 0x0F, 0x87,
  0x83, 0xC0, 0x3C, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x1E, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x38, 0x07, 0x87, 0x83, 0xC0, 0x3C, 0x3C, 0x1E, 0x01,
  0xE1, 0xE0, 0xF0, 0x0E, 0x0E, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x07, 0x87,
  0x81, 0xE0, 0x3C, 0x3C, 0x0F, 0x83, 0xE1, 0xE0, 0x7F, 0xFF, 0x0F, 0x01,
  0xFF, 0x70, 0x78, 0x07, 0xF3, 0x83, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x78, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x03, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87,
  0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x78, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xE0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x1F,
  0xFE, 0x3C, 0x1F, 0xFC, 0x3C, 0x1F, 0xFC, 0x7C, 0x1F, 0xFC, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0x70,
  0x0F, 0xE0, 0xEE, 0x01, 0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xBC, 0x0E, 0xF0,
  0x77, 0x83, 0xDC, 0x0E, 0x70, 0x73, 0x81, 0xCE, 0x1E, 0x70, 0x79, 0xC3,
  0x9E, 0x0F, 0x3C, 0xF3, 0xC1, 0xE7, 0x9E, 0x78, 0x3C, 0xF3, 0x8E, 0x07,
  0x8E, 0xF3, 0xC0, 0xF1, 0xDC, 0x78, 0x3E, 0x3F, 0x8F, 0x07, 0x87, 0xE1,
  0xE0, 0xF0, 0xFC, 0x3C, 0x1E, 0x1F, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xC0, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0xC0, 0x1E,
  0x07, 0xF0, 0x07, 0x81, 0xFE, 0x01, 0xE0, 0x7F, 0x80, 0x78, 0x1D, 0xE0,
  0x1E, 0x0F, 0x78, 0x0F, 0x83, 0xCE, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C,
  0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC1, 0xF1, 0xC1, 0xF0,
  0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE1, 0xE1,
  0xE0, 0x78, 0x38, 0x78, 0x3E, 0x0F, 0x3E, 0x0F, 0x83, 0xCF, 0x83, 0xC0,
  0xF3, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0x3C, 0x0F, 0x01, 0xEF, 0x03,
  0xC0, 0x7B, 0xC1, 0xF0, 0x1E, 0xF0, 0x78, 0x07, 0xB8, 0x1E, 0x00, 0xFE,
  0x07, 0x80, 0x3F, 0x81, 0xE0, 0x0F, 0xE0, 0x78, 0x03, 0xF8, 0x3E, 0x00,
  0xFE, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF9, 0xFE, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x01, 0xFC, 0x0F, 0x00,
  0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x1F, 0x81,
  0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81,
  0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x7C, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x0F, 0x80, 0xF3, 0xC0, 0xF8, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0xC0, 0xF8,
  0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x83, 0xC7,
  0x83, 0xB8, 0x3C, 0x78, 0x3B, 0x83, 0xC7, 0x83, 0xB8, 0x38, 0x78, 0x33,
  0x87, 0x87, 0x87, 0x38, 0x78, 0x78, 0x73, 0x87, 0x87, 0x87, 0x38, 0x70,
  0x78, 0xE3, 0x8F, 0x07, 0x8E, 0x38, 0xF0, 0x78, 0xE3, 0x0E, 0x07, 0x8C,
  0x31, 0xE0, 0x79, 0xC3, 0x1E, 0x07, 0x9C, 0x31, 0xE0, 0x79, 0xC3, 0x1C,
  0x07, 0x38, 0x33, 0xC0, 0x73, 0x87, 0x3C, 0x07, 0x38, 0x73, 0xC0, 0x73,
  0x87, 0x38, 0x07, 0x70, 0x77, 0x80, 0xF7, 0x07, 0x78, 0x0F, 0x70, 0x77,
  0x00, 0xF6, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x07,
  0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x0E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0x7E, 0x01, 0x01, 0xFF, 0x9E, 0x03, 0xFF,
  0x9E, 0x07, 0xFF, 0xDE, 0x0F, 0xC0, 0xDE, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7F, 0x1E, 0xF0, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x0F, 0xF1,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x9F, 0xF8, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F,
  0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7B, 0xCF,
  0xF0, 0x7B, 0xFF, 0xE0, 0x79, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00,
  0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0xFF, 0xCF, 0x00,
  0xFF, 0xE7, 0x80, 0xFF, 0xFB, 0xC0, 0xFC, 0x0D, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFE, 0x3D, 0xE0, 0x3F, 0xFD, 0xF0, 0x1F,
  0xFC, 0xF8, 0x03, 0xFC, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87,
  0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x78,
  0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x01, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xDE, 0x07,
  0xFF, 0xDE, 0x0F, 0xC0, 0xDE, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xDE, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F,
  0xFC, 0xF0, 0x0F, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x87, 0xE0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F,
  0x7F, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x43, 0xE0, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC1, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0x1C, 0x0F, 0x03, 0xDF, 0xCF, 0xE0, 0xFF, 0xF7, 0xF8,
  0x3F, 0x7D, 0xBF, 0x0F, 0x0F, 0x87, 0xC7, 0xC1, 0xE0, 0xF1, 0xE0, 0x70,
  0x3C, 0x78, 0x1C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0xF8, 0x3C, 0x1E, 0x3C, 0x0E, 0x07, 0x8F, 0x03, 0x81, 0xE3,
  0xC0, 0xE0, 0xF8, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83,
  0xC7, 0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x3C, 0x78, 0x1C, 0x0F, 0x1E, 0x0F,
  0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x38, 0x1E, 0x3C,
  0x0E, 0x07, 0x8F, 0x03, 0x81, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0x9F, 0xF8,
  0x0F, 0xBF, 0xFC, 0x0F, 0x7F, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0xCF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xE7, 0xFE, 0x01, 0xF7, 0xFF, 0x80, 0xF7, 0xFF, 0xC0, 0x7F, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x7B, 0xCF, 0xF0,
  0x3D, 0xFF, 0xF0, 0x3E, 0x7F, 0xF0, 0x1F, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x3C, 0x0F, 0xFE, 0x78, 0x3F,
  0xFE, 0xF0, 0xFC, 0x0F, 0xE3, 0xE0, 0x0F, 0xC7, 0x80, 0x1F, 0x9F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x8F, 0x78, 0x3F,
  0xFD, 0xF0, 0x7F, 0xF3, 0xE0, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x87,
  0xE0, 0x0F, 0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00,
  0x7C, 0x7F, 0x87, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x9F, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81,
  0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x81, 0xDC, 0x0F, 0xC1,
  0xEE, 0x06, 0xE0, 0xF7, 0x07, 0x70, 0x73, 0x83, 0xB8, 0x79, 0xC1, 0x9C,
  0x3C, 0xE1, 0xCE, 0x1C, 0x70, 0xE7, 0x1E, 0x38, 0x73, 0x8F, 0x1C, 0x71,
  0xC7, 0x0E, 0x38, 0xE3, 0x87, 0x1C, 0x73, 0xC3, 0x8C, 0x39, 0xC1, 0xCE,
  0x1C, 0xE0, 0xE7, 0x0E, 0xF0, 0x73, 0x07, 0x70, 0x3B, 0x83, 0x38, 0x1D,
  0xC1, 0xBC, 0x0E, 0xC0, 0xDC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x37, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x3F, 0xFE, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x07,
  0xF1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x1F, 0xF0,
  0x0F, 0x3F, 0xF8, 0x0F, 0x7F, 0xF8, 0x1F, 0x78, 0x7C, 0x1E, 0x78, 0x3E,
  0x1E, 0xF8, 0x3F, 0xFC, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x03,
  0xE0,
};

const GFXglyph JetBrainsMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 35, 29, 9, -35 },
  { 50, 16, 14, 29, 9, -35 },
  { 78, 28, 35, 29, 1, -35 },
  { 201, 26, 49, 29, 2, -42 },
  { 361, 33, 35, 29, -1, -35 },
  { 506, 27, 36, 29, 1, -36 },
  { 628, 6, 14, 29, 14, -35 },
  { 639, 20, 47, 29, 8, -41 },
  { 757, 20, 47, 29, 2, -41 },
  { 875, 26, 24, 29, 2, -29 },
  { 953, 23, 22, 29, 3, -27 },
  { 1017, 12, 15, 29, 5, -7 },
  { 1040, 16, 4, 29, 7, -18 },
  { 1048, 8, 7, 29, 9, -7 },
  { 1055, 28, 45, 29, 1, -40 },
  { 1213, 24, 36, 29, 3, -36 },
  { 1321, 22, 35, 29, 2, -35 },
  { 1418, 25, 36, 29, 2, -36 },
  { 1531, 25, 35, 29, 2, -35 },
  { 1641, 23, 35, 29, 3, -35 },
  { 1742, 24, 35, 29, 3, -35 },
  { 1847, 24, 35, 29, 2, -35 },
  { 1952, 23, 35, 29, 6, -35 },
  { 2053, 25, 36, 29, 2, -36 },
  { 2166, 24, 36, 29, 4, -36 },
  { 2274, 11, 27, 29, 9, -27 },
  { 2312, 15, 35, 29, 5, -27 },
  { 2378, 23, 26, 29, 4, -29 },
  { 2453, 23, 16, 29, 3, -24 },
  { 2499, 23, 26, 29, 2, -29 },
  { 2574, 19, 35, 29, 7, -35 },
  { 2658, 29, 45, 29, 0, -36 },
  { 2822, 24, 35, 29, 0, -35 },
  { 2927, 25, 35, 29, 2, -35 },
  { 3037, 24, 36, 29, 3, -36 },
  { 3145, 25, 35, 29, 2, -35 },
  { 3255, 25, 35, 29, 3, -35 },
  { 3365, 27, 35, 29, 2, -35 },
  { 3484, 24, 36, 29, 3, -36 },
  { 3592, 26, 35, 29, 2, -35 },
  { 3706, 24, 35, 29, 3, -35 },
  { 3811, 26, 35, 29, 1, -35 },
  { 3925, 28, 35, 29, 2, -35 },
  { 4048, 21, 35, 29, 3, -35 },
  { 4140, 27, 35, 29, 2, -35 },
  { 4259, 26, 35, 29, 2, -35 },
  { 4373, 24, 36, 29, 3, -36 },
  { 4481, 27, 35, 29, 2, -35 },
  { 4600, 24, 45, 29, 3, -36 },
  { 4735, 26, 35, 29, 2, -35 },
  { 4849, 26, 36, 29, 2, -36 },
  { 4966, 25, 35, 29, 5, -35 },
  { 5076, 25, 35, 29, 3, -35 },
  { 5186, 24, 35, 29, 6, -35 },
  { 5291, 28, 35, 29, 3, -35 },
  { 5414, 30, 35, 29, 0, -35 },
  { 5546, 26, 35, 29, 5, -35 },
  { 5660, 26, 35, 29, 2, -35 },
  { 5774, 19, 45, 29, 7, -40 },
  { 5881, 14, 45, 29, 8, -40 },
  { 5960, 19, 45, 29, 4, -40 },
  { 6067, 21, 19, 29, 4, -35 },
  { 6117, 24, 4, 29, 0, 1 },
  { 6129, 8, 7, 29, 13, -38 },
  { 6136, 24, 27, 29, 3, -27 },
  { 6217, 24, 35, 29, 2, -35 },
  { 6322, 23, 27, 29, 3, -27 },
  { 6400, 25, 35, 29, 3, -35 },
  { 6510, 23, 27, 29, 3, -27 },
  { 6588, 33, 44, 29, -2, -35 },
  { 6770, 24, 36, 29, 3, -27 },
  { 6878, 24, 35, 29, 2, -35 },
  { 6983, 23, 37, 29, 2, -37 },
  { 7090, 24, 46, 29, 1, -37 },
  { 7228, 26, 35, 29, 2, -35 },
  { 7342, 20, 35, 29, 5, -35 },
  { 7430, 26, 27, 29, 1, -27 },
  { 7518, 24, 27, 29, 2, -27 },
  { 7599, 23, 27, 29, 3, -27 },
  { 7677, 25, 36, 29, 1, -27 },
  { 7790, 23, 36, 29, 3, -27 },
  { 7894, 24, 27, 29, 3, -27 },
  { 7975, 23, 27, 29, 3, -27 },
  { 8053, 23, 34, 29, 4, -34 },
  { 8151, 24, 26, 29, 3, -26 },
  { 8229, 23, 26, 29, 5, -26 },
  { 8304, 25, 26, 29, 4, -26 },
  { 8386, 27, 26, 29, 1, -26 },
  { 8474, 24, 35, 29, 3, -26 },
  { 8579, 24, 26, 29, 2, -26 },
  { 8657, 25, 45, 29, 4, -40 },
  { 8798, 12, 45, 29, 9, -40 },
  { 8866, 25, 45, 29, 1, -40 },
  { 9007, 24, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_ITALIC48PT7B_H_
