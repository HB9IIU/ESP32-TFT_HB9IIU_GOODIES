#ifndef _JETBRAINSMONO_ITALIC8PT7B_H_
#define _JETBRAINSMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x10, 0x76, 0x80, 0x29, 0x96, 0xAE, 0x50, 0x11, 0x9A, 0xC3,
  0x59, 0xC4, 0x6D, 0x98, 0x66, 0xD8, 0x32, 0x11, 0x79, 0x78, 0xE0, 0x16,
  0x44, 0x88, 0x84, 0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x4B, 0xA0,
  0xE0, 0xE0, 0xC0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x32, 0x52, 0xE9, 0x38,
  0x35, 0x22, 0x2F, 0x32, 0x44, 0x44, 0x78, 0x71, 0x21, 0x96, 0x12, 0x45,
  0xF1, 0xF3, 0x93, 0x80, 0x12, 0x75, 0x97, 0xF9, 0x24, 0x48, 0x35, 0x57,
  0x97, 0x69, 0x9E, 0x48, 0x43, 0x41, 0x80, 0x16, 0x86, 0xE3, 0x80, 0x42,
  0x1E, 0x64, 0xA1, 0x00, 0x32, 0x6F, 0x5A, 0xDB, 0x80, 0x33, 0x55, 0x79,
  0x72, 0x5C, 0xA9, 0x78, 0x69, 0x88, 0xAE, 0x75, 0x55, 0x9E, 0x7A, 0x1C,
  0x84, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x69, 0x8E, 0xAE, 0x4A, 0x5C, 0xA9,
  0x48, 0x79, 0x08, 0x42, 0x78, 0x38, 0x84, 0x29, 0x70, 0x4A, 0x98, 0xC9,
  0x48, 0x92, 0x49, 0xC0, 0x4A, 0xD5, 0x69, 0x48, 0x4B, 0x5C, 0xEB, 0x48,
  0x69, 0xAA, 0xAC, 0x72, 0x52, 0xE8, 0x40, 0x32, 0x54, 0xA9, 0x38, 0xC0,
  0x72, 0x54, 0xC9, 0x48, 0x32, 0x50, 0x69, 0x38, 0xF4, 0x44, 0x44, 0x4A,
  0x54, 0xA9, 0x30, 0x99, 0xAA, 0xCC, 0xDD, 0xBE, 0xAA, 0x4A, 0x88, 0x45,
  0x48, 0x9A, 0xA4, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25, 0x26, 0x91,
  0x24, 0x89, 0x64, 0xA4, 0x96, 0x4E, 0x80, 0xF0, 0xC0, 0x75, 0x97, 0x46,
  0x55, 0x9F, 0xF2, 0x70, 0x09, 0x54, 0xA9, 0x38, 0xFE, 0x70, 0x19, 0x1E,
  0x44, 0x23, 0x00, 0xF6, 0xFE, 0x46, 0x55, 0x99, 0x14, 0x22, 0x2F, 0x16,
  0x11, 0x12, 0xE0, 0x42, 0x54, 0xCA, 0x48, 0xC9, 0x28, 0xC0, 0x7D, 0xAD,
  0x60, 0x75, 0x99, 0xF6, 0xE0, 0x75, 0x9F, 0x80, 0x75, 0x97, 0x10, 0xF2,
  0x40, 0x76, 0x1F, 0x4F, 0x44, 0x86, 0x55, 0x96, 0xBA, 0xCC, 0xDE, 0xAA,
  0x59, 0x19, 0x20, 0xB6, 0xFE, 0x72, 0x4F, 0x12, 0x24, 0xC4, 0x46, 0xFF,
  0x42, 0x22, 0x34, 0x4C, 0x4D, 0x80,
};

const GFXglyph JetBrainsMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 3, 5, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 3, 5, 2, -6 },
  { 23, 4, 8, 5, 1, -7 },
  { 27, 4, 8, 5, 0, -7 },
  { 31, 5, 4, 5, 0, -5 },
  { 34, 3, 4, 5, 1, -5 },
  { 36, 2, 2, 5, 1, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 2, 1, 5, 1, -1 },
  { 39, 5, 8, 5, 0, -7 },
  { 44, 5, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 3, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 4, 6, 5, 0, -6 },
  { 73, 4, 6, 5, 1, -6 },
  { 76, 2, 4, 5, 1, -4 },
  { 77, 2, 5, 5, 1, -4 },
  { 79, 4, 4, 5, 1, -5 },
  { 81, 3, 3, 5, 1, -4 },
  { 83, 4, 4, 5, 0, -5 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 5, 7, 5, 0, -6 },
  { 93, 4, 6, 5, 0, -6 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 4, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 5, 6, 5, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 5, 7, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 5, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 4, 6, 5, 1, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 3, 8, 5, 1, -7 },
  { 191, 3, 8, 5, 1, -7 },
  { 194, 3, 8, 5, 1, -7 },
  { 197, 3, 3, 5, 1, -6 },
  { 199, 4, 1, 5, 0, 0 },
  { 200, 2, 1, 5, 2, -6 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 4, 6, 5, 0, -6 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 5, 6, 5, 0, -6 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 5, 7, 5, 0, -6 },
  { 219, 3, 5, 5, 1, -4 },
  { 221, 4, 6, 5, 0, -6 },
  { 224, 4, 6, 5, 0, -6 },
  { 227, 4, 7, 5, 0, -6 },
  { 231, 5, 6, 5, 0, -6 },
  { 235, 3, 6, 5, 1, -6 },
  { 238, 5, 4, 5, 0, -4 },
  { 241, 4, 4, 5, 0, -4 },
  { 243, 3, 4, 5, 1, -4 },
  { 245, 4, 5, 5, 0, -4 },
  { 248, 4, 5, 5, 0, -4 },
  { 251, 3, 4, 5, 1, -4 },
  { 253, 4, 4, 5, 0, -4 },
  { 255, 4, 6, 5, 1, -6 },
  { 258, 4, 4, 5, 0, -4 },
  { 260, 4, 4, 5, 1, -4 },
  { 262, 4, 4, 5, 1, -4 },
  { 264, 5, 4, 5, 0, -4 },
  { 267, 3, 5, 5, 1, -4 },
  { 269, 4, 4, 5, 0, -4 },
  { 271, 4, 8, 5, 1, -7 },
  { 275, 1, 8, 5, 2, -7 },
  { 276, 4, 8, 5, 0, -7 },
  { 280, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_ITALIC8PT7B_H_
