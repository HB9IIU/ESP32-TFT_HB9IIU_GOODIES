#ifndef _JETBRAINSMONO_ITALIC68PT7B_H_
#define _JETBRAINSMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xEF, 0x7F, 0xC0, 0x07, 0xF0, 0xF1, 0xFE, 0x00, 0xFE,
  0x1F, 0x0F, 0xE0, 0x1F, 0xC1, 0xE0, 0x7E, 0x01, 0xF8, 0x1E, 0x07, 0xE0,
  0x1F, 0x81, 0xE0, 0x7E, 0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x3F, 0x01, 0xE0,
  0x7E, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00,
  0x3F, 0xC3, 0xC0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x00,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x00, 0x1E, 0x03,
  0xF0, 0x7E, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x7E, 0x03,
  0xC0, 0x7E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07,
  0xF0, 0x3C, 0x1F, 0xC0, 0x7F, 0x83, 0xC3, 0xF8, 0x03, 0xFE, 0x3C, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0xFE, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x87, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF1, 0xFC, 0x3F, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x47, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xF0, 0x0F,
  0xE3, 0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x7F, 0x3F, 0x03,
  0xF0, 0x03, 0xFB, 0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xFF, 0xFE, 0x7F, 0x01,
  0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x1F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x0F,
  0x80, 0x06, 0x3C, 0x00, 0xF8, 0x03, 0xE7, 0xF8, 0x0F, 0x01, 0xFE, 0x7F,
  0xE0, 0xF0, 0x7F, 0xEF, 0xFF, 0x0F, 0x1F, 0xFE, 0xFF, 0xFC, 0xE7, 0xFF,
  0xF3, 0xFF, 0xEE, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x01, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F, 0x07, 0xF8, 0x3F, 0x07,
  0xE0, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFF,
  0xCF, 0xC0, 0x01, 0xFF, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x03, 0x80,
  0x1F, 0xC0, 0x02, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x1F, 0xFC,
  0x00, 0x1F, 0x9F, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0xCF, 0xFF, 0x00, 0x0F, 0xDF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x7E, 0x00, 0x1F,
  0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0x81, 0xF8, 0x00, 0xFF, 0xC7, 0xC0,
  0xF8, 0x00, 0xFF, 0xF3, 0xE0, 0x7C, 0x00, 0xFF, 0xFD, 0xF0, 0x3E, 0x00,
  0xFF, 0x1F, 0xF8, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x03,
  0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x01,
  0xF0, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x0F,
  0x80, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x07, 0xF0, 0x3E,
  0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0x80, 0x3F,
  0xFF, 0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xBE, 0x07, 0xC0, 0x07, 0xFF, 0x9F,
  0x03, 0xE0, 0x00, 0xFF, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01,
  0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x03,
  0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E,
  0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x3D, 0xF0,
  0x01, 0xF7, 0x80, 0x7B, 0xE0, 0x07, 0xFF, 0x00, 0xF7, 0xC0, 0x0F, 0xBC,
  0x01, 0xEF, 0x80, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x7D, 0xF0, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x3E, 0x7C, 0x01, 0xF1,
  0xE0, 0xF8, 0xF8, 0x07, 0xE3, 0xE1, 0xF1, 0xF0, 0x0F, 0xC7, 0xC7, 0xC3,
  0xE0, 0x1F, 0x8F, 0x8F, 0x8F, 0xC0, 0x3E, 0x1F, 0x3E, 0x1F, 0x80, 0x7C,
  0x3E, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0xF0, 0x7C, 0x01, 0xF0, 0x7B, 0xE1,
  0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0x07, 0xE0, 0x1F,
  0x83, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xF0,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xF8,
  0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0x00,
  0xFD, 0xF0, 0x01, 0xF8, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0x3F, 0x7E, 0x00,
  0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x00, 0x7C,
  0x7C, 0x01, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x80, 0x7E, 0x1F,
  0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x03,
  0xF3, 0xF0, 0x07, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0x7C, 0xFC, 0x03,
  0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0xFD,
  0xF8, 0x07, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x1F, 0x7C, 0x03, 0xF0,
  0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xA0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x80, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x7F, 0x80, 0x3E, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xF7, 0x00,
  0x7C, 0x3F, 0x00, 0xF7, 0x00, 0x7C, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3F,
  0x00, 0xEF, 0x00, 0xF8, 0x3F, 0x01, 0xEF, 0x00, 0xF8, 0x3F, 0x01, 0xEF,
  0x01, 0xF8, 0x3F, 0x01, 0xEF, 0x01, 0xF8, 0x3F, 0x03, 0xCF, 0x01, 0xF0,
  0x3F, 0x03, 0xCF, 0x01, 0xF0, 0x3E, 0x03, 0xCF, 0x03, 0xF0, 0x3E, 0x03,
  0xCF, 0x03, 0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x3E, 0x07, 0x8F, 0x03,
  0xE0, 0x3E, 0x07, 0x8F, 0x07, 0xE0, 0x3E, 0x0F, 0x0F, 0x07, 0xC0, 0x3E,
  0x0F, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x0F,
  0x0F, 0xC0, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x7E, 0x1E, 0x0F, 0x0F, 0x80,
  0x7E, 0x1E, 0x0E, 0x1F, 0x80, 0x7E, 0x3C, 0x0E, 0x1F, 0x80, 0x7E, 0x3C,
  0x0E, 0x1F, 0x00, 0x7E, 0x3C, 0x1E, 0x1F, 0x00, 0x7E, 0x3C, 0x1E, 0x3F,
  0x00, 0x7E, 0x78, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x1E, 0x3E, 0x00, 0x7C,
  0x78, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x1E, 0x7E, 0x00, 0x7C, 0xF0, 0x1E,
  0x7C, 0x00, 0x7C, 0xF0, 0x1E, 0x7C, 0x00, 0x7C, 0xF0, 0x1E, 0x7C, 0x00,
  0x7D, 0xE0, 0x1E, 0xF8, 0x00, 0x7D, 0xE0, 0x1E, 0xF8, 0x00, 0x7D, 0xE0,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x07, 0xFF, 0x87, 0xE0, 0x07,
  0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0xDF, 0x80,
  0xFF, 0xC1, 0xF7, 0xE0, 0x7F, 0x80, 0x1D, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x37, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFE, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xCF, 0xC0, 0x0F,
  0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x40, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xFE, 0x00,
  0x3F, 0x1F, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFE,
  0x01, 0xFB, 0xE0, 0xFF, 0xC0, 0x7E, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFB, 0x00, 0x1F, 0xE0, 0x7E, 0xE0, 0x0F, 0xF0, 0x1F,
  0xBF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE, 0x00,
  0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xFF,
  0x1F, 0x80, 0x0F, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x3F,
  0xF0, 0x7D, 0xF8, 0x07, 0xF8, 0x01, 0xDF, 0x80, 0x7F, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xDF, 0x80,
  0x3F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0x00, 0x1F, 0xFF, 0xFB,
  0xF0, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0x3F,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x1F, 0xFF,
  0x1F, 0x80, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF,
  0xFB, 0xF0, 0x3F, 0xF0, 0x7D, 0xF8, 0x1F, 0xE0, 0x0E, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xEF,
  0xC0, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xE3,
  0xF0, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xC0,
  0x0F, 0xDF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7E, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xCF, 0xF0,
  0xFF, 0x80, 0x3F, 0x7F, 0xE7, 0xFF, 0x00, 0xFB, 0xFF, 0x9F, 0xFC, 0x03,
  0xEF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x3F,
  0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xF8, 0x03, 0xF7,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x7E, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFF,
  0x00, 0x0F, 0xCF, 0xFF, 0xF8, 0x00, 0xFD, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFC, 0x01, 0xFB, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFB, 0x00, 0x1F, 0xE0, 0x1F,
  0xBC, 0x03, 0xFC, 0x01, 0xFB, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xF8,
  0x01, 0xF9, 0xFF, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0xC0, 0x03, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF3,
  0xF0, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x1F, 0xE0, 0x07,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1B, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFE, 0x7E,
  0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFE, 0x00,
  0xFC, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xFC, 0x03, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x03, 0xB8,
  0x03, 0xEF, 0x80, 0x7B, 0x80, 0x7C, 0xF8, 0x07, 0xB8, 0x07, 0xCF, 0x80,
  0x7B, 0x80, 0x7C, 0xF8, 0x0F, 0x38, 0x0F, 0x8F, 0x80, 0xF3, 0x80, 0xF8,
  0xF8, 0x0F, 0x38, 0x0F, 0x8F, 0x81, 0xE7, 0x80, 0xF0, 0xF8, 0x1E, 0x78,
  0x1F, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0xF8, 0x1C, 0x78, 0x1F, 0x0F, 0x83,
  0xC7, 0x83, 0xE0, 0xF8, 0x3C, 0x78, 0x3E, 0x0F, 0x83, 0x87, 0x83, 0xE0,
  0xF8, 0x78, 0x78, 0x7C, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0xF8, 0x70, 0x78,
  0x7C, 0x0F, 0x8F, 0x07, 0x8F, 0x80, 0xF8, 0xF0, 0x78, 0xF8, 0x0F, 0x8E,
  0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x78, 0xF0, 0x0F, 0x9E, 0x07, 0x9F, 0x00,
  0xF9, 0xC0, 0x79, 0xF0, 0x0F, 0xBC, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x7B,
  0xE0, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xBF, 0x01, 0xFF, 0xFF,
  0xDF, 0x80, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF,
  0xC7, 0xE0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0xFF,
  0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x0F, 0xCF, 0xE3, 0xFC, 0x03, 0xE3, 0xF0,
  0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x7E, 0x7E, 0x01, 0xFC, 0x3F, 0x1F,
  0x80, 0x7F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xF0,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 16, 50, 41, 13, -50 },
  { 101, 23, 21, 41, 13, -50 },
  { 162, 39, 50, 41, 2, -50 },
  { 406, 36, 69, 41, 3, -59 },
  { 717, 47, 50, 41, -2, -50 },
  { 1011, 37, 51, 41, 2, -50 },
  { 1247, 9, 21, 41, 19, -50 },
  { 1271, 28, 66, 41, 11, -57 },
  { 1502, 28, 66, 41, 3, -57 },
  { 1733, 36, 35, 41, 4, -41 },
  { 1891, 32, 32, 41, 5, -38 },
  { 2019, 18, 21, 41, 6, -10 },
  { 2067, 22, 5, 41, 10, -25 },
  { 2081, 12, 12, 41, 12, -11 },
  { 2099, 41, 63, 41, 1, -56 },
  { 2422, 35, 51, 41, 4, -50 },
  { 2646, 32, 50, 41, 3, -50 },
  { 2846, 35, 50, 41, 3, -50 },
  { 3065, 35, 51, 41, 3, -50 },
  { 3289, 33, 50, 41, 4, -50 },
  { 3496, 34, 51, 41, 4, -50 },
  { 3713, 33, 51, 41, 3, -50 },
  { 3924, 33, 50, 41, 8, -50 },
  { 4131, 35, 51, 41, 3, -50 },
  { 4355, 33, 50, 41, 6, -50 },
  { 4562, 17, 39, 41, 12, -38 },
  { 4645, 22, 49, 41, 7, -38 },
  { 4780, 32, 36, 41, 6, -40 },
  { 4924, 32, 21, 41, 5, -33 },
  { 5008, 33, 36, 41, 3, -40 },
  { 5157, 27, 50, 41, 10, -50 },
  { 5326, 41, 62, 41, 0, -50 },
  { 5644, 34, 50, 41, 0, -50 },
  { 5857, 36, 50, 41, 3, -50 },
  { 6082, 35, 51, 41, 4, -50 },
  { 6306, 35, 50, 41, 3, -50 },
  { 6525, 36, 50, 41, 4, -50 },
  { 6750, 38, 50, 41, 3, -50 },
  { 6988, 35, 51, 41, 4, -50 },
  { 7212, 36, 50, 41, 3, -50 },
  { 7437, 35, 50, 41, 4, -50 },
  { 7656, 38, 51, 41, 1, -50 },
  { 7899, 39, 50, 41, 3, -50 },
  { 8143, 29, 50, 41, 5, -50 },
  { 8325, 39, 50, 41, 2, -50 },
  { 8569, 37, 50, 41, 3, -50 },
  { 8801, 34, 51, 41, 4, -50 },
  { 9018, 38, 50, 41, 3, -50 },
  { 9256, 35, 62, 41, 4, -50 },
  { 9528, 37, 50, 41, 3, -50 },
  { 9760, 36, 51, 41, 3, -50 },
  { 9990, 34, 50, 41, 8, -50 },
  { 10203, 36, 51, 41, 4, -50 },
  { 10433, 34, 50, 41, 8, -50 },
  { 10646, 40, 50, 41, 4, -50 },
  { 10896, 42, 50, 41, 0, -50 },
  { 11159, 36, 50, 41, 7, -50 },
  { 11384, 36, 50, 41, 3, -50 },
  { 11609, 27, 63, 41, 10, -56 },
  { 11822, 21, 63, 41, 11, -56 },
  { 11988, 27, 63, 41, 6, -56 },
  { 12201, 30, 27, 41, 6, -50 },
  { 12303, 33, 5, 41, 0, 2 },
  { 12324, 12, 9, 41, 18, -53 },
  { 12338, 34, 39, 41, 4, -38 },
  { 12504, 34, 51, 41, 3, -50 },
  { 12721, 33, 39, 41, 4, -38 },
  { 12882, 36, 51, 41, 4, -50 },
  { 13112, 32, 39, 41, 4, -38 },
  { 13268, 46, 62, 41, -3, -50 },
  { 13625, 33, 50, 41, 5, -38 },
  { 13832, 34, 50, 41, 3, -50 },
  { 14045, 33, 53, 41, 2, -53 },
  { 14264, 35, 65, 41, 1, -53 },
  { 14549, 37, 50, 41, 3, -50 },
  { 14781, 28, 50, 41, 7, -50 },
  { 14956, 38, 38, 41, 1, -38 },
  { 15137, 34, 38, 41, 3, -38 },
  { 15299, 32, 39, 41, 4, -38 },
  { 15455, 36, 50, 41, 1, -38 },
  { 15680, 33, 50, 41, 4, -38 },
  { 15887, 33, 38, 41, 5, -38 },
  { 16044, 32, 39, 41, 4, -38 },
  { 16200, 32, 48, 41, 6, -48 },
  { 16392, 34, 38, 41, 4, -37 },
  { 16554, 33, 37, 41, 7, -37 },
  { 16707, 36, 37, 41, 5, -37 },
  { 16874, 38, 37, 41, 1, -37 },
  { 17050, 33, 49, 41, 5, -37 },
  { 17253, 34, 37, 41, 3, -37 },
  { 17411, 35, 63, 41, 6, -56 },
  { 17687, 16, 63, 41, 13, -56 },
  { 17813, 34, 63, 41, 2, -56 },
  { 18081, 34, 14, 41, 4, -31 },
};

const GFXfont JetBrainsMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_ITALIC68PT7B_H_
