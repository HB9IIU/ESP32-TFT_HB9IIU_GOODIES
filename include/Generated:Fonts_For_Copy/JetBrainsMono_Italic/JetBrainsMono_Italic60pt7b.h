#ifndef _JETBRAINSMONO_ITALIC60PT7B_H_
#define _JETBRAINSMONO_ITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03,
  0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78,
  0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0x8F, 0x3F, 0x80, 0x7E, 0x1C, 0x3F, 0x01, 0xF8, 0x38, 0x3F,
  0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1F, 0x83, 0xC1, 0xF8,
  0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x01,
  0xF8, 0x38, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x07,
  0xF3, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x3F, 0xC0, 0x00, 0x0E,
  0x3F, 0x80, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x78, 0x3F, 0x00, 0x00, 0xF0,
  0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x07, 0x03,
  0xF1, 0xF8, 0x1E, 0x07, 0xE3, 0xF0, 0x3C, 0x0F, 0x87, 0xE0, 0x78, 0x1F,
  0x0F, 0xC0, 0xF0, 0x7E, 0x0F, 0xC1, 0xC1, 0xF8, 0x1F, 0xC3, 0x87, 0xE0,
  0x3F, 0xF7, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x03,
  0xE1, 0xE0, 0x00, 0x1F, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xF1, 0xF0,
  0x00, 0x03, 0xFF, 0xF1, 0xF0, 0x00, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0x7C,
  0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x0F,
  0x80, 0x00, 0x3C, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x00, 0xFD, 0xF8, 0x0F, 0x80, 0x3F, 0x7C, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xFE, 0x01, 0xFE,
  0x1F, 0xEF, 0xC0, 0x3F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF0, 0x7E, 0x01,
  0xFF, 0xF8, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x03, 0xE0, 0x06, 0x3E, 0x03, 0xE0,
  0x3E, 0x7F, 0x83, 0xC1, 0xFE, 0x7F, 0xE1, 0xC7, 0xFF, 0xFF, 0xF9, 0xCF,
  0xFF, 0x3F, 0xFD, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x06, 0x03, 0xF0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0xFE, 0x0F, 0x83, 0xE1, 0xFC, 0x1F, 0x07,
  0xC3, 0xF8, 0x3E, 0x1F, 0x87, 0xF0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7C,
  0x03, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFB, 0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x70, 0x07, 0xC0, 0x04,
  0x00, 0x7C, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3E, 0x03,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x8F, 0xFE, 0x00, 0x3E, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3,
  0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xE7,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xBF, 0x00, 0x7F, 0xFB, 0xF0, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x7F, 0x1E, 0x0F, 0x80, 0x1F, 0xF9, 0xE0, 0xF8, 0x03,
  0xFF, 0xDE, 0x0F, 0x80, 0x7F, 0xFD, 0xE0, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0xF0, 0x1F, 0x80, 0x7E, 0x1F, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x1E,
  0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x3E, 0x00, 0x7C, 0x3E,
  0x03, 0xE0, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x3C,
  0x00, 0xF8, 0x3C, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7F, 0x07, 0xC0, 0x3F, 0xFE, 0xF0, 0x7C, 0x01, 0xFF, 0xCF,
  0x07, 0xC0, 0x0F, 0xF9, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0xF8, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x03,
  0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0x0F,
  0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF, 0x87, 0xE0,
  0x7F, 0xFE, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3D, 0xE0, 0x0F, 0x78, 0x0F, 0x78, 0x07,
  0xDE, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xF0,
  0x3C, 0xF0, 0x1E, 0x7C, 0x1F, 0x3C, 0x07, 0x8F, 0x07, 0x9F, 0x01, 0xE3,
  0xC3, 0xE7, 0xC0, 0x78, 0xF0, 0xF1, 0xF0, 0x3E, 0x3C, 0x7C, 0x78, 0x0F,
  0x8F, 0x1E, 0x3E, 0x03, 0xE3, 0xE7, 0x8F, 0x80, 0xF8, 0x7B, 0xC3, 0xE0,
  0x3E, 0x1E, 0xF0, 0xF8, 0x0F, 0x87, 0xF8, 0x7E, 0x07, 0xE1, 0xFE, 0x1F,
  0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFE,
  0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFE,
  0x00, 0x3E, 0x03, 0xDE, 0x00, 0x3E, 0x07, 0xDF, 0x00, 0x7E, 0x07, 0xDF,
  0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0xCF,
  0x00, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x0F, 0xCF, 0x80, 0xFC, 0x0F, 0x8F,
  0x80, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x0F, 0x87,
  0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x1F, 0x87,
  0xC1, 0xF8, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x01,
  0xE3, 0xF0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x01,
  0xF3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0xF3, 0xE0, 0x7E, 0x00,
  0xFB, 0xE0, 0x7E, 0x00, 0xFB, 0xC0, 0x7C, 0x00, 0xFB, 0xC0, 0x7C, 0x00,
  0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0xFC, 0x00,
  0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0x80, 0xF8, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x01, 0xFC,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x03,
  0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xF8, 0x0F, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0x78, 0xF8, 0x07, 0xE0, 0x1F,
  0x1F, 0x00, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x80, 0x7C, 0x7C, 0x07, 0x70,
  0x1F, 0x0F, 0x80, 0xEE, 0x03, 0xE3, 0xE0, 0x3D, 0xC0, 0x7C, 0x7C, 0x07,
  0xB8, 0x0F, 0x8F, 0x80, 0xEF, 0x03, 0xE1, 0xF0, 0x1D, 0xE0, 0x7C, 0x3E,
  0x07, 0xBC, 0x0F, 0x87, 0xC0, 0xF7, 0x81, 0xE0, 0xF8, 0x1C, 0xF0, 0x7C,
  0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x7C, 0x1C, 0x78,
  0x3C, 0x0F, 0x83, 0x8F, 0x0F, 0x81, 0xF0, 0xF1, 0xC1, 0xF0, 0x3E, 0x1E,
  0x38, 0x3C, 0x07, 0xC3, 0x87, 0x07, 0x80, 0xF8, 0xF0, 0xE1, 0xF0, 0x1F,
  0x1E, 0x1C, 0x3E, 0x03, 0xE3, 0x83, 0x87, 0x80, 0x78, 0x70, 0x71, 0xF0,
  0x0F, 0x1E, 0x0E, 0x3E, 0x01, 0xE3, 0xC1, 0xC7, 0xC0, 0x3C, 0x70, 0x38,
  0xF0, 0x07, 0x9E, 0x07, 0x3E, 0x00, 0xF3, 0xC0, 0xE7, 0xC0, 0x3E, 0x70,
  0x1C, 0xF0, 0x07, 0xCE, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0xF7, 0xC0, 0x1F,
  0x78, 0x1E, 0xF8, 0x03, 0xEE, 0x03, 0xDE, 0x00, 0x7D, 0xC0, 0x7B, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x78,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF7,
  0xE0, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F,
  0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0xFB, 0xF0,
  0x3F, 0xFF, 0xDF, 0x83, 0xFC, 0x1E, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF,
  0x7C, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x1F, 0x00, 0x7F, 0xE0, 0xF8,
  0x00, 0x38, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x0F, 0x83, 0xFE, 0x00,
  0x7C, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0x81, 0xFF,
  0x81, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x00,
  0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0xFD, 0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xE0,
  0x3F, 0x3F, 0xFE, 0x01, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0C,
  0x03, 0xE0, 0x01, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF,
  0xBF, 0x00, 0xFF, 0xFF, 0x7E, 0x03, 0xFC, 0x1E, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0x00, 0x7F, 0xFF,
  0x3E, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF,
  0xFB, 0xF0, 0x3F, 0xFF, 0xDF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0x80, 0x3F,
  0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x3B,
  0xE0, 0x7F, 0xFF, 0xDF, 0x03, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0,
  0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x0F,
  0x87, 0xFE, 0x00, 0x7C, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0xF0, 0x1F, 0x7F,
  0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x10, 0x03, 0xE3, 0xF0, 0x7F, 0x01, 0xF7, 0xFC,
  0xFF, 0x80, 0xFB, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0x80,
  0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0xC1, 0xF0,
  0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x0F,
  0x80, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF0,
  0x7C, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E,
  0x1F, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x0F,
  0x83, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x01,
  0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF,
  0xC0, 0x7D, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0xFF,
  0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xF8, 0x0F, 0xDF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x80, 0x3F, 0x3F, 0xFE,
  0x00, 0x7C, 0x3F, 0xF0, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x7E, 0x03,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xDF, 0x83, 0xFC, 0x1E, 0xF8, 0x3F, 0x80,
  0x3F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0xC1, 0xFF, 0xFF, 0x7C, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0x1F, 0x00,
  0x7F, 0xE0, 0xF8, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0x8F, 0xFC, 0x00, 0x7C, 0x7F, 0xFC, 0x01, 0xF3, 0xFF, 0xF8, 0x07,
  0xDF, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x01, 0xEF,
  0x01, 0xFC, 0x03, 0xDE, 0x03, 0xF8, 0x0F, 0xBC, 0x07, 0x70, 0x1E, 0x78,
  0x1E, 0xE0, 0x3C, 0xF0, 0x3D, 0xC0, 0xF9, 0xE0, 0x73, 0x81, 0xE3, 0xC0,
  0xE7, 0x03, 0xC7, 0x83, 0xCE, 0x0F, 0x8F, 0x07, 0x1C, 0x1E, 0x1E, 0x0E,
  0x38, 0x3C, 0x3C, 0x3C, 0x70, 0xF8, 0x78, 0x70, 0xE1, 0xE0, 0xF0, 0xE1,
  0xC3, 0xC1, 0xE3, 0xC3, 0x87, 0x83, 0xC7, 0x07, 0x1E, 0x07, 0x8E, 0x0E,
  0x3C, 0x0F, 0x3C, 0x1C, 0x78, 0x1E, 0x70, 0x39, 0xF0, 0x3C, 0xE0, 0x73,
  0xC0, 0x7B, 0xC0, 0xE7, 0x80, 0xF7, 0x01, 0xDF, 0x01, 0xEE, 0x03, 0xBC,
  0x03, 0xFC, 0x07, 0x78, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0x7C, 0x0F,
  0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0x0F, 0x80, 0x01, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x3F, 0xF8, 0x03, 0xF1,
  0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xC0, 0x3E, 0x7E, 0x3F, 0x80, 0xF9, 0xF0,
  0x7F, 0x03, 0xE7, 0xC0, 0xFC, 0x1F, 0x3E, 0x01, 0xFF, 0xFC, 0xF8, 0x07,
  0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00, 0x1F,
  0x80,
};

const GFXglyph JetBrainsMono_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 15, 44, 36, 11, -44 },
  { 84, 20, 18, 36, 11, -44 },
  { 129, 35, 44, 36, 1, -44 },
  { 322, 31, 60, 36, 3, -52 },
  { 555, 41, 44, 36, -2, -44 },
  { 781, 34, 45, 36, 1, -44 },
  { 973, 8, 18, 36, 17, -44 },
  { 991, 25, 59, 36, 10, -51 },
  { 1176, 25, 59, 36, 3, -51 },
  { 1361, 32, 31, 36, 3, -37 },
  { 1485, 29, 28, 36, 4, -34 },
  { 1587, 15, 19, 36, 6, -9 },
  { 1623, 20, 5, 36, 9, -22 },
  { 1636, 10, 10, 36, 11, -9 },
  { 1649, 36, 57, 36, 1, -50 },
  { 1906, 31, 45, 36, 3, -44 },
  { 2081, 28, 44, 36, 3, -44 },
  { 2235, 31, 44, 36, 3, -44 },
  { 2406, 31, 45, 36, 3, -44 },
  { 2581, 28, 44, 36, 4, -44 },
  { 2735, 30, 45, 36, 4, -44 },
  { 2904, 29, 45, 36, 3, -44 },
  { 3068, 29, 44, 36, 7, -44 },
  { 3228, 31, 45, 36, 3, -44 },
  { 3403, 29, 44, 36, 6, -44 },
  { 3563, 14, 35, 36, 11, -34 },
  { 3625, 19, 44, 36, 6, -34 },
  { 3730, 29, 32, 36, 5, -36 },
  { 3846, 29, 19, 36, 4, -29 },
  { 3915, 29, 32, 36, 3, -36 },
  { 4031, 25, 44, 36, 8, -44 },
  { 4169, 36, 55, 36, 0, -44 },
  { 4417, 30, 44, 36, 0, -44 },
  { 4582, 31, 44, 36, 3, -44 },
  { 4753, 30, 45, 36, 4, -44 },
  { 4922, 31, 44, 36, 3, -44 },
  { 5093, 33, 44, 36, 3, -44 },
  { 5275, 33, 44, 36, 3, -44 },
  { 5457, 30, 45, 36, 4, -44 },
  { 5626, 32, 44, 36, 3, -44 },
  { 5802, 30, 44, 36, 4, -44 },
  { 5967, 33, 45, 36, 1, -44 },
  { 6153, 34, 44, 36, 3, -44 },
  { 6340, 26, 44, 36, 4, -44 },
  { 6483, 34, 44, 36, 2, -44 },
  { 6670, 32, 44, 36, 3, -44 },
  { 6846, 30, 45, 36, 4, -44 },
  { 7015, 33, 44, 36, 3, -44 },
  { 7197, 31, 55, 36, 3, -44 },
  { 7411, 32, 44, 36, 3, -44 },
  { 7587, 31, 45, 36, 3, -44 },
  { 7762, 30, 44, 36, 7, -44 },
  { 7927, 31, 45, 36, 4, -44 },
  { 8102, 30, 44, 36, 7, -44 },
  { 8267, 35, 44, 36, 4, -44 },
  { 8460, 37, 44, 36, 0, -44 },
  { 8664, 32, 44, 36, 6, -44 },
  { 8840, 33, 44, 36, 2, -44 },
  { 9022, 23, 57, 36, 9, -50 },
  { 9186, 18, 57, 36, 10, -50 },
  { 9315, 24, 57, 36, 5, -50 },
  { 9486, 27, 24, 36, 5, -44 },
  { 9567, 30, 5, 36, 0, 1 },
  { 9586, 11, 8, 36, 16, -47 },
  { 9597, 29, 35, 36, 4, -34 },
  { 9724, 29, 45, 36, 3, -44 },
  { 9888, 29, 35, 36, 4, -34 },
  { 10015, 31, 45, 36, 4, -44 },
  { 10190, 28, 35, 36, 4, -34 },
  { 10313, 41, 55, 36, -3, -44 },
  { 10595, 29, 45, 36, 4, -34 },
  { 10759, 29, 44, 36, 3, -44 },
  { 10919, 29, 47, 36, 2, -47 },
  { 11090, 31, 58, 36, 1, -47 },
  { 11315, 32, 44, 36, 3, -44 },
  { 11491, 25, 44, 36, 6, -44 },
  { 11629, 33, 34, 36, 1, -34 },
  { 11770, 29, 34, 36, 3, -34 },
  { 11894, 28, 35, 36, 4, -34 },
  { 12017, 31, 45, 36, 1, -34 },
  { 12192, 29, 45, 36, 4, -34 },
  { 12356, 30, 34, 36, 4, -34 },
  { 12484, 28, 35, 36, 4, -34 },
  { 12607, 29, 42, 36, 5, -42 },
  { 12760, 29, 34, 36, 4, -33 },
  { 12884, 29, 33, 36, 6, -33 },
  { 13004, 31, 33, 36, 5, -33 },
  { 13132, 34, 33, 36, 1, -33 },
  { 13273, 29, 44, 36, 4, -33 },
  { 13433, 30, 33, 36, 3, -33 },
  { 13557, 30, 57, 36, 6, -50 },
  { 13771, 14, 57, 36, 12, -50 },
  { 13871, 31, 57, 36, 1, -50 },
  { 14092, 30, 12, 36, 4, -27 },
};

const GFXfont JetBrainsMono_Italic60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_ITALIC60PT7B_H_
