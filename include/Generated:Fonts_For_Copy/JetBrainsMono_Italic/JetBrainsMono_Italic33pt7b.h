#ifndef _JETBRAINSMONO_ITALIC33PT7B_H_
#define _JETBRAINSMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8,
  0x78, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xE3, 0xB8, 0x77, 0x0E,
  0xE1, 0xDC, 0x30, 0x00, 0xE0, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0xE0,
  0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE0, 0xE0, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x38,
  0x07, 0x06, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0x06, 0x00, 0xE0, 0xC0,
  0x18, 0x38, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x38, 0x07, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x1E, 0xDE, 0x1E, 0x67, 0x0E, 0x31, 0xCF, 0x18, 0xE7,
  0x18, 0x03, 0xCC, 0x01, 0xE6, 0x00, 0x7B, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x33, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06,
  0x39, 0xC6, 0x1C, 0xE3, 0x1C, 0x79, 0x8E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xE0, 0x0E, 0x1F, 0xE0, 0x30, 0x38, 0xC0, 0xE0, 0xE1, 0x83,
  0x81, 0xC3, 0x0E, 0x03, 0x06, 0x18, 0x06, 0x0C, 0x60, 0x0C, 0x39, 0x80,
  0x1E, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x33, 0xF8, 0x00, 0xEF, 0x78, 0x03,
  0x98, 0x70, 0x0E, 0x30, 0xE0, 0x18, 0x61, 0xC0, 0x61, 0xC3, 0x81, 0x83,
  0x86, 0x07, 0x07, 0x1C, 0x1C, 0x07, 0xF0, 0x70, 0x07, 0xC0, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0x70, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3B, 0xC1, 0xDC, 0x70, 0xE7, 0x0E, 0x71, 0xC3, 0xBC, 0x70, 0x7E,
  0x38, 0x1F, 0x0E, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x7C, 0x3C, 0x7B, 0x87,
  0xFC, 0xE0, 0xFC, 0x1C, 0x7B, 0x9C, 0xE7, 0x39, 0xDC, 0xE7, 0x00, 0x00,
  0x04, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x60, 0x04, 0x00, 0x38, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x0C, 0x0B, 0x86, 0x1F,
  0xF3, 0x7F, 0xFD, 0x7E, 0x1F, 0xF8, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xDC,
  0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x20, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x87, 0x87, 0x83,
  0xC3, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0xFF, 0xFF, 0xF8, 0x7B,
  0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0C,
  0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x71, 0xCE, 0x78, 0xE7, 0x3C,
  0x73, 0x8E, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x1C, 0x03, 0x8F, 0x03, 0xC3, 0xC7, 0xC1, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFB, 0x81, 0xC7, 0x07, 0x0E, 0x08,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xC7, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF8, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x1C, 0x0E,
  0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0xF0, 0x1D, 0xFE, 0x0F, 0xFF, 0x07,
  0x83, 0xC3, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x1C, 0x03, 0x8F, 0x03, 0xC3, 0xC7, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0xF0, 0x3F,
  0xFC, 0x3F, 0x7E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x7C, 0xF8, 0x7F,
  0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0F, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1E, 0x3C, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x1E, 0x3C, 0x38, 0x1C, 0x70, 0x1E, 0x60,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x7C, 0xF8, 0x7F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x3E, 0x38, 0x0F, 0x78,
  0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x1E, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xFC, 0xF8, 0xF8, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFE, 0x20, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x3F, 0x81, 0xFF, 0x1F, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x7F, 0x83, 0xF8, 0x1F, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0x81, 0xE0,
  0x70, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07,
  0x38, 0x1E, 0x63, 0x83, 0xF6, 0x38, 0x70, 0xE3, 0x86, 0x0E, 0x38, 0xE0,
  0xE3, 0x0E, 0x0E, 0x30, 0xE0, 0xE7, 0x0C, 0x0C, 0x70, 0xC0, 0xC7, 0x1C,
  0x1C, 0x71, 0xC1, 0xC6, 0x0E, 0x3C, 0x60, 0xFF, 0xCE, 0x07, 0xD8, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0xE0, 0xC0, 0x70, 0x70, 0x38,
  0x38, 0x38, 0x1C, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x73, 0x80, 0x19, 0xC0, 0x0F, 0xE0, 0x07, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x07,
  0xFF, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x38, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0xC0, 0xE1, 0xC0, 0x79,
  0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x03, 0xC3, 0xE7, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0xC0,
  0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x0F, 0xF3, 0x8F, 0xF1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x03,
  0xC3, 0xE7, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0x0F, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x3C,
  0x1F, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x1C, 0x01, 0xE3, 0x80, 0x70,
  0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x0E, 0x07, 0x01,
  0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xE1, 0xC0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x07, 0x87, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0x7F,
  0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x1F, 0x0D, 0x83, 0xE1, 0xB0,
  0x6C, 0x37, 0x1F, 0x86, 0xE3, 0x70, 0xCC, 0xEC, 0x19, 0x99, 0x87, 0x37,
  0x70, 0xE6, 0xCE, 0x1C, 0xF9, 0xC3, 0x9E, 0x38, 0x70, 0x07, 0x0C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0x1E, 0x03,
  0x8F, 0x81, 0xC7, 0xC0, 0xE3, 0xE0, 0x71, 0xB0, 0x31, 0xD8, 0x38, 0xEE,
  0x1C, 0x77, 0x0E, 0x3B, 0x87, 0x1C, 0xC3, 0x8E, 0x61, 0xCE, 0x39, 0xC7,
  0x1C, 0xE3, 0x8E, 0x71, 0xC3, 0x38, 0xE1, 0x9C, 0x70, 0xEE, 0x30, 0x76,
  0x38, 0x3B, 0x1C, 0x0F, 0x8E, 0x07, 0xC7, 0x03, 0xE3, 0x81, 0xF1, 0x80,
  0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xC7, 0xC3, 0xC0, 0xE1, 0xC0, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x03, 0x83, 0xE7, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x70,
  0x1E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xC7, 0xC3, 0xC0, 0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x07, 0x1C, 0x03, 0x8F, 0x03, 0xC3, 0xE7, 0xC1, 0xFF, 0xC0, 0x3F,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x80, 0xF1, 0xC0,
  0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E,
  0x07, 0x87, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x01, 0xC3, 0x80, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xE3, 0x80, 0x71, 0xC0, 0x3C, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78,
  0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x38, 0x78, 0x1E, 0x1F, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x0E, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x03, 0x83, 0xE7, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0x63, 0x80,
  0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x70, 0x70, 0xEE, 0x1E, 0x1D, 0xC3, 0xC3,
  0xB8, 0x78, 0x67, 0x1B, 0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D, 0x8C,
  0x63, 0x33, 0x8C, 0x64, 0x71, 0x8C, 0x8C, 0x33, 0x11, 0x86, 0x66, 0x70,
  0xCC, 0xCE, 0x19, 0x99, 0x87, 0x63, 0x70, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3,
  0xE1, 0xB0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0x0F, 0x00, 0x78, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x01,
  0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x80, 0x07, 0x9C, 0x00, 0x38,
  0xE0, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x81,
  0xC0, 0x1C, 0x1E, 0x00, 0x70, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0xF0,
  0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF8, 0x7F, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xDC, 0x07, 0x30, 0x38, 0xC0, 0xE3, 0x87,
  0x0E, 0x18, 0x18, 0xE0, 0x77, 0x01, 0xDC, 0x03, 0xE0, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC7, 0x0E, 0x1C, 0x07, 0xF7, 0x0F, 0xF7, 0x1E, 0x1F,
  0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C,
  0x78, 0xFC, 0x7F, 0xDC, 0x3F, 0xB8, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x39, 0xFC, 0x3B, 0xFE, 0x3E, 0x1E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C,
  0xFC, 0xF8, 0xEF, 0xF0, 0xEF, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C,
  0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x1F, 0xDC, 0x1F, 0xEE, 0x1E,
  0x1F, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x1E, 0x03,
  0x8F, 0x03, 0xC3, 0xC7, 0xE1, 0xFF, 0x70, 0x7F, 0x70, 0x07, 0xF8, 0x0F,
  0xFC, 0x1E, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF7, 0x0F, 0xF7, 0x1E, 0x1F, 0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C,
  0x70, 0x1C, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xDC, 0x0F, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x39, 0xFC, 0x3B, 0xFE, 0x3E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x70, 0x1E, 0x38, 0x0E, 0x1C,
  0x0E, 0x0E, 0x0E, 0x07, 0x0F, 0x07, 0x0F, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x71, 0xE0, 0x38, 0x70, 0x1C, 0x3C, 0x1C, 0x0E, 0x0E, 0x07,
  0x87, 0x01, 0xC3, 0x80, 0xF1, 0xC0, 0x3C, 0x7F, 0x83, 0xFE, 0x0F, 0xF8,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x3B, 0xCF, 0x8F, 0xFF, 0xE3, 0x8F, 0x38, 0xE3, 0x86, 0x38, 0xE1,
  0x8C, 0x38, 0xE3, 0x0C, 0x39, 0xC3, 0x0E, 0x70, 0xC3, 0x9C, 0x30, 0xE7,
  0x1C, 0x31, 0xC7, 0x1C, 0x61, 0xC7, 0x38, 0x61, 0xCE, 0x18, 0x73, 0x86,
  0x1C, 0xE3, 0x86, 0x38, 0xE3, 0x80, 0x39, 0xFC, 0x3B, 0xFE, 0x3E, 0x1E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E,
  0x3C, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38,
  0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1C, 0xFE, 0x0E, 0xFF, 0x87, 0xC3,
  0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71,
  0xE0, 0x78, 0xFC, 0x78, 0x77, 0xF8, 0x39, 0xF8, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0xF7, 0x0F,
  0xF7, 0x1E, 0x1F, 0x3C, 0x0F, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0x78, 0xDC, 0x7F, 0xDC, 0x3F, 0xB8, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x1D, 0xFC, 0x0F,
  0xFF, 0x07, 0xC3, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xFE, 0x1C, 0x1E, 0x38, 0x0F, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x1C, 0xF8, 0x78, 0x7F, 0xF8, 0x3F, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C,
  0xF0, 0x1C, 0x70, 0x38, 0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0xE0, 0x07,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x19, 0xC0,
  0x19, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0xC1, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF0, 0xD8, 0x78, 0xEC, 0x6C, 0x76, 0x36, 0x33, 0x1B,
  0x19, 0x99, 0x9C, 0xCC, 0xCC, 0x66, 0x66, 0x36, 0x37, 0x1B, 0x1B, 0x0D,
  0x8D, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x70,
  0x00, 0x0E, 0x01, 0xE1, 0xE0, 0x78, 0x1C, 0x1E, 0x01, 0xC3, 0x80, 0x38,
  0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0xC0, 0x1C, 0x38, 0x07, 0x87,
  0x81, 0xE0, 0x70, 0x38, 0x0F, 0x1E, 0x00, 0xF0, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x78, 0x7C,
  0x7F, 0xDC, 0x3F, 0xDC, 0x06, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x07, 0xC0, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0x80, 0x00, 0x1F, 0x03, 0x9F, 0xC1, 0x9F, 0xE1, 0xCC, 0x38, 0xEE,
  0x1F, 0xE7, 0x07, 0xF3, 0x80, 0xE0,
};

const GFXglyph JetBrainsMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 11, 10, 20, 6, -24 },
  { 39, 19, 24, 20, 1, -24 },
  { 96, 17, 34, 20, 2, -29 },
  { 169, 23, 24, 20, -1, -24 },
  { 238, 18, 24, 20, 1, -24 },
  { 292, 5, 10, 20, 9, -24 },
  { 299, 14, 32, 20, 5, -28 },
  { 355, 13, 32, 20, 2, -28 },
  { 407, 17, 17, 20, 2, -20 },
  { 444, 16, 16, 20, 2, -19 },
  { 476, 9, 10, 20, 3, -5 },
  { 488, 11, 2, 20, 5, -12 },
  { 491, 6, 5, 20, 6, -5 },
  { 495, 20, 31, 20, 0, -27 },
  { 573, 17, 24, 20, 2, -24 },
  { 624, 15, 24, 20, 2, -24 },
  { 669, 17, 24, 20, 2, -24 },
  { 720, 16, 24, 20, 2, -24 },
  { 768, 16, 24, 20, 2, -24 },
  { 816, 17, 24, 20, 2, -24 },
  { 867, 16, 24, 20, 2, -24 },
  { 915, 16, 24, 20, 4, -24 },
  { 963, 16, 24, 20, 2, -24 },
  { 1011, 16, 24, 20, 3, -24 },
  { 1059, 8, 18, 20, 6, -18 },
  { 1077, 11, 23, 20, 3, -18 },
  { 1109, 16, 18, 20, 3, -20 },
  { 1145, 16, 10, 20, 2, -16 },
  { 1165, 16, 18, 20, 2, -20 },
  { 1201, 13, 24, 20, 5, -24 },
  { 1240, 20, 30, 20, 0, -24 },
  { 1315, 17, 24, 20, 0, -24 },
  { 1366, 17, 24, 20, 2, -24 },
  { 1417, 17, 24, 20, 2, -24 },
  { 1468, 16, 24, 20, 2, -24 },
  { 1516, 18, 24, 20, 2, -24 },
  { 1570, 18, 24, 20, 2, -24 },
  { 1624, 17, 24, 20, 2, -24 },
  { 1675, 17, 24, 20, 2, -24 },
  { 1726, 17, 24, 20, 2, -24 },
  { 1777, 18, 24, 20, 1, -24 },
  { 1831, 19, 24, 20, 2, -24 },
  { 1888, 15, 24, 20, 2, -24 },
  { 1933, 19, 24, 20, 1, -24 },
  { 1990, 17, 24, 20, 2, -24 },
  { 2041, 17, 24, 20, 2, -24 },
  { 2092, 18, 24, 20, 2, -24 },
  { 2146, 17, 30, 20, 2, -24 },
  { 2210, 17, 24, 20, 2, -24 },
  { 2261, 18, 24, 20, 1, -24 },
  { 2315, 16, 24, 20, 4, -24 },
  { 2363, 17, 24, 20, 2, -24 },
  { 2414, 17, 24, 20, 4, -24 },
  { 2465, 19, 24, 20, 2, -24 },
  { 2522, 21, 24, 20, 0, -24 },
  { 2585, 17, 24, 20, 4, -24 },
  { 2636, 18, 24, 20, 1, -24 },
  { 2690, 13, 31, 20, 5, -27 },
  { 2741, 10, 31, 20, 5, -27 },
  { 2780, 13, 31, 20, 3, -27 },
  { 2831, 14, 13, 20, 3, -24 },
  { 2854, 16, 2, 20, 0, 1 },
  { 2858, 6, 5, 20, 9, -26 },
  { 2862, 16, 18, 20, 2, -18 },
  { 2898, 16, 24, 20, 2, -24 },
  { 2946, 16, 18, 20, 2, -18 },
  { 2982, 17, 24, 20, 2, -24 },
  { 3033, 16, 18, 20, 2, -18 },
  { 3069, 23, 30, 20, -2, -24 },
  { 3156, 16, 24, 20, 2, -18 },
  { 3204, 16, 24, 20, 2, -24 },
  { 3252, 16, 26, 20, 1, -26 },
  { 3304, 18, 32, 20, 0, -26 },
  { 3376, 17, 24, 20, 2, -24 },
  { 3427, 14, 24, 20, 3, -24 },
  { 3469, 18, 18, 20, 1, -18 },
  { 3510, 16, 18, 20, 2, -18 },
  { 3546, 16, 18, 20, 2, -18 },
  { 3582, 17, 24, 20, 1, -18 },
  { 3633, 16, 24, 20, 2, -18 },
  { 3681, 17, 18, 20, 2, -18 },
  { 3720, 16, 18, 20, 2, -18 },
  { 3756, 16, 23, 20, 3, -23 },
  { 3802, 16, 18, 20, 2, -18 },
  { 3838, 16, 18, 20, 3, -18 },
  { 3874, 17, 18, 20, 3, -18 },
  { 3913, 19, 18, 20, 0, -18 },
  { 3956, 16, 24, 20, 2, -18 },
  { 4004, 16, 18, 20, 2, -18 },
  { 4040, 17, 31, 20, 3, -27 },
  { 4106, 8, 31, 20, 6, -27 },
  { 4137, 17, 31, 20, 1, -27 },
  { 4203, 17, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_ITALIC33PT7B_H_
