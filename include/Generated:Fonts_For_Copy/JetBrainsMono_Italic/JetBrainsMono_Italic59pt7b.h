#ifndef _JETBRAINSMONO_ITALIC59PT7B_H_
#define _JETBRAINSMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE7,
  0x3F, 0x80, 0x3F, 0x0E, 0x3F, 0x80, 0xFC, 0x3C, 0x3F, 0x01, 0xF0, 0x78,
  0x3E, 0x07, 0xE0, 0xF0, 0x7C, 0x0F, 0x81, 0xC0, 0xF8, 0x1F, 0x03, 0x81,
  0xF0, 0x3E, 0x07, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xF8, 0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xF1, 0xC0, 0x00,
  0x07, 0xFB, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x1F, 0xC0, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x70, 0x3E, 0x00, 0x00,
  0xE0, 0x7E, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0xFC, 0x0F,
  0x03, 0xE1, 0xF8, 0x1E, 0x07, 0xC3, 0xF0, 0x3C, 0x1F, 0x87, 0xE0, 0x70,
  0x3E, 0x07, 0xE0, 0xE0, 0xFC, 0x0F, 0xE3, 0xC7, 0xF0, 0x1F, 0xF7, 0xBF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x01, 0xE0,
  0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x83,
  0xC0, 0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x03, 0xC3, 0xC0, 0x00,
  0x1F, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xFF, 0xE3, 0xE0, 0x00, 0x03, 0xFF,
  0xE3, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0xFF, 0xFC, 0x00,
  0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x0F, 0x80, 0x00, 0x78,
  0x7C, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x00,
  0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x3E, 0x1F,
  0x03, 0xE0, 0x1F, 0x9F, 0x81, 0xF0, 0x07, 0xEF, 0x80, 0xF8, 0x03, 0xFF,
  0x80, 0x7C, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x07,
  0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x0F,
  0xEF, 0xC0, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xE0, 0xF8, 0x07, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x3E,
  0x7D, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x20, 0x03, 0xE0, 0x04, 0x78, 0x07, 0x80, 0x3D, 0xFC, 0x0F, 0x03, 0xFB,
  0xFE, 0x1E, 0x1F, 0xFF, 0xFF, 0x38, 0xFF, 0xEF, 0xFF, 0x77, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x87, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F,
  0x81, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0xFE, 0x0F,
  0x83, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7C, 0x1F, 0x07, 0xF0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x3F, 0xC3,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03,
  0x00, 0x7E, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x0F,
  0x9F, 0xFE, 0x00, 0xFD, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0x3F, 0xF8,
  0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x1F, 0xBF, 0xF8, 0x01, 0xFB,
  0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFF,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xDF, 0x00, 0x7F, 0xFD, 0xF8, 0x01, 0xFF, 0xDF, 0x80,
  0x00, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFD, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x38, 0x3E, 0x0F, 0x80, 0x1F, 0xF3, 0xE0, 0xF8, 0x03, 0xFF,
  0xBE, 0x0F, 0x80, 0x7F, 0xFB, 0xC0, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x3E, 0x00,
  0x78, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x0F, 0x83,
  0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x7C, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7F, 0x07, 0xC0, 0x3F, 0xFD, 0xE0, 0x7C, 0x01, 0xFF, 0xDE, 0x07,
  0xC0, 0x0F, 0xF9, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x0F, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x0F, 0x81,
  0xFF, 0xF8, 0x3E, 0x07, 0xFF, 0xE0, 0xF8, 0x1F, 0xFF, 0x87, 0xE0, 0x7F,
  0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0x70,
  0x1F, 0xE0, 0x0F, 0xB8, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xBC, 0x03, 0xDE,
  0x07, 0x9E, 0x03, 0xEF, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE7, 0x81, 0xF7,
  0x80, 0xF3, 0xC0, 0xF3, 0xC0, 0x79, 0xF0, 0xF9, 0xE0, 0x3C, 0x78, 0x78,
  0xF0, 0x3E, 0x3C, 0x7C, 0xF8, 0x1F, 0x1E, 0x3C, 0x7C, 0x0F, 0x8F, 0x3E,
  0x3E, 0x07, 0xC7, 0x9E, 0x1E, 0x03, 0xE3, 0xEF, 0x1F, 0x01, 0xF0, 0xFF,
  0x0F, 0x81, 0xF0, 0x7F, 0x87, 0xC0, 0xF8, 0x3F, 0x83, 0xE0, 0x7C, 0x1F,
  0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x00,
  0xF8, 0x1F, 0xE0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x7F, 0xC0, 0x0F,
  0x80, 0xFF, 0x80, 0x1F, 0x03, 0xFF, 0x00, 0x3E, 0x07, 0xDE, 0x00, 0x7C,
  0x0F, 0xBC, 0x00, 0xF8, 0x1F, 0x7C, 0x01, 0xF0, 0x3E, 0xF8, 0x07, 0xE0,
  0x7D, 0xF0, 0x0F, 0x81, 0xF1, 0xE0, 0x1F, 0x03, 0xE3, 0xC0, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x3E,
  0x1E, 0x07, 0xC0, 0xFC, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xE1, 0xF8, 0x1F, 0x03,
  0xC3, 0xE0, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x1F,
  0x1F, 0x03, 0xE0, 0x1E, 0x3E, 0x07, 0xC0, 0x3C, 0x7C, 0x0F, 0x80, 0x7D,
  0xF0, 0x1F, 0x00, 0xFB, 0xE0, 0x7E, 0x01, 0xF7, 0xC0, 0xF8, 0x01, 0xEF,
  0x81, 0xF0, 0x03, 0xDF, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xFC,
  0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x3F, 0xC0,
  0xF8, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xFC,
  0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xCF,
  0x80, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0x78, 0xF0, 0x0F, 0xE0, 0x3E,
  0x7C, 0x03, 0xF8, 0x0F, 0x9F, 0x00, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x80,
  0xF1, 0xF0, 0x1D, 0xE0, 0x7C, 0x7C, 0x07, 0x70, 0x1F, 0x1F, 0x03, 0xDC,
  0x07, 0xC7, 0xC0, 0xF7, 0x01, 0xE1, 0xF0, 0x39, 0xC0, 0xF8, 0x7C, 0x0E,
  0x70, 0x3E, 0x1F, 0x07, 0x9C, 0x0F, 0x07, 0xC1, 0xE7, 0x07, 0xC1, 0xF0,
  0x71, 0xC1, 0xF0, 0x7C, 0x3C, 0x70, 0x7C, 0x1F, 0x0F, 0x1C, 0x1E, 0x07,
  0xC3, 0x87, 0x0F, 0x81, 0xF0, 0xE1, 0xC3, 0xE0, 0x7C, 0x78, 0x70, 0xF0,
  0x1E, 0x1E, 0x1C, 0x3C, 0x07, 0x87, 0x0F, 0x1F, 0x01, 0xE3, 0xC3, 0xC7,
  0xC0, 0x78, 0xF0, 0xF1, 0xE0, 0x1E, 0x38, 0x3C, 0x78, 0x07, 0x8E, 0x0F,
  0x3E, 0x03, 0xE7, 0x83, 0xCF, 0x80, 0xF9, 0xE0, 0xF3, 0xC0, 0x3E, 0x70,
  0x3D, 0xF0, 0x0F, 0xBC, 0x0E, 0x7C, 0x03, 0xEF, 0x03, 0x9E, 0x00, 0xFB,
  0x80, 0xE7, 0x80, 0x3E, 0xE0, 0x3B, 0xE0, 0x0F, 0xF8, 0x0E, 0xF8, 0x03,
  0xFE, 0x03, 0xBC, 0x00, 0xF7, 0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x78, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F,
  0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x08, 0x03, 0xFF,
  0x8F, 0x80, 0x7F, 0xFE, 0x7C, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xDF,
  0x07, 0xF8, 0x0E, 0xF8, 0x3F, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x1D, 0xF0, 0x3F, 0xFF, 0xEF, 0x80, 0xFF, 0xFE, 0x7C, 0x03, 0xFF,
  0xE7, 0xE0, 0x0F, 0xFC, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x7C, 0xFF, 0xFC, 0x07, 0xEF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF7, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0xC0, 0x1F, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xBF, 0xFF, 0xC0, 0xFD,
  0xFF, 0xFC, 0x07, 0xC7, 0xFF, 0xC0, 0x3E, 0x1F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x7C, 0x01, 0xFF,
  0xF9, 0xF0, 0x0F, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xDF, 0x03, 0xFC, 0x07,
  0x7C, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x1D, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0x9F, 0x00, 0x7F,
  0xFC, 0xFC, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x08, 0x03, 0xFF, 0x8F, 0x80, 0x7F, 0xFE, 0x7C, 0x07, 0xFF, 0xFB,
  0xE0, 0x7F, 0xFF, 0xDF, 0x07, 0xF8, 0x0E, 0xF8, 0x3F, 0x00, 0x3F, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x6F, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xBE, 0x01, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x0F,
  0xE0, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x7C, 0xFF,
  0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0x81, 0xF7, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0xCF,
  0xE1, 0xFE, 0x07, 0xDF, 0xF3, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0x07, 0xE1,
  0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0x80,
  0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0x3E, 0x1F, 0x01,
  0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x01,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03,
  0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03,
  0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x07,
  0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07,
  0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x78, 0x0F,
  0x01, 0xF0, 0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3E, 0x3F,
  0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFE,
  0x07, 0xDC, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xE3, 0xFF,
  0xC0, 0x07, 0xCF, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7D, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xEF, 0xFF,
  0xF0, 0x0F, 0xDF, 0xFF, 0xC0, 0x1F, 0x1F, 0xFF, 0x00, 0x3E, 0x1F, 0xF8,
  0x00, 0x7C, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x08,
  0x07, 0xFF, 0x8F, 0x80, 0x7F, 0xFE, 0x7C, 0x07, 0xFF, 0xFB, 0xE0, 0x7F,
  0xFF, 0xDF, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x1D, 0xF0, 0x3F, 0xFF, 0xEF, 0x80, 0xFF, 0xFE, 0x7C,
  0x03, 0xFF, 0xE7, 0xE0, 0x0F, 0xFC, 0x3E, 0x00, 0x06, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3E, 0x3F, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x0F,
  0xBF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFE, 0x07, 0xDC, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0x7F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x80, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0x7B, 0xC0,
  0x3F, 0x01, 0xF7, 0x80, 0xFE, 0x03, 0xEF, 0x01, 0xDC, 0x07, 0x9E, 0x03,
  0xB8, 0x0F, 0x3C, 0x0F, 0x70, 0x3E, 0x78, 0x1C, 0xE0, 0x78, 0xF0, 0x39,
  0xC0, 0xF1, 0xE0, 0xF3, 0x83, 0xE3, 0xC1, 0xC7, 0x07, 0x87, 0x83, 0x8E,
  0x0F, 0x0F, 0x0F, 0x1C, 0x3E, 0x1E, 0x1C, 0x38, 0x78, 0x3C, 0x38, 0x70,
  0xF0, 0x78, 0xF1, 0xE3, 0xE0, 0xF1, 0xC3, 0xC7, 0x81, 0xE3, 0x87, 0x8F,
  0x03, 0xC7, 0x0F, 0x1E, 0x07, 0x9E, 0x1E, 0x78, 0x0F, 0x38, 0x3C, 0xF0,
  0x1E, 0x70, 0x79, 0xE0, 0x3D, 0xE0, 0xF7, 0x80, 0x7B, 0x81, 0xEF, 0x00,
  0xF7, 0x03, 0xDE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0D, 0xF0, 0x7F, 0x81,
  0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0x3E,
  0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x7F, 0xE0, 0x07, 0xC7, 0xFF, 0x80, 0x3E, 0x7F,
  0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x0F, 0xBE, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F,
  0x07, 0xDF, 0x01, 0xFC, 0x7E, 0xF8, 0x07, 0xFF, 0xE7, 0xC0, 0x1F, 0xFE,
  0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 43, 35, 11, -43 },
  { 77, 20, 18, 35, 11, -43 },
  { 122, 35, 43, 35, 1, -43 },
  { 311, 31, 59, 35, 3, -51 },
  { 540, 41, 43, 35, -2, -43 },
  { 761, 33, 45, 35, 1, -44 },
  { 947, 7, 18, 35, 17, -43 },
  { 963, 25, 57, 35, 9, -50 },
  { 1142, 24, 57, 35, 3, -50 },
  { 1313, 31, 30, 35, 3, -36 },
  { 1430, 28, 27, 35, 4, -33 },
  { 1525, 15, 18, 35, 6, -9 },
  { 1559, 20, 5, 35, 8, -22 },
  { 1572, 11, 10, 35, 10, -9 },
  { 1586, 35, 55, 35, 1, -49 },
  { 1827, 31, 45, 35, 3, -44 },
  { 2002, 27, 43, 35, 3, -43 },
  { 2148, 30, 44, 35, 3, -44 },
  { 2313, 30, 44, 35, 3, -43 },
  { 2478, 28, 43, 35, 4, -43 },
  { 2629, 29, 44, 35, 4, -43 },
  { 2789, 29, 44, 35, 3, -43 },
  { 2949, 29, 43, 35, 7, -43 },
  { 3105, 30, 45, 35, 3, -44 },
  { 3274, 29, 44, 35, 5, -44 },
  { 3434, 15, 34, 35, 10, -33 },
  { 3498, 19, 42, 35, 6, -33 },
  { 3598, 28, 31, 35, 5, -35 },
  { 3707, 28, 19, 35, 4, -29 },
  { 3774, 28, 31, 35, 3, -35 },
  { 3883, 24, 43, 35, 8, -43 },
  { 4012, 36, 55, 35, 0, -44 },
  { 4260, 30, 43, 35, 0, -43 },
  { 4422, 31, 43, 35, 3, -43 },
  { 4589, 30, 45, 35, 4, -44 },
  { 4758, 30, 43, 35, 3, -43 },
  { 4920, 32, 43, 35, 3, -43 },
  { 5092, 32, 43, 35, 3, -43 },
  { 5264, 30, 45, 35, 4, -44 },
  { 5433, 31, 43, 35, 3, -43 },
  { 5600, 29, 43, 35, 4, -43 },
  { 5756, 32, 44, 35, 1, -43 },
  { 5932, 34, 43, 35, 3, -43 },
  { 6115, 26, 43, 35, 4, -43 },
  { 6255, 33, 43, 35, 2, -43 },
  { 6433, 31, 43, 35, 3, -43 },
  { 6600, 29, 45, 35, 4, -44 },
  { 6764, 32, 43, 35, 3, -43 },
  { 6936, 31, 55, 35, 3, -44 },
  { 7150, 31, 43, 35, 3, -43 },
  { 7317, 31, 45, 35, 3, -44 },
  { 7492, 29, 43, 35, 7, -43 },
  { 7648, 30, 44, 35, 4, -43 },
  { 7813, 30, 43, 35, 7, -43 },
  { 7975, 34, 43, 35, 4, -43 },
  { 8158, 37, 43, 35, 0, -43 },
  { 8357, 32, 43, 35, 6, -43 },
  { 8529, 32, 43, 35, 2, -43 },
  { 8701, 24, 55, 35, 8, -49 },
  { 8866, 17, 55, 35, 10, -49 },
  { 8983, 23, 55, 35, 5, -49 },
  { 9142, 26, 23, 35, 5, -43 },
  { 9217, 29, 5, 35, 0, 1 },
  { 9236, 10, 8, 35, 16, -46 },
  { 9246, 29, 34, 35, 4, -33 },
  { 9370, 29, 44, 35, 3, -43 },
  { 9530, 28, 34, 35, 4, -33 },
  { 9649, 30, 44, 35, 4, -43 },
  { 9814, 28, 34, 35, 4, -33 },
  { 9933, 41, 54, 35, -3, -43 },
  { 10210, 29, 44, 35, 4, -33 },
  { 10370, 29, 43, 35, 3, -43 },
  { 10526, 29, 46, 35, 2, -46 },
  { 10693, 30, 57, 35, 1, -46 },
  { 10907, 32, 43, 35, 3, -43 },
  { 11079, 25, 43, 35, 6, -43 },
  { 11214, 32, 33, 35, 1, -33 },
  { 11346, 29, 33, 35, 3, -33 },
  { 11466, 28, 34, 35, 4, -33 },
  { 11585, 31, 44, 35, 1, -33 },
  { 11756, 29, 44, 35, 4, -33 },
  { 11916, 29, 33, 35, 4, -33 },
  { 12036, 28, 34, 35, 3, -33 },
  { 12155, 28, 41, 35, 5, -41 },
  { 12299, 29, 33, 35, 4, -32 },
  { 12419, 28, 32, 35, 6, -32 },
  { 12531, 31, 32, 35, 5, -32 },
  { 12655, 33, 32, 35, 1, -32 },
  { 12787, 29, 43, 35, 4, -32 },
  { 12943, 29, 32, 35, 3, -32 },
  { 13059, 31, 55, 35, 5, -49 },
  { 13273, 14, 55, 35, 11, -49 },
  { 13370, 31, 55, 35, 1, -49 },
  { 13584, 29, 12, 35, 4, -27 },
};

const GFXfont JetBrainsMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_ITALIC59PT7B_H_
