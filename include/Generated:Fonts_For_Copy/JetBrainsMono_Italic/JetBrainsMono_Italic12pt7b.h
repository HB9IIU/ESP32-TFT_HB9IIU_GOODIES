#ifndef _JETBRAINSMONO_ITALIC12PT7B_H_
#define _JETBRAINSMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x80, 0xC0, 0x5D, 0x99, 0x12, 0x24, 0x53, 0x72, 0x45,
  0x3F, 0x24, 0xD0, 0x10, 0xE5, 0xD4, 0x61, 0xC2, 0x8A, 0xAB, 0xC2, 0x10,
  0x31, 0x52, 0x54, 0x78, 0x10, 0x1E, 0x32, 0x52, 0x8C, 0x1C, 0x48, 0x81,
  0x07, 0x2A, 0x93, 0x44, 0x74, 0x5E, 0x19, 0x10, 0x84, 0x42, 0x10, 0x86,
  0x18, 0x20, 0x61, 0x84, 0x21, 0x08, 0x42, 0x21, 0x31, 0x00, 0x12, 0x9D,
  0xC8, 0x52, 0x60, 0x10, 0x82, 0x7E, 0x20, 0x80, 0x2D, 0x40, 0xF0, 0x70,
  0x02, 0x0C, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x39, 0x3C,
  0x61, 0xAA, 0x28, 0xA2, 0xF0, 0x13, 0xA4, 0x21, 0x18, 0x84, 0xF8, 0x39,
  0x38, 0x42, 0x18, 0xC6, 0x30, 0xF8, 0x7C, 0x21, 0x08, 0x18, 0x20, 0xA2,
  0xF0, 0x08, 0x8C, 0x44, 0xC7, 0xE1, 0x18, 0x7D, 0x04, 0x1C, 0xC8, 0x20,
  0xA2, 0xF0, 0x18, 0x88, 0x8F, 0xC6, 0x31, 0xF0, 0x7D, 0x1C, 0x82, 0x10,
  0x42, 0x08, 0x40, 0x39, 0x34, 0xD2, 0x33, 0x28, 0xA2, 0xF0, 0x39, 0x38,
  0x61, 0xC9, 0xE1, 0x08, 0x40, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x64,
  0x80, 0x0C, 0xCC, 0x30, 0x30, 0x60, 0xFC, 0x00, 0x3E, 0xC1, 0x86, 0x36,
  0x40, 0xE0, 0x84, 0x26, 0x22, 0x00, 0xC0, 0x1C, 0x45, 0x0A, 0x75, 0x2A,
  0x64, 0xCE, 0x81, 0x01, 0xC0, 0x08, 0x61, 0x89, 0x24, 0x97, 0xD1, 0x84,
  0x79, 0x34, 0x72, 0xF2, 0x28, 0xA2, 0xF0, 0x39, 0x34, 0x60, 0x82, 0x08,
  0x22, 0xF0, 0x79, 0x24, 0x72, 0x8A, 0x28, 0xA6, 0xF0, 0x7D, 0x04, 0x10,
  0xFA, 0x08, 0x20, 0xF8, 0x7D, 0x04, 0x30, 0xFA, 0x08, 0x20, 0x80, 0x39,
  0x34, 0x60, 0x82, 0xE8, 0xA2, 0xF0, 0x45, 0x14, 0x72, 0xFA, 0x28, 0xA2,
  0x98, 0x7C, 0x41, 0x08, 0x20, 0x82, 0x08, 0xF8, 0x0E, 0x24, 0x10, 0x20,
  0x40, 0xA1, 0x64, 0x78, 0x45, 0x34, 0xB4, 0xF2, 0x49, 0x26, 0x88, 0x42,
  0x10, 0x84, 0x42, 0x10, 0xF8, 0x22, 0xCD, 0x5A, 0xD5, 0xC8, 0x91, 0x22,
  0xC4, 0x45, 0x96, 0x6A, 0xAA, 0xA9, 0xA6, 0x98, 0x39, 0x34, 0x62, 0x8A,
  0x28, 0xA2, 0xF0, 0x79, 0x14, 0x71, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x3C,
  0x63, 0x8A, 0x28, 0xA2, 0xF0, 0xC1, 0x00, 0x79, 0x34, 0x71, 0xFA, 0x49,
  0x26, 0x88, 0x39, 0x34, 0x10, 0x70, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x45, 0x14, 0x72, 0x8A, 0x28, 0xA2, 0xF0, 0xC5,
  0x14, 0xD2, 0x49, 0x45, 0x18, 0x60, 0x93, 0x2A, 0xD5, 0xAB, 0x5B, 0x36,
  0x6C, 0x90, 0x62, 0x4C, 0xD0, 0xC1, 0x07, 0x0A, 0x26, 0xC4, 0x86, 0x89,
  0x22, 0xC3, 0x04, 0x08, 0x10, 0x20, 0x3E, 0x0C, 0x10, 0x41, 0x06, 0x08,
  0x20, 0xFC, 0x74, 0x44, 0x44, 0xC8, 0x88, 0xE0, 0x88, 0xC4, 0x44, 0x42,
  0x22, 0x30, 0x38, 0xC4, 0x21, 0x08, 0x42, 0x21, 0x38, 0x11, 0x8A, 0x98,
  0x80, 0xFC, 0xC0, 0x35, 0x28, 0xA2, 0x8A, 0x2F, 0x80, 0x42, 0x1D, 0x98,
  0xC6, 0x31, 0xF0, 0x31, 0x28, 0xA0, 0x82, 0x2F, 0x00, 0x04, 0x13, 0x52,
  0x8A, 0x28, 0xA2, 0xF8, 0x32, 0x63, 0xF8, 0x47, 0xC0, 0x07, 0x86, 0x02,
  0x07, 0xE0, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x3C, 0x00, 0x35, 0x28,
  0xA2, 0x8B, 0x66, 0x84, 0xF0, 0x42, 0x1F, 0x98, 0xC6, 0x31, 0x88, 0x08,
  0x03, 0x82, 0x18, 0x41, 0x04, 0xFC, 0x04, 0x03, 0xC3, 0x08, 0x20, 0x82,
  0x08, 0x4F, 0x00, 0x41, 0x04, 0x72, 0x93, 0x89, 0x24, 0x88, 0xE1, 0x08,
  0x42, 0x31, 0x08, 0x38, 0x74, 0xB5, 0x4A, 0xA5, 0x4A, 0xA5, 0x00, 0x7E,
  0x63, 0x18, 0xC6, 0x20, 0x32, 0x63, 0x18, 0xC7, 0xC0, 0x3D, 0x94, 0x51,
  0x45, 0x17, 0xB0, 0x80, 0x35, 0x28, 0xA2, 0x8A, 0x6E, 0x84, 0x10, 0x79,
  0x34, 0xE0, 0x82, 0x08, 0x00, 0x3A, 0x60, 0xE0, 0xC7, 0xC0, 0x23, 0xF2,
  0x08, 0x21, 0x04, 0x0E, 0x47, 0x28, 0xA2, 0x8A, 0x2F, 0x00, 0x86, 0x24,
  0x94, 0x51, 0xC6, 0x00, 0x96, 0xDB, 0x76, 0xDB, 0x69, 0x00, 0x62, 0x48,
  0xE0, 0x82, 0x8D, 0x31, 0x00, 0x47, 0x28, 0xA2, 0x8B, 0x66, 0x84, 0xF0,
  0x7C, 0x21, 0x08, 0x42, 0x0F, 0x80, 0x0C, 0x41, 0x04, 0x13, 0x83, 0x08,
  0x20, 0x83, 0x80, 0x24, 0x94, 0x92, 0x4B, 0x00, 0x30, 0x61, 0x04, 0x10,
  0x71, 0x0C, 0x20, 0x8E, 0x00, 0xE6, 0x60,
};

const GFXglyph JetBrainsMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 12, 7, 1, -10 },
  { 24, 8, 9, 7, 0, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 7, 3, -9 },
  { 42, 5, 12, 7, 2, -10 },
  { 50, 5, 12, 7, 1, -10 },
  { 58, 6, 6, 7, 1, -7 },
  { 63, 6, 6, 7, 1, -7 },
  { 68, 3, 4, 7, 1, -2 },
  { 70, 4, 1, 7, 2, -4 },
  { 71, 2, 2, 7, 2, -2 },
  { 72, 7, 11, 7, 0, -10 },
  { 82, 6, 9, 7, 1, -9 },
  { 89, 5, 9, 7, 1, -9 },
  { 95, 6, 9, 7, 1, -9 },
  { 102, 6, 9, 7, 1, -9 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 6, 9, 7, 1, -9 },
  { 122, 5, 9, 7, 1, -9 },
  { 128, 6, 9, 7, 1, -9 },
  { 135, 6, 9, 7, 1, -9 },
  { 142, 6, 9, 7, 1, -9 },
  { 149, 3, 7, 7, 2, -7 },
  { 152, 4, 9, 7, 1, -7 },
  { 157, 6, 6, 7, 1, -7 },
  { 162, 6, 4, 7, 1, -6 },
  { 165, 5, 6, 7, 1, -7 },
  { 169, 5, 9, 7, 2, -9 },
  { 175, 7, 11, 7, 0, -9 },
  { 185, 6, 9, 7, 0, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 6, 9, 7, 1, -9 },
  { 206, 6, 9, 7, 1, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 6, 9, 7, 1, -9 },
  { 234, 6, 9, 7, 1, -9 },
  { 241, 6, 9, 7, 1, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 6, 9, 7, 1, -9 },
  { 263, 5, 9, 7, 1, -9 },
  { 269, 7, 9, 7, 0, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 6, 9, 7, 1, -9 },
  { 298, 6, 11, 7, 1, -9 },
  { 307, 6, 9, 7, 1, -9 },
  { 314, 6, 9, 7, 1, -9 },
  { 321, 6, 9, 7, 1, -9 },
  { 328, 6, 9, 7, 1, -9 },
  { 335, 6, 9, 7, 1, -9 },
  { 342, 7, 9, 7, 1, -9 },
  { 350, 7, 9, 7, 0, -9 },
  { 358, 7, 9, 7, 1, -9 },
  { 366, 7, 9, 7, 0, -9 },
  { 374, 4, 11, 7, 2, -10 },
  { 380, 4, 11, 7, 2, -10 },
  { 386, 5, 11, 7, 1, -10 },
  { 393, 5, 5, 7, 1, -9 },
  { 397, 6, 1, 7, 0, 0 },
  { 398, 2, 1, 7, 3, -9 },
  { 399, 6, 7, 7, 1, -7 },
  { 405, 5, 9, 7, 1, -9 },
  { 411, 6, 7, 7, 1, -7 },
  { 417, 6, 9, 7, 1, -9 },
  { 424, 5, 7, 7, 1, -7 },
  { 429, 9, 11, 7, -1, -9 },
  { 442, 6, 9, 7, 1, -7 },
  { 449, 5, 9, 7, 1, -9 },
  { 455, 6, 9, 7, 0, -9 },
  { 462, 6, 11, 7, 0, -9 },
  { 471, 6, 9, 7, 1, -9 },
  { 478, 5, 9, 7, 1, -9 },
  { 484, 7, 7, 7, 0, -7 },
  { 491, 5, 7, 7, 1, -7 },
  { 496, 5, 7, 7, 1, -7 },
  { 501, 6, 9, 7, 0, -7 },
  { 508, 6, 9, 7, 1, -7 },
  { 515, 6, 7, 7, 1, -7 },
  { 521, 5, 7, 7, 1, -7 },
  { 526, 6, 8, 7, 1, -8 },
  { 532, 6, 7, 7, 1, -7 },
  { 538, 6, 7, 7, 1, -7 },
  { 544, 6, 7, 7, 1, -7 },
  { 550, 7, 7, 7, 0, -7 },
  { 557, 6, 9, 7, 1, -7 },
  { 564, 6, 7, 7, 1, -7 },
  { 570, 6, 11, 7, 1, -10 },
  { 579, 3, 11, 7, 2, -10 },
  { 584, 6, 11, 7, 0, -10 },
  { 593, 6, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_ITALIC12PT7B_H_
