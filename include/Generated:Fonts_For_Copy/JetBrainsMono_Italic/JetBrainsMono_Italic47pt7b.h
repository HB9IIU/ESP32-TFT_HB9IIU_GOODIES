#ifndef _JETBRAINSMONO_ITALIC47PT7B_H_
#define _JETBRAINSMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x80,
  0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x0F, 0x01, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0xEF, 0xC0, 0x78, 0x63,
  0xE0, 0x7C, 0x70, 0xF0, 0x3C, 0x38, 0x78, 0x3E, 0x1C, 0x3C, 0x1F, 0x0E,
  0x00, 0x0F, 0x87, 0x00, 0x07, 0xC3, 0x00, 0x03, 0xE3, 0x80, 0x01, 0xF9,
  0xC0, 0x00, 0x7E, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x7E, 0x00,
  0x03, 0x9F, 0x80, 0x01, 0xC7, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x1F,
  0x0F, 0x87, 0x1F, 0x07, 0xC3, 0x1F, 0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0xFE, 0x00,
  0x0E, 0x03, 0xFF, 0x00, 0x1C, 0x07, 0xFF, 0x80, 0x3C, 0x07, 0x87, 0x80,
  0x78, 0x0F, 0x03, 0x80, 0xF0, 0x0F, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x87, 0x80, 0x0E, 0x07, 0x8F,
  0x00, 0x0E, 0x07, 0x1E, 0x00, 0x0F, 0x0F, 0x3C, 0x00, 0x0F, 0xFE, 0x38,
  0x00, 0x07, 0xFC, 0x70, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x02,
  0x00, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x1C, 0x7F, 0xE0, 0x00, 0x3C, 0xFF,
  0xF0, 0x00, 0x79, 0xE0, 0xF0, 0x00, 0xF1, 0xE0, 0xF0, 0x00, 0xE1, 0xC0,
  0xF0, 0x01, 0xC1, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0xF0, 0x07, 0x83, 0xC0,
  0xE0, 0x0F, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x1C, 0x03, 0xC3,
  0xE0, 0x38, 0x01, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0x80, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF3, 0xC0, 0x7C, 0xF8, 0xF8, 0x1E, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0xC7,
  0xC7, 0xC0, 0xF3, 0xE1, 0xF0, 0x3E, 0xF0, 0x78, 0x07, 0xF8, 0x1E, 0x01,
  0xFE, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xF0, 0x1E,
  0x01, 0xFC, 0x07, 0x80, 0xFF, 0x81, 0xF8, 0xFD, 0xF0, 0x7F, 0xFE, 0x7C,
  0x0F, 0xFF, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0x3E, 0x79, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x1C, 0x03, 0x3E,
  0x0E, 0x0F, 0xBF, 0xC7, 0x1F, 0xFF, 0xF3, 0x3F, 0xE7, 0xFD, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x18, 0x01,
  0x80, 0x04, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x3F, 0x9F, 0xEF, 0xE7,
  0xF3, 0xF9, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7E, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x7C,
  0x3C, 0x78, 0x10, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x0F,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF3, 0xC0,
  0x1F, 0x8F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0xC0, 0x20,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC1, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0x78,
  0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x30,
  0x01, 0xE7, 0xFC, 0x03, 0xDF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xE1, 0xFC,
  0x3F, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFB, 0xFC, 0x01, 0xEF, 0xFC, 0x07,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03,
  0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x07,
  0xC0, 0x7C, 0x03, 0xE1, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0x81, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0x80,
  0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1F,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xFF, 0x7F, 0xC1,
  0xFF, 0xFF, 0x00, 0xFF, 0xBE, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x78, 0xF1, 0xE0, 0x1F, 0xEF, 0x1E,
  0x03, 0xFE, 0xE1, 0xE0, 0x7C, 0x3E, 0x1E, 0x0F, 0x81, 0xE1, 0xE0, 0xF0,
  0x1E, 0x1C, 0x0F, 0x01, 0xE3, 0xC0, 0xE0, 0x1E, 0x3C, 0x1E, 0x01, 0xE3,
  0xC1, 0xE0, 0x1C, 0x3C, 0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x38, 0x1E,
  0x03, 0xC3, 0x81, 0xC0, 0x3C, 0x78, 0x1C, 0x03, 0xC7, 0x81, 0xE0, 0x78,
  0x78, 0x1E, 0x0F, 0x87, 0x81, 0xFF, 0xB8, 0x78, 0x1F, 0xFB, 0x87, 0x00,
  0xFE, 0x78, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x78, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0x9F, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x83, 0xFE, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x07,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x1F, 0xFC,
  0x3C, 0x1F, 0xFC, 0x7C, 0x3F, 0xFC, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x7F, 0x9F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E,
  0x0F, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xB8, 0x07, 0xE0, 0x77,
  0x01, 0xFC, 0x0E, 0xE0, 0x3B, 0x81, 0xDC, 0x0F, 0x70, 0x3B, 0xC1, 0xDE,
  0x07, 0x78, 0x7B, 0xC1, 0xE7, 0x0E, 0x70, 0x3C, 0xE3, 0xCE, 0x07, 0x9C,
  0x73, 0xC0, 0xF3, 0x9E, 0x78, 0x1E, 0x7B, 0x8F, 0x03, 0x87, 0x71, 0xE0,
  0xF0, 0xFC, 0x3C, 0x1E, 0x1F, 0x8F, 0x03, 0xC3, 0xE1, 0xE0, 0x78, 0x7C,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0x83, 0xF8, 0x03, 0xC1, 0xFC,
  0x01, 0xE0, 0xFE, 0x00, 0xF0, 0x7F, 0x00, 0xF8, 0x3B, 0x80, 0x78, 0x1D,
  0xE0, 0x3C, 0x1E, 0xF0, 0x1E, 0x0F, 0x78, 0x0F, 0x07, 0xBC, 0x07, 0x83,
  0xCE, 0x03, 0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC1, 0xE0, 0xF9, 0xE0, 0xF0,
  0x78, 0xF0, 0x78, 0x3C, 0x38, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F,
  0x07, 0x87, 0x8F, 0x07, 0xC3, 0xC7, 0x83, 0xC0, 0xE3, 0xC1, 0xE0, 0x79,
  0xE0, 0xF0, 0x3C, 0xF0, 0x78, 0x1E, 0x78, 0x3C, 0x0F, 0x78, 0x3E, 0x03,
  0xBC, 0x1E, 0x01, 0xFE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0xC0,
  0x3F, 0xC1, 0xE0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x78,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F,
  0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x3F, 0xCF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x78, 0x01, 0xF8,
  0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3C, 0x03, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE0,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7F, 0x1F, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0,
  0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x0F, 0x81, 0xEF, 0x01, 0xF0, 0x3D, 0xE0, 0x3E, 0x07, 0xBC, 0x0F, 0xC0,
  0xE7, 0x81, 0xF8, 0x3C, 0xF0, 0x37, 0x07, 0x9E, 0x0E, 0xC0, 0xF3, 0xC1,
  0xD8, 0x3C, 0x78, 0x3B, 0x07, 0x8F, 0x06, 0x60, 0xF1, 0xE1, 0xCC, 0x1C,
  0x3C, 0x39, 0x87, 0x87, 0x86, 0x30, 0xF0, 0xF1, 0xC6, 0x1E, 0x1E, 0x39,
  0xC3, 0x83, 0xC7, 0x38, 0xF0, 0x78, 0xC7, 0x1E, 0x0E, 0x38, 0xE3, 0xC1,
  0xC7, 0x1C, 0x70, 0x38, 0xC3, 0x9E, 0x07, 0x38, 0x73, 0xC0, 0xE7, 0x0E,
  0x70, 0x1C, 0xE1, 0xDE, 0x07, 0x98, 0x3B, 0xC0, 0xF7, 0x07, 0x78, 0x1E,
  0xE0, 0xEE, 0x03, 0xD8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0D, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80,
  0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0x38, 0x00, 0x79, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1,
  0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x0F,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0x77, 0x80, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xFE, 0x1E,
  0x07, 0xFF, 0x3C, 0x1F, 0xFE, 0xF8, 0x7F, 0xBF, 0xE1, 0xF8, 0x0F, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80, 0xFE,
  0x1F, 0xC7, 0xF8, 0x3F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F, 0xE3, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x8F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7B, 0xCF, 0xE0, 0xFC,
  0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F,
  0xC0, 0x3E, 0x1F, 0xE3, 0xF8, 0x3D, 0xFF, 0xE0, 0xFB, 0xFF, 0x81, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xBF, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x13, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x87,
  0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0xE7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x1E, 0x03, 0xFF, 0x9E, 0x07,
  0xFF, 0xBE, 0x0F, 0xF7, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7F,
  0x1F, 0xE0, 0x7F, 0xFD, 0xE0, 0x3F, 0xF9, 0xE0, 0x1F, 0xF1, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0x00,
  0xF8, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x1E, 0x07, 0xFF, 0x3C, 0x1F, 0xFF, 0xF8, 0x7F, 0xBF, 0xE1, 0xF8,
  0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0,
  0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xF9, 0xEF, 0x07,
  0xFF, 0xBE, 0x07, 0xFF, 0x78, 0x07, 0xF8, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x8F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7F, 0x8F, 0xE0,
  0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0x3E, 0x3F, 0x03, 0xDF, 0xDF, 0xE0, 0xEF, 0xF7, 0xF8, 0x3C, 0x3E,
  0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x81, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0x81, 0xE3, 0xC0, 0xE0, 0x70,
  0xF0, 0x38, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF0, 0x70, 0x3C, 0x38, 0x1C, 0x0F, 0x1E, 0x07, 0x07, 0x87, 0x81,
  0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0E, 0x07, 0x87,
  0x83, 0x81, 0xE3, 0xC0, 0xE0, 0x70, 0xF0, 0x38, 0x3C, 0x3C, 0x1E, 0x0F,
  0x00, 0x0F, 0x8F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7F, 0x8F,
  0xE0, 0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3,
  0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFD, 0xFE, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3E,
  0x78, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0x78,
  0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC7, 0xF0, 0x07, 0x9F, 0xFC, 0x07, 0xBF,
  0xFE, 0x07, 0xFC, 0xFE, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3F, 0x00, 0xF8, 0x3F, 0xC3,
  0xF0, 0x3D, 0xFF, 0xE0, 0x7D, 0xFF, 0xC0, 0x7C, 0x7F, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x1E, 0x07, 0xFF, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xBF, 0xE1, 0xF8, 0x0F,
  0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80,
  0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F, 0xE3,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0x1F, 0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7F, 0x8F, 0xE0,
  0xFC, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xF8, 0xFE, 0x1F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80,
  0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x3E,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xB8, 0x1F, 0x03, 0xDC, 0x0F,
  0x81, 0xEE, 0x06, 0xC0, 0xE7, 0x07, 0x60, 0xF3, 0x83, 0xB0, 0x79, 0xC1,
  0x98, 0x38, 0xE1, 0xCC, 0x3C, 0x70, 0xE6, 0x1E, 0x38, 0x63, 0x0E, 0x1C,
  0x71, 0x87, 0x0E, 0x38, 0xC7, 0x87, 0x18, 0x63, 0x83, 0x9C, 0x31, 0xC1,
  0xCE, 0x19, 0xE0, 0xE6, 0x0C, 0xE0, 0x77, 0x06, 0x70, 0x3B, 0x83, 0x78,
  0x1D, 0x81, 0xB8, 0x0E, 0xC0, 0xDC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0xEF,
  0x07, 0xFF, 0xBE, 0x07, 0xFE, 0x78, 0x03, 0xF8, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1E, 0x3F, 0xE0, 0x3C,
  0xFF, 0xE0, 0x7B, 0xE7, 0xC0, 0xF7, 0x87, 0xC3, 0xFE, 0x07, 0xCF, 0xBC,
  0x07, 0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 34, 28, 9, -34 },
  { 48, 16, 14, 28, 9, -34 },
  { 76, 27, 34, 28, 1, -34 },
  { 191, 25, 48, 28, 2, -41 },
  { 341, 32, 35, 28, -1, -35 },
  { 481, 26, 35, 28, 1, -35 },
  { 595, 7, 14, 28, 13, -34 },
  { 608, 20, 46, 28, 7, -40 },
  { 723, 20, 46, 28, 2, -40 },
  { 838, 25, 25, 28, 2, -29 },
  { 917, 23, 23, 28, 3, -27 },
  { 984, 13, 15, 28, 4, -7 },
  { 1009, 15, 3, 28, 7, -17 },
  { 1015, 9, 7, 28, 8, -7 },
  { 1023, 28, 44, 28, 1, -39 },
  { 1177, 24, 35, 28, 3, -35 },
  { 1282, 22, 34, 28, 2, -34 },
  { 1376, 25, 35, 28, 2, -35 },
  { 1486, 24, 34, 28, 2, -34 },
  { 1588, 22, 34, 28, 3, -34 },
  { 1682, 23, 34, 28, 3, -34 },
  { 1780, 23, 34, 28, 2, -34 },
  { 1878, 23, 34, 28, 6, -34 },
  { 1976, 24, 35, 28, 2, -35 },
  { 2081, 23, 35, 28, 4, -35 },
  { 2182, 12, 26, 28, 8, -26 },
  { 2221, 15, 34, 28, 5, -26 },
  { 2285, 23, 25, 28, 4, -28 },
  { 2357, 23, 15, 28, 3, -23 },
  { 2401, 23, 25, 28, 2, -28 },
  { 2473, 19, 34, 28, 7, -34 },
  { 2554, 28, 43, 28, 0, -35 },
  { 2705, 24, 34, 28, 0, -34 },
  { 2807, 25, 34, 28, 2, -34 },
  { 2914, 24, 35, 28, 3, -35 },
  { 3019, 24, 34, 28, 2, -34 },
  { 3121, 25, 34, 28, 3, -34 },
  { 3228, 26, 34, 28, 2, -34 },
  { 3339, 24, 35, 28, 3, -35 },
  { 3444, 25, 34, 28, 2, -34 },
  { 3551, 24, 34, 28, 3, -34 },
  { 3653, 26, 34, 28, 1, -34 },
  { 3764, 27, 34, 28, 2, -34 },
  { 3879, 21, 34, 28, 3, -34 },
  { 3969, 27, 34, 28, 1, -34 },
  { 4084, 25, 34, 28, 2, -34 },
  { 4191, 23, 35, 28, 3, -35 },
  { 4292, 26, 34, 28, 2, -34 },
  { 4403, 24, 43, 28, 3, -35 },
  { 4532, 25, 34, 28, 2, -34 },
  { 4639, 25, 35, 28, 2, -35 },
  { 4749, 24, 34, 28, 5, -34 },
  { 4851, 24, 34, 28, 3, -34 },
  { 4953, 23, 34, 28, 6, -34 },
  { 5051, 27, 34, 28, 3, -34 },
  { 5166, 29, 34, 28, 0, -34 },
  { 5290, 25, 34, 28, 5, -34 },
  { 5397, 25, 34, 28, 2, -34 },
  { 5504, 18, 44, 28, 7, -39 },
  { 5603, 14, 44, 28, 8, -39 },
  { 5680, 19, 44, 28, 4, -39 },
  { 5785, 21, 18, 28, 4, -34 },
  { 5833, 23, 4, 28, 0, 1 },
  { 5845, 9, 7, 28, 12, -37 },
  { 5853, 23, 26, 28, 3, -26 },
  { 5928, 23, 34, 28, 2, -34 },
  { 6026, 23, 26, 28, 3, -26 },
  { 6101, 24, 34, 28, 3, -34 },
  { 6203, 22, 26, 28, 3, -26 },
  { 6275, 32, 42, 28, -2, -34 },
  { 6443, 23, 34, 28, 3, -26 },
  { 6541, 23, 34, 28, 2, -34 },
  { 6639, 22, 37, 28, 2, -37 },
  { 6741, 24, 45, 28, 1, -37 },
  { 6876, 26, 34, 28, 2, -34 },
  { 6987, 19, 34, 28, 5, -34 },
  { 7068, 26, 26, 28, 1, -26 },
  { 7153, 23, 26, 28, 2, -26 },
  { 7228, 22, 26, 28, 3, -26 },
  { 7300, 24, 34, 28, 1, -26 },
  { 7402, 23, 34, 28, 3, -26 },
  { 7500, 23, 26, 28, 3, -26 },
  { 7575, 22, 26, 28, 3, -26 },
  { 7647, 22, 33, 28, 4, -33 },
  { 7738, 23, 26, 28, 3, -26 },
  { 7813, 22, 26, 28, 5, -26 },
  { 7885, 25, 26, 28, 4, -26 },
  { 7967, 26, 26, 28, 1, -26 },
  { 8052, 23, 34, 28, 3, -26 },
  { 8150, 23, 26, 28, 2, -26 },
  { 8225, 24, 44, 28, 4, -39 },
  { 8357, 11, 44, 28, 9, -39 },
  { 8418, 24, 44, 28, 1, -39 },
  { 8550, 23, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_ITALIC47PT7B_H_
