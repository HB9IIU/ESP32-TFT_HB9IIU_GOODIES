#ifndef _JETBRAINSMONO_ITALIC32PT7B_H_
#define _JETBRAINSMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0,
  0x71, 0xEE, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x0E, 0x01, 0x83,
  0x00, 0xE0, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x0E, 0x01, 0x83, 0x80,
  0xE0, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x83, 0x83, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0C, 0x1C, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0xE0,
  0x18, 0x30, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x1E, 0x6F, 0x0E, 0x63,
  0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x01, 0xC6, 0x00, 0xF3, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x37, 0x80, 0x19, 0xC0,
  0x0C, 0x70, 0x0C, 0x39, 0xC6, 0x38, 0xE3, 0x1C, 0x71, 0x9E, 0x3E, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x04, 0x1F, 0x80, 0x60, 0xFF, 0x03, 0x87, 0x0C, 0x1C,
  0x1C, 0x30, 0xE0, 0x60, 0xC3, 0x01, 0x87, 0x18, 0x06, 0x1C, 0xC0, 0x18,
  0x66, 0x00, 0x7F, 0xB8, 0x00, 0xF9, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x0C, 0xFC, 0x00, 0x77, 0xF8, 0x03, 0x98, 0x60,
  0x1C, 0xE1, 0x80, 0x63, 0x86, 0x03, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0xE0,
  0xE3, 0x07, 0x03, 0xFC, 0x38, 0x07, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x3B, 0x8E,
  0x1D, 0xC7, 0x1C, 0xE1, 0xDC, 0x60, 0xEC, 0x70, 0x3E, 0x38, 0x1E, 0x1C,
  0x0F, 0x0E, 0x0F, 0xC7, 0x8F, 0xE1, 0xFF, 0x38, 0x7E, 0x1E, 0x77, 0x77,
  0xFE, 0xEE, 0xE0, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x1B, 0xE6, 0x3D,
  0xFB, 0x7F, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xDC, 0x01, 0xCE,
  0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xE0, 0x70, 0x20, 0x20, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F,
  0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07,
  0x71, 0x86, 0x73, 0xCE, 0x73, 0xCE, 0x71, 0xCE, 0x60, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78, 0xF0,
  0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x1E, 0xE0, 0x79, 0xC1,
  0xC3, 0x83, 0x06, 0x04, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x38, 0xF8, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x39, 0xE0, 0x67, 0x81, 0xCE, 0x03,
  0xB8, 0x07, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3B, 0xF8,
  0x3F, 0xFC, 0x3E, 0x3C, 0x38, 0x1E, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x78, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x40, 0x3F, 0xF0, 0xFF,
  0xF3, 0xE1, 0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3B, 0x80, 0x77, 0x81, 0xC7, 0x8F, 0x8F, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x0E,
  0x1C, 0x0E, 0x1C, 0x1C, 0x0F, 0x78, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78,
  0x38, 0x3C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0xF8, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8,
  0x1F, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x7C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE0,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x7F, 0x87,
  0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x1E, 0x07, 0xC3, 0xF8, 0x3E, 0x03, 0x80, 0x38, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x18, 0x01, 0xC7,
  0x00, 0x18, 0xC0, 0x03, 0x38, 0x04, 0xE7, 0x07, 0xFC, 0xE1, 0xFF, 0x9C,
  0x70, 0x73, 0x0E, 0x0C, 0x61, 0x81, 0x8C, 0x30, 0x73, 0x86, 0x0E, 0x71,
  0xC1, 0xCE, 0x38, 0x39, 0x87, 0x06, 0x30, 0xE1, 0xC6, 0x0F, 0xD9, 0xC1,
  0xF3, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x6C, 0x00, 0xEC, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCE, 0x01,
  0xCE, 0x03, 0x8E, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0E, 0x0E,
  0x06, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C,
  0x1E, 0x18, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38,
  0x1E, 0x38, 0x7C, 0x3F, 0xF0, 0x7F, 0xF8, 0x70, 0x3C, 0x70, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x1E,
  0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1C, 0x1E, 0x1C,
  0x0E, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70,
  0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x1E,
  0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x71, 0xFE, 0x71, 0xFE, 0x71, 0xFE, 0x70,
  0x0E, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x07, 0x8F,
  0x83, 0xFF, 0x80, 0xFF, 0x00, 0x1C, 0x03, 0xC7, 0x01, 0xE1, 0xC0, 0x70,
  0x70, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x38,
  0x70, 0x0E, 0x38, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0F, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38, 0x1E, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xB0, 0x6C, 0x6C, 0x3E, 0x1B,
  0x0D, 0x86, 0xC7, 0x61, 0xB9, 0x98, 0xEE, 0x6E, 0x39, 0xB3, 0x8E, 0x6C,
  0xE3, 0x9E, 0x30, 0xE7, 0x9C, 0x31, 0xE7, 0x0C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC0, 0x0F, 0x01, 0xC3, 0xC0, 0x60, 0xF8,
  0x38, 0x3E, 0x0E, 0x1F, 0x83, 0x87, 0x60, 0xE1, 0xD8, 0x38, 0x77, 0x0C,
  0x1D, 0xC7, 0x06, 0x71, 0xC3, 0x8C, 0x70, 0xE3, 0x1C, 0x38, 0xE7, 0x0E,
  0x39, 0x83, 0x8E, 0xE0, 0xC1, 0xB8, 0x70, 0x6E, 0x1C, 0x1F, 0x87, 0x07,
  0xE1, 0xC1, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x0E, 0x03, 0xC0, 0x00, 0xF0,
  0x03, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x3C, 0xF0, 0x38, 0x78, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x87, 0x03, 0xC3, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x8C, 0x07, 0x8F, 0xFF, 0x87,
  0xFF, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0x03, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFE, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xE0, 0x60, 0x70, 0x70,
  0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x70,
  0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xF0, 0xE0, 0x38, 0x60,
  0x1C, 0x70, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0xE3, 0xE0, 0xFF,
  0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x60,
  0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1E, 0x07, 0x07, 0x8F, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x18, 0x60, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x33, 0x80,
  0x33, 0x00, 0x37, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x70, 0xE0, 0xEE, 0x1C, 0x19, 0xC2, 0x87, 0x38, 0xD0, 0xE7, 0x1E, 0x18,
  0xC3, 0xC3, 0x18, 0xD8, 0xE3, 0x1B, 0x1C, 0x63, 0x63, 0x0C, 0x4C, 0xE1,
  0x99, 0x9C, 0x33, 0x33, 0x06, 0x66, 0x61, 0xD8, 0xDC, 0x3B, 0x1B, 0x87,
  0x63, 0x60, 0xEC, 0x6C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x70, 0x1E,
  0x07, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x01, 0xCE,
  0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x73, 0xC0, 0x07,
  0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7,
  0x01, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70,
  0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x36, 0x01, 0xD8, 0x06, 0x70, 0x38, 0xC1, 0xC3, 0x06, 0x0E, 0x38, 0x39,
  0xC0, 0x67, 0x01, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xE3, 0x87,
  0x03, 0xC7, 0x0F, 0xF6, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x38, 0x78, 0xF8, 0x7F, 0xB8, 0x3F, 0x38,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x1E, 0x0E,
  0xFF, 0x1F, 0xFE, 0x3C, 0x1E, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x81, 0xCF, 0x8F, 0x9F, 0xFE, 0x3B, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xEE, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0xDC, 0x03, 0xBC, 0x0E,
  0x3C, 0x7C, 0x7F, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x38, 0x3F, 0xDC, 0x3F, 0xFC, 0x3C,
  0x1E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1,
  0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x07,
  0x07, 0x8F, 0x83, 0xFD, 0xC0, 0xFC, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xE0, 0xF3, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x7F, 0xFC,
  0xFF, 0xF9, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xBC, 0x0E, 0x3C,
  0x3C, 0x7F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC7, 0x0F, 0xF6, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x7C, 0x7F, 0xD8, 0x3F, 0xB8, 0x1F, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x1E,
  0x0E, 0xFF, 0x1F, 0xFE, 0x3C, 0x1E, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80,
  0x77, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x3C, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x1C,
  0x1C, 0x1C, 0x0C, 0x1C, 0x0E, 0x1E, 0x07, 0x1E, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0x70, 0xFF, 0x83, 0xFC, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x3B,
  0xCF, 0x1F, 0xEF, 0xCF, 0x7C, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0x86, 0x1C,
  0xC3, 0x0E, 0xE1, 0x86, 0x70, 0xC3, 0x38, 0xE3, 0x9C, 0x71, 0xCC, 0x30,
  0xE6, 0x18, 0x77, 0x0C, 0x33, 0x86, 0x19, 0xC7, 0x1C, 0xE3, 0x8E, 0x61,
  0x87, 0x00, 0x38, 0xF0, 0x77, 0xF8, 0xFF, 0xF1, 0xE0, 0xF3, 0x80, 0xEF,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x70,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0x80, 0x77, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0xBC, 0x0E, 0x3C, 0x78, 0x7F, 0xE0, 0x3F, 0x80, 0x1C, 0x78,
  0x1D, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x78, 0x1C, 0x7C, 0x7C, 0x7F, 0xF8, 0x67, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xC7,
  0x0F, 0xF6, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x3C, 0xF0, 0x38, 0x78, 0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x1C, 0xF8,
  0x1D, 0xFC, 0x1B, 0xFE, 0x3E, 0x0E, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x0E, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF9, 0xC0, 0x73, 0x80, 0xE7, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xB8, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x38, 0x78, 0xF0, 0x7F, 0xE0,
  0x1F, 0xC0, 0xE0, 0x07, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x70, 0x30, 0x70, 0x38, 0xE0, 0x38, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x39, 0x80, 0x1B, 0x80, 0x1B, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0xE1, 0xC1, 0xB0, 0xE0, 0xD8, 0x70, 0xEC, 0x28, 0x66, 0x34,
  0x33, 0x1A, 0x39, 0x89, 0x18, 0xCC, 0x8C, 0x66, 0x46, 0x32, 0x27, 0x1B,
  0x13, 0x0D, 0x89, 0x86, 0x85, 0xC3, 0xC2, 0xC1, 0xE1, 0x60, 0xF0, 0xF0,
  0x70, 0x70, 0x38, 0x38, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0x70, 0x78,
  0x1C, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x07, 0x38, 0x03, 0x87,
  0x01, 0xE1, 0xC0, 0xF0, 0x38, 0x38, 0x0E, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C,
  0x70, 0x7C, 0x7F, 0xD8, 0x3F, 0xB8, 0x0E, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x30,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x3F,
  0x07, 0x7F, 0x87, 0x73, 0x86, 0xE1, 0xFE, 0xE0, 0xFC, 0xE0, 0x78,
};

const GFXglyph JetBrainsMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 11, 9, 19, 6, -23 },
  { 37, 18, 23, 19, 1, -23 },
  { 89, 17, 32, 19, 1, -28 },
  { 157, 22, 24, 19, -1, -24 },
  { 223, 17, 24, 19, 1, -24 },
  { 274, 4, 9, 19, 9, -23 },
  { 279, 13, 31, 19, 5, -27 },
  { 330, 13, 31, 19, 2, -27 },
  { 381, 17, 17, 19, 2, -20 },
  { 418, 16, 15, 19, 2, -18 },
  { 448, 8, 10, 19, 3, -5 },
  { 458, 10, 3, 19, 5, -12 },
  { 462, 5, 5, 19, 6, -5 },
  { 466, 20, 31, 19, 0, -27 },
  { 544, 16, 24, 19, 2, -24 },
  { 592, 15, 23, 19, 1, -23 },
  { 636, 16, 24, 19, 2, -24 },
  { 684, 16, 23, 19, 2, -23 },
  { 730, 15, 23, 19, 2, -23 },
  { 774, 16, 23, 19, 2, -23 },
  { 820, 15, 23, 19, 2, -23 },
  { 864, 15, 23, 19, 4, -23 },
  { 908, 16, 24, 19, 2, -24 },
  { 956, 16, 24, 19, 3, -24 },
  { 1004, 7, 18, 19, 6, -18 },
  { 1020, 11, 23, 19, 3, -18 },
  { 1052, 15, 17, 19, 3, -19 },
  { 1084, 16, 11, 19, 2, -16 },
  { 1106, 15, 17, 19, 2, -19 },
  { 1138, 12, 23, 19, 5, -23 },
  { 1173, 19, 30, 19, 0, -24 },
  { 1245, 16, 23, 19, 0, -23 },
  { 1291, 16, 23, 19, 2, -23 },
  { 1337, 16, 24, 19, 2, -24 },
  { 1385, 16, 23, 19, 2, -23 },
  { 1431, 17, 23, 19, 2, -23 },
  { 1480, 17, 23, 19, 2, -23 },
  { 1529, 16, 24, 19, 2, -24 },
  { 1577, 17, 23, 19, 2, -23 },
  { 1626, 16, 23, 19, 2, -23 },
  { 1672, 17, 23, 19, 1, -23 },
  { 1721, 18, 23, 19, 2, -23 },
  { 1773, 14, 23, 19, 2, -23 },
  { 1814, 18, 23, 19, 1, -23 },
  { 1866, 18, 23, 19, 1, -23 },
  { 1918, 16, 24, 19, 2, -24 },
  { 1966, 17, 23, 19, 2, -23 },
  { 2015, 16, 30, 19, 2, -24 },
  { 2075, 17, 23, 19, 2, -23 },
  { 2124, 17, 24, 19, 1, -24 },
  { 2175, 16, 23, 19, 4, -23 },
  { 2221, 17, 23, 19, 2, -23 },
  { 2270, 16, 23, 19, 4, -23 },
  { 2316, 19, 23, 19, 2, -23 },
  { 2371, 20, 23, 19, 0, -23 },
  { 2429, 17, 23, 19, 3, -23 },
  { 2478, 17, 23, 19, 1, -23 },
  { 2527, 12, 31, 19, 5, -27 },
  { 2574, 10, 31, 19, 5, -27 },
  { 2613, 12, 31, 19, 3, -27 },
  { 2660, 14, 12, 19, 3, -23 },
  { 2681, 16, 2, 19, 0, 1 },
  { 2685, 6, 4, 19, 8, -25 },
  { 2688, 16, 18, 19, 2, -18 },
  { 2724, 15, 23, 19, 2, -23 },
  { 2768, 15, 18, 19, 2, -18 },
  { 2802, 17, 23, 19, 2, -23 },
  { 2851, 15, 18, 19, 2, -18 },
  { 2885, 22, 29, 19, -2, -23 },
  { 2965, 16, 24, 19, 2, -18 },
  { 3013, 15, 23, 19, 2, -23 },
  { 3057, 16, 25, 19, 1, -25 },
  { 3107, 17, 31, 19, 0, -25 },
  { 3173, 17, 23, 19, 2, -23 },
  { 3222, 14, 23, 19, 3, -23 },
  { 3263, 17, 18, 19, 1, -18 },
  { 3302, 15, 18, 19, 2, -18 },
  { 3336, 15, 18, 19, 2, -18 },
  { 3370, 16, 24, 19, 1, -18 },
  { 3418, 16, 24, 19, 2, -18 },
  { 3466, 16, 18, 19, 2, -18 },
  { 3502, 15, 18, 19, 2, -18 },
  { 3536, 15, 22, 19, 3, -22 },
  { 3578, 16, 18, 19, 2, -18 },
  { 3614, 16, 18, 19, 3, -18 },
  { 3650, 17, 18, 19, 2, -18 },
  { 3689, 18, 18, 19, 0, -18 },
  { 3730, 16, 24, 19, 2, -18 },
  { 3778, 16, 18, 19, 1, -18 },
  { 3814, 16, 31, 19, 3, -27 },
  { 3876, 8, 31, 19, 6, -27 },
  { 3907, 16, 31, 19, 1, -27 },
  { 3969, 16, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_ITALIC32PT7B_H_
